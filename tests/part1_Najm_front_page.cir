* SPICE netlist of Najm's book front page
V1 1 0 3

R1 1 2 450
Q1 4 2 0 Qmodel
C1 4 0 2e-12
R2 3 4 640
L1 6 3 1e-3
R3 3 5 10e3
C2 5 0 2e-12
M1 5 4 0 0 NMOS L=2e-6 W=8e-6
