* SPICE netlist of Part1-Parser.pdf

V1 5 0 2
V2 3 2 0.2
V3 7 6 2
I1 4 8 1e-3
I2 0 6 1e-3
R1 1 5 1.5
R2 1 2 1
R3 5 2 50
R4 5 6 0.1
R5 2 6 1.5
R6 3 4 0.1
R7 8 0 1e3
R8 4 0 10

.op
* .OPTIONS method=Cholesky
.DC V1 1 3 0.2
.DC V2 2 4 0.5
* .print DC V(4)
* .print DC V(2)
