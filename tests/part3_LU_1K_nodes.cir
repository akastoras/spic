* Resistive network with 1000 nodes

R1 N1 N2 675.48
R2 N2 N3 122.51
R3 N3 N4 347.53
R4 N4 N5 300.89
R5 N5 N6 762.82
R6 N6 N7 709.03
R7 N7 N8 902.96
R8 N8 N9 178.24
R9 N9 N10 479.73
R10 N10 N11 126.82
R11 N11 N12 296.77
R12 N12 N13 554.82
R13 N13 N14 123.88
R14 N14 N15 278.95
R15 N15 N16 684.90
R16 N16 N17 590.45
R17 N17 N18 298.40
R18 N18 N19 630.34
R19 N19 N20 828.49
R20 N20 N21 105.85
R21 N21 N22 825.24
R22 N22 N23 728.33
R23 N23 N24 406.23
R24 N24 N25 239.93
R25 N25 N26 961.49
R26 N26 N27 402.94
R27 N27 N28 183.47
R28 N28 N29 187.04
R29 N29 N30 862.74
R30 N30 N31 643.35
R31 N31 N32 826.42
R32 N32 N33 756.76
R33 N33 N34 582.61
R34 N34 N35 975.80
R35 N35 N36 440.68
R36 N36 N37 596.84
R37 N37 N38 846.46
R38 N38 N39 656.67
R39 N39 N40 875.54
R40 N40 N41 619.62
R41 N41 N42 734.11
R42 N42 N43 141.24
R43 N43 N44 305.11
R44 N44 N45 360.45
R45 N45 N46 171.81
R46 N46 N47 309.51
R47 N47 N48 190.90
R48 N48 N49 350.18
R49 N49 N50 672.12
R50 N50 N51 428.35
R51 N51 N52 433.16
R52 N52 N53 288.56
R53 N53 N54 340.28
R54 N54 N55 942.99
R55 N55 N56 683.23
R56 N56 N57 648.22
R57 N57 N58 254.02
R58 N58 N59 756.21
R59 N59 N60 247.06
R60 N60 N61 441.51
R61 N61 N62 990.57
R62 N62 N63 676.00
R63 N63 N64 601.25
R64 N64 N65 716.15
R65 N65 N66 858.57
R66 N66 N67 798.40
R67 N67 N68 306.14
R68 N68 N69 128.89
R69 N69 N70 383.91
R70 N70 N71 340.97
R71 N71 N72 289.88
R72 N72 N73 948.62
R73 N73 N74 888.73
R74 N74 N75 383.21
R75 N75 N76 689.89
R76 N76 N77 456.07
R77 N77 N78 923.09
R78 N78 N79 512.97
R79 N79 N80 338.39
R80 N80 N81 321.96
R81 N81 N82 605.23
R82 N82 N83 336.47
R83 N83 N84 626.13
R84 N84 N85 908.04
R85 N85 N86 459.46
R86 N86 N87 297.39
R87 N87 N88 997.78
R88 N88 N89 558.57
R89 N89 N90 181.82
R90 N90 N91 142.40
R91 N91 N92 198.68
R92 N92 N93 664.70
R93 N93 N94 812.87
R94 N94 N95 479.94
R95 N95 N96 157.17
R96 N96 N97 443.46
R97 N97 N98 996.51
R98 N98 N99 576.20
R99 N99 N100 973.97
R100 N100 N101 874.70
R101 N101 N102 110.33
R102 N102 N103 748.65
R103 N103 N104 713.54
R104 N104 N105 583.27
R105 N105 N106 340.14
R106 N106 N107 676.87
R107 N107 N108 200.40
R108 N108 N109 491.29
R109 N109 N110 508.35
R110 N110 N111 958.43
R111 N111 N112 888.27
R112 N112 N113 337.05
R113 N113 N114 550.53
R114 N114 N115 260.79
R115 N115 N116 921.37
R116 N116 N117 883.47
R117 N117 N118 368.60
R118 N118 N119 675.05
R119 N119 N120 648.07
R120 N120 N121 237.56
R121 N121 N122 786.26
R122 N122 N123 585.44
R123 N123 N124 800.76
R124 N124 N125 577.32
R125 N125 N126 100.51
R126 N126 N127 391.74
R127 N127 N128 117.53
R128 N128 N129 936.19
R129 N129 N130 890.85
R130 N130 N131 848.50
R131 N131 N132 376.76
R132 N132 N133 152.13
R133 N133 N134 890.21
R134 N134 N135 952.25
R135 N135 N136 177.09
R136 N136 N137 537.39
R137 N137 N138 162.29
R138 N138 N139 784.54
R139 N139 N140 789.25
R140 N140 N141 215.55
R141 N141 N142 527.75
R142 N142 N143 594.82
R143 N143 N144 338.55
R144 N144 N145 885.19
R145 N145 N146 480.82
R146 N146 N147 290.62
R147 N147 N148 585.37
R148 N148 N149 756.94
R149 N149 N150 281.04
R150 N150 N151 380.54
R151 N151 N152 995.63
R152 N152 N153 684.89
R153 N153 N154 494.29
R154 N154 N155 565.82
R155 N155 N156 208.90
R156 N156 N157 302.23
R157 N157 N158 404.28
R158 N158 N159 629.48
R159 N159 N160 307.10
R160 N160 N161 298.20
R161 N161 N162 163.89
R162 N162 N163 667.99
R163 N163 N164 306.05
R164 N164 N165 914.88
R165 N165 N166 873.67
R166 N166 N167 163.77
R167 N167 N168 314.20
R168 N168 N169 702.08
R169 N169 N170 292.81
R170 N170 N171 219.08
R171 N171 N172 941.96
R172 N172 N173 613.94
R173 N173 N174 525.40
R174 N174 N175 806.16
R175 N175 N176 826.75
R176 N176 N177 271.37
R177 N177 N178 187.24
R178 N178 N179 487.95
R179 N179 N180 481.22
R180 N180 N181 520.32
R181 N181 N182 756.17
R182 N182 N183 706.03
R183 N183 N184 985.75
R184 N184 N185 188.58
R185 N185 N186 462.36
R186 N186 N187 405.37
R187 N187 N188 875.51
R188 N188 N189 323.79
R189 N189 N190 271.19
R190 N190 N191 503.75
R191 N191 N192 479.69
R192 N192 N193 350.69
R193 N193 N194 324.83
R194 N194 N195 930.94
R195 N195 N196 498.82
R196 N196 N197 875.21
R197 N197 N198 595.29
R198 N198 N199 145.53
R199 N199 N200 999.35
R200 N200 N201 852.42
R201 N201 N202 972.10
R202 N202 N203 933.73
R203 N203 N204 863.83
R204 N204 N205 249.68
R205 N205 N206 537.08
R206 N206 N207 292.37
R207 N207 N208 460.94
R208 N208 N209 152.77
R209 N209 N210 441.08
R210 N210 N211 986.78
R211 N211 N212 338.68
R212 N212 N213 805.66
R213 N213 N214 509.51
R214 N214 N215 480.71
R215 N215 N216 961.59
R216 N216 N217 995.88
R217 N217 N218 600.19
R218 N218 N219 746.57
R219 N219 N220 239.32
R220 N220 N221 367.04
R221 N221 N222 971.84
R222 N222 N223 621.26
R223 N223 N224 587.98
R224 N224 N225 773.18
R225 N225 N226 151.45
R226 N226 N227 625.76
R227 N227 N228 552.57
R228 N228 N229 867.45
R229 N229 N230 241.69
R230 N230 N231 964.70
R231 N231 N232 172.10
R232 N232 N233 267.24
R233 N233 N234 635.53
R234 N234 N235 707.69
R235 N235 N236 311.68
R236 N236 N237 207.90
R237 N237 N238 901.26
R238 N238 N239 321.59
R239 N239 N240 635.07
R240 N240 N241 657.44
R241 N241 N242 477.30
R242 N242 N243 625.31
R243 N243 N244 570.50
R244 N244 N245 941.24
R245 N245 N246 283.83
R246 N246 N247 744.57
R247 N247 N248 314.82
R248 N248 N249 456.21
R249 N249 N250 704.52
R250 N250 N251 370.00
R251 N251 N252 384.56
R252 N252 N253 776.68
R253 N253 N254 165.29
R254 N254 N255 512.46
R255 N255 N256 998.61
R256 N256 N257 996.49
R257 N257 N258 165.93
R258 N258 N259 291.84
R259 N259 N260 338.68
R260 N260 N261 939.93
R261 N261 N262 892.78
R262 N262 N263 891.34
R263 N263 N264 432.57
R264 N264 N265 241.97
R265 N265 N266 850.37
R266 N266 N267 733.19
R267 N267 N268 650.51
R268 N268 N269 988.51
R269 N269 N270 688.58
R270 N270 N271 107.04
R271 N271 N272 835.39
R272 N272 N273 369.44
R273 N273 N274 697.05
R274 N274 N275 945.04
R275 N275 N276 220.86
R276 N276 N277 203.89
R277 N277 N278 196.33
R278 N278 N279 597.90
R279 N279 N280 345.11
R280 N280 N281 644.35
R281 N281 N282 745.85
R282 N282 N283 283.24
R283 N283 N284 670.81
R284 N284 N285 337.59
R285 N285 N286 539.68
R286 N286 N287 914.80
R287 N287 N288 861.49
R288 N288 N289 183.07
R289 N289 N290 481.22
R290 N290 N291 349.01
R291 N291 N292 103.19
R292 N292 N293 794.01
R293 N293 N294 673.40
R294 N294 N295 335.76
R295 N295 N296 767.11
R296 N296 N297 596.51
R297 N297 N298 484.92
R298 N298 N299 108.70
R299 N299 N300 167.72
R300 N300 N301 894.80
R301 N301 N302 913.54
R302 N302 N303 591.03
R303 N303 N304 851.14
R304 N304 N305 624.26
R305 N305 N306 233.28
R306 N306 N307 214.70
R307 N307 N308 377.43
R308 N308 N309 909.08
R309 N309 N310 816.51
R310 N310 N311 874.63
R311 N311 N312 909.03
R312 N312 N313 289.07
R313 N313 N314 324.58
R314 N314 N315 192.51
R315 N315 N316 802.10
R316 N316 N317 895.72
R317 N317 N318 465.74
R318 N318 N319 658.60
R319 N319 N320 239.10
R320 N320 N321 936.89
R321 N321 N322 878.15
R322 N322 N323 978.59
R323 N323 N324 829.69
R324 N324 N325 893.27
R325 N325 N326 122.31
R326 N326 N327 762.91
R327 N327 N328 398.97
R328 N328 N329 937.73
R329 N329 N330 822.01
R330 N330 N331 877.66
R331 N331 N332 829.67
R332 N332 N333 340.13
R333 N333 N334 808.64
R334 N334 N335 197.29
R335 N335 N336 884.95
R336 N336 N337 872.73
R337 N337 N338 300.19
R338 N338 N339 834.93
R339 N339 N340 514.27
R340 N340 N341 374.67
R341 N341 N342 815.81
R342 N342 N343 304.84
R343 N343 N344 121.30
R344 N344 N345 273.82
R345 N345 N346 395.44
R346 N346 N347 877.92
R347 N347 N348 970.20
R348 N348 N349 351.21
R349 N349 N350 677.33
R350 N350 N351 459.71
R351 N351 N352 983.03
R352 N352 N353 582.59
R353 N353 N354 945.31
R354 N354 N355 203.81
R355 N355 N356 973.36
R356 N356 N357 260.71
R357 N357 N358 966.28
R358 N358 N359 338.92
R359 N359 N360 197.56
R360 N360 N361 491.11
R361 N361 N362 755.69
R362 N362 N363 382.31
R363 N363 N364 645.59
R364 N364 N365 560.28
R365 N365 N366 446.68
R366 N366 N367 618.93
R367 N367 N368 329.25
R368 N368 N369 737.91
R369 N369 N370 101.52
R370 N370 N371 933.02
R371 N371 N372 584.61
R372 N372 N373 747.49
R373 N373 N374 767.76
R374 N374 N375 703.57
R375 N375 N376 427.80
R376 N376 N377 162.98
R377 N377 N378 697.81
R378 N378 N379 397.18
R379 N379 N380 382.52
R380 N380 N381 863.21
R381 N381 N382 747.78
R382 N382 N383 370.29
R383 N383 N384 378.36
R384 N384 N385 467.55
R385 N385 N386 462.16
R386 N386 N387 366.09
R387 N387 N388 214.56
R388 N388 N389 478.40
R389 N389 N390 946.33
R390 N390 N391 709.59
R391 N391 N392 912.52
R392 N392 N393 653.96
R393 N393 N394 370.85
R394 N394 N395 593.14
R395 N395 N396 100.37
R396 N396 N397 358.22
R397 N397 N398 486.90
R398 N398 N399 621.99
R399 N399 N400 689.24
R400 N400 N401 518.49
R401 N401 N402 497.94
R402 N402 N403 292.33
R403 N403 N404 525.87
R404 N404 N405 911.06
R405 N405 N406 816.42
R406 N406 N407 252.72
R407 N407 N408 176.32
R408 N408 N409 563.91
R409 N409 N410 669.65
R410 N410 N411 401.67
R411 N411 N412 836.58
R412 N412 N413 776.02
R413 N413 N414 705.52
R414 N414 N415 302.18
R415 N415 N416 279.22
R416 N416 N417 121.98
R417 N417 N418 320.36
R418 N418 N419 527.62
R419 N419 N420 864.76
R420 N420 N421 165.55
R421 N421 N422 473.00
R422 N422 N423 666.79
R423 N423 N424 274.99
R424 N424 N425 726.72
R425 N425 N426 544.94
R426 N426 N427 319.59
R427 N427 N428 690.45
R428 N428 N429 104.99
R429 N429 N430 775.87
R430 N430 N431 793.04
R431 N431 N432 195.93
R432 N432 N433 482.63
R433 N433 N434 258.30
R434 N434 N435 962.17
R435 N435 N436 566.16
R436 N436 N437 145.20
R437 N437 N438 324.28
R438 N438 N439 863.50
R439 N439 N440 510.82
R440 N440 N441 821.27
R441 N441 N442 700.82
R442 N442 N443 989.10
R443 N443 N444 635.91
R444 N444 N445 955.04
R445 N445 N446 902.28
R446 N446 N447 651.39
R447 N447 N448 747.35
R448 N448 N449 554.30
R449 N449 N450 847.51
R450 N450 N451 593.08
R451 N451 N452 907.49
R452 N452 N453 769.29
R453 N453 N454 527.21
R454 N454 N455 333.27
R455 N455 N456 322.52
R456 N456 N457 673.90
R457 N457 N458 789.23
R458 N458 N459 569.17
R459 N459 N460 664.07
R460 N460 N461 347.14
R461 N461 N462 169.74
R462 N462 N463 357.16
R463 N463 N464 344.54
R464 N464 N465 387.74
R465 N465 N466 586.14
R466 N466 N467 224.54
R467 N467 N468 308.14
R468 N468 N469 724.55
R469 N469 N470 735.78
R470 N470 N471 157.81
R471 N471 N472 466.84
R472 N472 N473 588.35
R473 N473 N474 474.20
R474 N474 N475 286.15
R475 N475 N476 478.13
R476 N476 N477 914.35
R477 N477 N478 625.67
R478 N478 N479 725.97
R479 N479 N480 871.06
R480 N480 N481 789.04
R481 N481 N482 442.34
R482 N482 N483 105.31
R483 N483 N484 416.58
R484 N484 N485 778.13
R485 N485 N486 868.10
R486 N486 N487 958.09
R487 N487 N488 477.12
R488 N488 N489 772.76
R489 N489 N490 591.52
R490 N490 N491 642.93
R491 N491 N492 298.48
R492 N492 N493 297.48
R493 N493 N494 492.25
R494 N494 N495 126.12
R495 N495 N496 402.52
R496 N496 N497 711.23
R497 N497 N498 463.89
R498 N498 N499 248.54
R499 N499 N500 520.65
R500 N500 N501 214.87
R501 N501 N502 660.03
R502 N502 N503 124.27
R503 N503 N504 454.62
R504 N504 N505 607.95
R505 N505 N506 124.39
R506 N506 N507 678.47
R507 N507 N508 222.13
R508 N508 N509 515.53
R509 N509 N510 145.26
R510 N510 N511 441.19
R511 N511 N512 290.49
R512 N512 N513 394.16
R513 N513 N514 785.11
R514 N514 N515 441.21
R515 N515 N516 776.81
R516 N516 N517 848.73
R517 N517 N518 327.04
R518 N518 N519 173.72
R519 N519 N520 117.44
R520 N520 N521 585.48
R521 N521 N522 999.92
R522 N522 N523 414.96
R523 N523 N524 685.13
R524 N524 N525 803.11
R525 N525 N526 686.58
R526 N526 N527 778.81
R527 N527 N528 954.65
R528 N528 N529 279.42
R529 N529 N530 118.34
R530 N530 N531 237.14
R531 N531 N532 213.60
R532 N532 N533 702.51
R533 N533 N534 607.57
R534 N534 N535 296.17
R535 N535 N536 729.52
R536 N536 N537 790.21
R537 N537 N538 251.01
R538 N538 N539 646.52
R539 N539 N540 773.13
R540 N540 N541 203.08
R541 N541 N542 837.37
R542 N542 N543 968.25
R543 N543 N544 197.29
R544 N544 N545 123.11
R545 N545 N546 380.76
R546 N546 N547 709.61
R547 N547 N548 962.36
R548 N548 N549 456.99
R549 N549 N550 743.51
R550 N550 N551 168.40
R551 N551 N552 721.55
R552 N552 N553 664.52
R553 N553 N554 191.71
R554 N554 N555 795.23
R555 N555 N556 865.26
R556 N556 N557 640.37
R557 N557 N558 208.95
R558 N558 N559 985.46
R559 N559 N560 804.37
R560 N560 N561 412.48
R561 N561 N562 485.54
R562 N562 N563 433.51
R563 N563 N564 555.36
R564 N564 N565 407.11
R565 N565 N566 864.62
R566 N566 N567 840.10
R567 N567 N568 194.98
R568 N568 N569 964.71
R569 N569 N570 672.03
R570 N570 N571 845.84
R571 N571 N572 736.58
R572 N572 N573 491.94
R573 N573 N574 760.42
R574 N574 N575 968.93
R575 N575 N576 343.07
R576 N576 N577 827.38
R577 N577 N578 584.36
R578 N578 N579 535.15
R579 N579 N580 492.02
R580 N580 N581 757.92
R581 N581 N582 341.56
R582 N582 N583 866.54
R583 N583 N584 847.66
R584 N584 N585 178.00
R585 N585 N586 893.47
R586 N586 N587 319.48
R587 N587 N588 518.24
R588 N588 N589 649.30
R589 N589 N590 441.09
R590 N590 N591 125.83
R591 N591 N592 865.86
R592 N592 N593 263.66
R593 N593 N594 290.91
R594 N594 N595 818.05
R595 N595 N596 406.30
R596 N596 N597 892.29
R597 N597 N598 731.07
R598 N598 N599 348.64
R599 N599 N600 109.14
R600 N600 N601 953.26
R601 N601 N602 177.05
R602 N602 N603 748.07
R603 N603 N604 539.72
R604 N604 N605 782.35
R605 N605 N606 721.55
R606 N606 N607 681.31
R607 N607 N608 541.74
R608 N608 N609 813.64
R609 N609 N610 183.75
R610 N610 N611 299.44
R611 N611 N612 722.61
R612 N612 N613 375.59
R613 N613 N614 623.40
R614 N614 N615 525.93
R615 N615 N616 577.83
R616 N616 N617 482.95
R617 N617 N618 771.34
R618 N618 N619 397.71
R619 N619 N620 732.57
R620 N620 N621 343.82
R621 N621 N622 326.26
R622 N622 N623 208.59
R623 N623 N624 273.33
R624 N624 N625 207.60
R625 N625 N626 582.28
R626 N626 N627 785.97
R627 N627 N628 266.63
R628 N628 N629 294.75
R629 N629 N630 535.78
R630 N630 N631 752.13
R631 N631 N632 978.95
R632 N632 N633 572.17
R633 N633 N634 354.70
R634 N634 N635 190.47
R635 N635 N636 274.71
R636 N636 N637 304.73
R637 N637 N638 261.50
R638 N638 N639 112.73
R639 N639 N640 580.72
R640 N640 N641 346.88
R641 N641 N642 976.87
R642 N642 N643 598.02
R643 N643 N644 727.68
R644 N644 N645 213.65
R645 N645 N646 881.62
R646 N646 N647 541.79
R647 N647 N648 885.45
R648 N648 N649 616.66
R649 N649 N650 522.46
R650 N650 N651 496.42
R651 N651 N652 265.93
R652 N652 N653 146.24
R653 N653 N654 946.96
R654 N654 N655 529.96
R655 N655 N656 839.90
R656 N656 N657 460.64
R657 N657 N658 166.67
R658 N658 N659 666.50
R659 N659 N660 148.25
R660 N660 N661 234.28
R661 N661 N662 606.56
R662 N662 N663 373.45
R663 N663 N664 994.53
R664 N664 N665 206.61
R665 N665 N666 788.00
R666 N666 N667 645.69
R667 N667 N668 811.67
R668 N668 N669 303.12
R669 N669 N670 570.32
R670 N670 N671 505.46
R671 N671 N672 498.45
R672 N672 N673 874.15
R673 N673 N674 991.03
R674 N674 N675 374.84
R675 N675 N676 658.92
R676 N676 N677 648.67
R677 N677 N678 766.08
R678 N678 N679 952.83
R679 N679 N680 287.01
R680 N680 N681 289.92
R681 N681 N682 694.39
R682 N682 N683 241.35
R683 N683 N684 256.43
R684 N684 N685 167.56
R685 N685 N686 102.41
R686 N686 N687 505.45
R687 N687 N688 634.43
R688 N688 N689 362.13
R689 N689 N690 308.33
R690 N690 N691 736.26
R691 N691 N692 732.69
R692 N692 N693 508.63
R693 N693 N694 718.65
R694 N694 N695 931.52
R695 N695 N696 809.05
R696 N696 N697 662.55
R697 N697 N698 695.06
R698 N698 N699 940.30
R699 N699 N700 482.63
R700 N700 N701 590.11
R701 N701 N702 682.87
R702 N702 N703 917.57
R703 N703 N704 843.97
R704 N704 N705 164.27
R705 N705 N706 249.33
R706 N706 N707 376.85
R707 N707 N708 774.06
R708 N708 N709 612.29
R709 N709 N710 359.75
R710 N710 N711 211.92
R711 N711 N712 719.81
R712 N712 N713 729.76
R713 N713 N714 948.41
R714 N714 N715 550.42
R715 N715 N716 544.42
R716 N716 N717 172.40
R717 N717 N718 135.87
R718 N718 N719 488.83
R719 N719 N720 390.09
R720 N720 N721 325.33
R721 N721 N722 182.19
R722 N722 N723 965.72
R723 N723 N724 852.36
R724 N724 N725 617.68
R725 N725 N726 955.71
R726 N726 N727 999.62
R727 N727 N728 705.05
R728 N728 N729 342.56
R729 N729 N730 136.21
R730 N730 N731 780.64
R731 N731 N732 523.45
R732 N732 N733 686.36
R733 N733 N734 924.47
R734 N734 N735 263.34
R735 N735 N736 626.80
R736 N736 N737 671.31
R737 N737 N738 542.55
R738 N738 N739 182.12
R739 N739 N740 413.16
R740 N740 N741 399.98
R741 N741 N742 703.12
R742 N742 N743 871.96
R743 N743 N744 396.82
R744 N744 N745 724.31
R745 N745 N746 359.40
R746 N746 N747 950.67
R747 N747 N748 832.21
R748 N748 N749 595.09
R749 N749 N750 509.34
R750 N750 N751 383.07
R751 N751 N752 390.95
R752 N752 N753 973.17
R753 N753 N754 463.76
R754 N754 N755 563.14
R755 N755 N756 989.31
R756 N756 N757 691.89
R757 N757 N758 588.33
R758 N758 N759 471.92
R759 N759 N760 268.82
R760 N760 N761 425.60
R761 N761 N762 780.80
R762 N762 N763 662.87
R763 N763 N764 783.99
R764 N764 N765 283.20
R765 N765 N766 594.30
R766 N766 N767 934.91
R767 N767 N768 494.30
R768 N768 N769 728.43
R769 N769 N770 209.28
R770 N770 N771 975.83
R771 N771 N772 647.98
R772 N772 N773 315.37
R773 N773 N774 242.54
R774 N774 N775 595.76
R775 N775 N776 597.03
R776 N776 N777 183.89
R777 N777 N778 993.03
R778 N778 N779 921.64
R779 N779 N780 515.30
R780 N780 N781 205.72
R781 N781 N782 848.93
R782 N782 N783 548.54
R783 N783 N784 744.94
R784 N784 N785 557.98
R785 N785 N786 346.08
R786 N786 N787 851.25
R787 N787 N788 982.22
R788 N788 N789 319.36
R789 N789 N790 596.14
R790 N790 N791 445.23
R791 N791 N792 929.68
R792 N792 N793 557.42
R793 N793 N794 891.39
R794 N794 N795 877.62
R795 N795 N796 348.62
R796 N796 N797 811.01
R797 N797 N798 473.45
R798 N798 N799 940.82
R799 N799 N800 556.96
R800 N800 N801 838.49
R801 N801 N802 354.56
R802 N802 N803 368.70
R803 N803 N804 628.24
R804 N804 N805 999.01
R805 N805 N806 540.68
R806 N806 N807 233.74
R807 N807 N808 584.72
R808 N808 N809 410.61
R809 N809 N810 596.73
R810 N810 N811 589.09
R811 N811 N812 509.81
R812 N812 N813 389.60
R813 N813 N814 269.79
R814 N814 N815 727.75
R815 N815 N816 614.62
R816 N816 N817 310.21
R817 N817 N818 797.99
R818 N818 N819 139.28
R819 N819 N820 770.23
R820 N820 N821 734.71
R821 N821 N822 830.27
R822 N822 N823 447.47
R823 N823 N824 697.32
R824 N824 N825 838.67
R825 N825 N826 982.74
R826 N826 N827 545.80
R827 N827 N828 133.32
R828 N828 N829 552.06
R829 N829 N830 631.16
R830 N830 N831 882.73
R831 N831 N832 886.77
R832 N832 N833 496.28
R833 N833 N834 573.36
R834 N834 N835 511.24
R835 N835 N836 750.20
R836 N836 N837 468.98
R837 N837 N838 689.30
R838 N838 N839 238.93
R839 N839 N840 522.54
R840 N840 N841 972.28
R841 N841 N842 404.71
R842 N842 N843 723.43
R843 N843 N844 684.85
R844 N844 N845 866.59
R845 N845 N846 867.11
R846 N846 N847 873.41
R847 N847 N848 442.01
R848 N848 N849 385.00
R849 N849 N850 746.85
R850 N850 N851 783.46
R851 N851 N852 885.14
R852 N852 N853 132.31
R853 N853 N854 161.58
R854 N854 N855 668.04
R855 N855 N856 928.84
R856 N856 N857 997.68
R857 N857 N858 772.09
R858 N858 N859 490.57
R859 N859 N860 188.60
R860 N860 N861 670.37
R861 N861 N862 885.32
R862 N862 N863 499.31
R863 N863 N864 724.60
R864 N864 N865 913.08
R865 N865 N866 141.39
R866 N866 N867 816.53
R867 N867 N868 364.03
R868 N868 N869 437.36
R869 N869 N870 231.01
R870 N870 N871 578.05
R871 N871 N872 609.34
R872 N872 N873 813.27
R873 N873 N874 252.99
R874 N874 N875 171.07
R875 N875 N876 883.76
R876 N876 N877 657.74
R877 N877 N878 316.75
R878 N878 N879 921.55
R879 N879 N880 228.81
R880 N880 N881 515.03
R881 N881 N882 328.58
R882 N882 N883 329.79
R883 N883 N884 108.46
R884 N884 N885 824.17
R885 N885 N886 911.09
R886 N886 N887 709.85
R887 N887 N888 242.18
R888 N888 N889 497.56
R889 N889 N890 411.01
R890 N890 N891 628.81
R891 N891 N892 675.04
R892 N892 N893 481.88
R893 N893 N894 325.09
R894 N894 N895 860.77
R895 N895 N896 279.30
R896 N896 N897 446.22
R897 N897 N898 534.89
R898 N898 N899 313.49
R899 N899 N900 614.73
R900 N900 N901 617.33
R901 N901 N902 993.42
R902 N902 N903 365.71
R903 N903 N904 980.15
R904 N904 N905 692.41
R905 N905 N906 347.03
R906 N906 N907 609.34
R907 N907 N908 717.22
R908 N908 N909 770.20
R909 N909 N910 144.14
R910 N910 N911 645.77
R911 N911 N912 547.05
R912 N912 N913 913.74
R913 N913 N914 357.57
R914 N914 N915 818.97
R915 N915 N916 646.36
R916 N916 N917 417.09
R917 N917 N918 672.96
R918 N918 N919 658.80
R919 N919 N920 709.99
R920 N920 N921 748.84
R921 N921 N922 693.26
R922 N922 N923 854.50
R923 N923 N924 665.42
R924 N924 N925 913.06
R925 N925 N926 681.71
R926 N926 N927 378.04
R927 N927 N928 496.74
R928 N928 N929 621.62
R929 N929 N930 759.12
R930 N930 N931 181.12
R931 N931 N932 365.60
R932 N932 N933 772.73
R933 N933 N934 258.08
R934 N934 N935 218.94
R935 N935 N936 585.47
R936 N936 N937 974.34
R937 N937 N938 577.77
R938 N938 N939 922.14
R939 N939 N940 847.43
R940 N940 N941 331.27
R941 N941 N942 842.22
R942 N942 N943 533.66
R943 N943 N944 825.84
R944 N944 N945 771.90
R945 N945 N946 404.84
R946 N946 N947 203.65
R947 N947 N948 966.60
R948 N948 N949 226.68
R949 N949 N950 969.85
R950 N950 N951 874.13
R951 N951 N952 751.80
R952 N952 N953 981.95
R953 N953 N954 970.54
R954 N954 N955 824.13
R955 N955 N956 429.20
R956 N956 N957 811.61
R957 N957 N958 112.53
R958 N958 N959 582.92
R959 N959 N960 509.31
R960 N960 N961 705.55
R961 N961 N962 705.11
R962 N962 N963 626.10
R963 N963 N964 840.18
R964 N964 N965 946.26
R965 N965 N966 197.51
R966 N966 N967 310.44
R967 N967 N968 122.52
R968 N968 N969 895.81
R969 N969 N970 605.27
R970 N970 N971 923.73
R971 N971 N972 299.23
R972 N972 N973 156.90
R973 N973 N974 841.47
R974 N974 N975 918.45
R975 N975 N976 371.97
R976 N976 N977 467.47
R977 N977 N978 225.80
R978 N978 N979 951.64
R979 N979 N980 373.93
R980 N980 N981 543.36
R981 N981 N982 187.47
R982 N982 N983 898.53
R983 N983 N984 222.10
R984 N984 N985 508.28
R985 N985 N986 703.44
R986 N986 N987 768.83
R987 N987 N988 951.38
R988 N988 N989 477.21
R989 N989 N990 768.04
R990 N990 N991 239.07
R991 N991 N992 473.40
R992 N992 N993 189.12
R993 N993 N994 540.41
R994 N994 N995 467.30
R995 N995 N996 956.37
R996 N996 N997 129.44
R997 N997 N998 433.48
R998 N998 N999 499.04
R999 N999 N1000 955.50
RG1 N1 0 1e6
RG2 N2 0 1e6
RG3 N3 0 1e6
RG4 N4 0 1e6
RG5 N5 0 1e6
RG6 N6 0 1e6
RG7 N7 0 1e6
RG8 N8 0 1e6
RG9 N9 0 1e6
RG10 N10 0 1e6
RG11 N11 0 1e6
RG12 N12 0 1e6
RG13 N13 0 1e6
RG14 N14 0 1e6
RG15 N15 0 1e6
RG16 N16 0 1e6
RG17 N17 0 1e6
RG18 N18 0 1e6
RG19 N19 0 1e6
RG20 N20 0 1e6
RG21 N21 0 1e6
RG22 N22 0 1e6
RG23 N23 0 1e6
RG24 N24 0 1e6
RG25 N25 0 1e6
RG26 N26 0 1e6
RG27 N27 0 1e6
RG28 N28 0 1e6
RG29 N29 0 1e6
RG30 N30 0 1e6
RG31 N31 0 1e6
RG32 N32 0 1e6
RG33 N33 0 1e6
RG34 N34 0 1e6
RG35 N35 0 1e6
RG36 N36 0 1e6
RG37 N37 0 1e6
RG38 N38 0 1e6
RG39 N39 0 1e6
RG40 N40 0 1e6
RG41 N41 0 1e6
RG42 N42 0 1e6
RG43 N43 0 1e6
RG44 N44 0 1e6
RG45 N45 0 1e6
RG46 N46 0 1e6
RG47 N47 0 1e6
RG48 N48 0 1e6
RG49 N49 0 1e6
RG50 N50 0 1e6
RG51 N51 0 1e6
RG52 N52 0 1e6
RG53 N53 0 1e6
RG54 N54 0 1e6
RG55 N55 0 1e6
RG56 N56 0 1e6
RG57 N57 0 1e6
RG58 N58 0 1e6
RG59 N59 0 1e6
RG60 N60 0 1e6
RG61 N61 0 1e6
RG62 N62 0 1e6
RG63 N63 0 1e6
RG64 N64 0 1e6
RG65 N65 0 1e6
RG66 N66 0 1e6
RG67 N67 0 1e6
RG68 N68 0 1e6
RG69 N69 0 1e6
RG70 N70 0 1e6
RG71 N71 0 1e6
RG72 N72 0 1e6
RG73 N73 0 1e6
RG74 N74 0 1e6
RG75 N75 0 1e6
RG76 N76 0 1e6
RG77 N77 0 1e6
RG78 N78 0 1e6
RG79 N79 0 1e6
RG80 N80 0 1e6
RG81 N81 0 1e6
RG82 N82 0 1e6
RG83 N83 0 1e6
RG84 N84 0 1e6
RG85 N85 0 1e6
RG86 N86 0 1e6
RG87 N87 0 1e6
RG88 N88 0 1e6
RG89 N89 0 1e6
RG90 N90 0 1e6
RG91 N91 0 1e6
RG92 N92 0 1e6
RG93 N93 0 1e6
RG94 N94 0 1e6
RG95 N95 0 1e6
RG96 N96 0 1e6
RG97 N97 0 1e6
RG98 N98 0 1e6
RG99 N99 0 1e6
RG100 N100 0 1e6
RG101 N101 0 1e6
RG102 N102 0 1e6
RG103 N103 0 1e6
RG104 N104 0 1e6
RG105 N105 0 1e6
RG106 N106 0 1e6
RG107 N107 0 1e6
RG108 N108 0 1e6
RG109 N109 0 1e6
RG110 N110 0 1e6
RG111 N111 0 1e6
RG112 N112 0 1e6
RG113 N113 0 1e6
RG114 N114 0 1e6
RG115 N115 0 1e6
RG116 N116 0 1e6
RG117 N117 0 1e6
RG118 N118 0 1e6
RG119 N119 0 1e6
RG120 N120 0 1e6
RG121 N121 0 1e6
RG122 N122 0 1e6
RG123 N123 0 1e6
RG124 N124 0 1e6
RG125 N125 0 1e6
RG126 N126 0 1e6
RG127 N127 0 1e6
RG128 N128 0 1e6
RG129 N129 0 1e6
RG130 N130 0 1e6
RG131 N131 0 1e6
RG132 N132 0 1e6
RG133 N133 0 1e6
RG134 N134 0 1e6
RG135 N135 0 1e6
RG136 N136 0 1e6
RG137 N137 0 1e6
RG138 N138 0 1e6
RG139 N139 0 1e6
RG140 N140 0 1e6
RG141 N141 0 1e6
RG142 N142 0 1e6
RG143 N143 0 1e6
RG144 N144 0 1e6
RG145 N145 0 1e6
RG146 N146 0 1e6
RG147 N147 0 1e6
RG148 N148 0 1e6
RG149 N149 0 1e6
RG150 N150 0 1e6
RG151 N151 0 1e6
RG152 N152 0 1e6
RG153 N153 0 1e6
RG154 N154 0 1e6
RG155 N155 0 1e6
RG156 N156 0 1e6
RG157 N157 0 1e6
RG158 N158 0 1e6
RG159 N159 0 1e6
RG160 N160 0 1e6
RG161 N161 0 1e6
RG162 N162 0 1e6
RG163 N163 0 1e6
RG164 N164 0 1e6
RG165 N165 0 1e6
RG166 N166 0 1e6
RG167 N167 0 1e6
RG168 N168 0 1e6
RG169 N169 0 1e6
RG170 N170 0 1e6
RG171 N171 0 1e6
RG172 N172 0 1e6
RG173 N173 0 1e6
RG174 N174 0 1e6
RG175 N175 0 1e6
RG176 N176 0 1e6
RG177 N177 0 1e6
RG178 N178 0 1e6
RG179 N179 0 1e6
RG180 N180 0 1e6
RG181 N181 0 1e6
RG182 N182 0 1e6
RG183 N183 0 1e6
RG184 N184 0 1e6
RG185 N185 0 1e6
RG186 N186 0 1e6
RG187 N187 0 1e6
RG188 N188 0 1e6
RG189 N189 0 1e6
RG190 N190 0 1e6
RG191 N191 0 1e6
RG192 N192 0 1e6
RG193 N193 0 1e6
RG194 N194 0 1e6
RG195 N195 0 1e6
RG196 N196 0 1e6
RG197 N197 0 1e6
RG198 N198 0 1e6
RG199 N199 0 1e6
RG200 N200 0 1e6
RG201 N201 0 1e6
RG202 N202 0 1e6
RG203 N203 0 1e6
RG204 N204 0 1e6
RG205 N205 0 1e6
RG206 N206 0 1e6
RG207 N207 0 1e6
RG208 N208 0 1e6
RG209 N209 0 1e6
RG210 N210 0 1e6
RG211 N211 0 1e6
RG212 N212 0 1e6
RG213 N213 0 1e6
RG214 N214 0 1e6
RG215 N215 0 1e6
RG216 N216 0 1e6
RG217 N217 0 1e6
RG218 N218 0 1e6
RG219 N219 0 1e6
RG220 N220 0 1e6
RG221 N221 0 1e6
RG222 N222 0 1e6
RG223 N223 0 1e6
RG224 N224 0 1e6
RG225 N225 0 1e6
RG226 N226 0 1e6
RG227 N227 0 1e6
RG228 N228 0 1e6
RG229 N229 0 1e6
RG230 N230 0 1e6
RG231 N231 0 1e6
RG232 N232 0 1e6
RG233 N233 0 1e6
RG234 N234 0 1e6
RG235 N235 0 1e6
RG236 N236 0 1e6
RG237 N237 0 1e6
RG238 N238 0 1e6
RG239 N239 0 1e6
RG240 N240 0 1e6
RG241 N241 0 1e6
RG242 N242 0 1e6
RG243 N243 0 1e6
RG244 N244 0 1e6
RG245 N245 0 1e6
RG246 N246 0 1e6
RG247 N247 0 1e6
RG248 N248 0 1e6
RG249 N249 0 1e6
RG250 N250 0 1e6
RG251 N251 0 1e6
RG252 N252 0 1e6
RG253 N253 0 1e6
RG254 N254 0 1e6
RG255 N255 0 1e6
RG256 N256 0 1e6
RG257 N257 0 1e6
RG258 N258 0 1e6
RG259 N259 0 1e6
RG260 N260 0 1e6
RG261 N261 0 1e6
RG262 N262 0 1e6
RG263 N263 0 1e6
RG264 N264 0 1e6
RG265 N265 0 1e6
RG266 N266 0 1e6
RG267 N267 0 1e6
RG268 N268 0 1e6
RG269 N269 0 1e6
RG270 N270 0 1e6
RG271 N271 0 1e6
RG272 N272 0 1e6
RG273 N273 0 1e6
RG274 N274 0 1e6
RG275 N275 0 1e6
RG276 N276 0 1e6
RG277 N277 0 1e6
RG278 N278 0 1e6
RG279 N279 0 1e6
RG280 N280 0 1e6
RG281 N281 0 1e6
RG282 N282 0 1e6
RG283 N283 0 1e6
RG284 N284 0 1e6
RG285 N285 0 1e6
RG286 N286 0 1e6
RG287 N287 0 1e6
RG288 N288 0 1e6
RG289 N289 0 1e6
RG290 N290 0 1e6
RG291 N291 0 1e6
RG292 N292 0 1e6
RG293 N293 0 1e6
RG294 N294 0 1e6
RG295 N295 0 1e6
RG296 N296 0 1e6
RG297 N297 0 1e6
RG298 N298 0 1e6
RG299 N299 0 1e6
RG300 N300 0 1e6
RG301 N301 0 1e6
RG302 N302 0 1e6
RG303 N303 0 1e6
RG304 N304 0 1e6
RG305 N305 0 1e6
RG306 N306 0 1e6
RG307 N307 0 1e6
RG308 N308 0 1e6
RG309 N309 0 1e6
RG310 N310 0 1e6
RG311 N311 0 1e6
RG312 N312 0 1e6
RG313 N313 0 1e6
RG314 N314 0 1e6
RG315 N315 0 1e6
RG316 N316 0 1e6
RG317 N317 0 1e6
RG318 N318 0 1e6
RG319 N319 0 1e6
RG320 N320 0 1e6
RG321 N321 0 1e6
RG322 N322 0 1e6
RG323 N323 0 1e6
RG324 N324 0 1e6
RG325 N325 0 1e6
RG326 N326 0 1e6
RG327 N327 0 1e6
RG328 N328 0 1e6
RG329 N329 0 1e6
RG330 N330 0 1e6
RG331 N331 0 1e6
RG332 N332 0 1e6
RG333 N333 0 1e6
RG334 N334 0 1e6
RG335 N335 0 1e6
RG336 N336 0 1e6
RG337 N337 0 1e6
RG338 N338 0 1e6
RG339 N339 0 1e6
RG340 N340 0 1e6
RG341 N341 0 1e6
RG342 N342 0 1e6
RG343 N343 0 1e6
RG344 N344 0 1e6
RG345 N345 0 1e6
RG346 N346 0 1e6
RG347 N347 0 1e6
RG348 N348 0 1e6
RG349 N349 0 1e6
RG350 N350 0 1e6
RG351 N351 0 1e6
RG352 N352 0 1e6
RG353 N353 0 1e6
RG354 N354 0 1e6
RG355 N355 0 1e6
RG356 N356 0 1e6
RG357 N357 0 1e6
RG358 N358 0 1e6
RG359 N359 0 1e6
RG360 N360 0 1e6
RG361 N361 0 1e6
RG362 N362 0 1e6
RG363 N363 0 1e6
RG364 N364 0 1e6
RG365 N365 0 1e6
RG366 N366 0 1e6
RG367 N367 0 1e6
RG368 N368 0 1e6
RG369 N369 0 1e6
RG370 N370 0 1e6
RG371 N371 0 1e6
RG372 N372 0 1e6
RG373 N373 0 1e6
RG374 N374 0 1e6
RG375 N375 0 1e6
RG376 N376 0 1e6
RG377 N377 0 1e6
RG378 N378 0 1e6
RG379 N379 0 1e6
RG380 N380 0 1e6
RG381 N381 0 1e6
RG382 N382 0 1e6
RG383 N383 0 1e6
RG384 N384 0 1e6
RG385 N385 0 1e6
RG386 N386 0 1e6
RG387 N387 0 1e6
RG388 N388 0 1e6
RG389 N389 0 1e6
RG390 N390 0 1e6
RG391 N391 0 1e6
RG392 N392 0 1e6
RG393 N393 0 1e6
RG394 N394 0 1e6
RG395 N395 0 1e6
RG396 N396 0 1e6
RG397 N397 0 1e6
RG398 N398 0 1e6
RG399 N399 0 1e6
RG400 N400 0 1e6
RG401 N401 0 1e6
RG402 N402 0 1e6
RG403 N403 0 1e6
RG404 N404 0 1e6
RG405 N405 0 1e6
RG406 N406 0 1e6
RG407 N407 0 1e6
RG408 N408 0 1e6
RG409 N409 0 1e6
RG410 N410 0 1e6
RG411 N411 0 1e6
RG412 N412 0 1e6
RG413 N413 0 1e6
RG414 N414 0 1e6
RG415 N415 0 1e6
RG416 N416 0 1e6
RG417 N417 0 1e6
RG418 N418 0 1e6
RG419 N419 0 1e6
RG420 N420 0 1e6
RG421 N421 0 1e6
RG422 N422 0 1e6
RG423 N423 0 1e6
RG424 N424 0 1e6
RG425 N425 0 1e6
RG426 N426 0 1e6
RG427 N427 0 1e6
RG428 N428 0 1e6
RG429 N429 0 1e6
RG430 N430 0 1e6
RG431 N431 0 1e6
RG432 N432 0 1e6
RG433 N433 0 1e6
RG434 N434 0 1e6
RG435 N435 0 1e6
RG436 N436 0 1e6
RG437 N437 0 1e6
RG438 N438 0 1e6
RG439 N439 0 1e6
RG440 N440 0 1e6
RG441 N441 0 1e6
RG442 N442 0 1e6
RG443 N443 0 1e6
RG444 N444 0 1e6
RG445 N445 0 1e6
RG446 N446 0 1e6
RG447 N447 0 1e6
RG448 N448 0 1e6
RG449 N449 0 1e6
RG450 N450 0 1e6
RG451 N451 0 1e6
RG452 N452 0 1e6
RG453 N453 0 1e6
RG454 N454 0 1e6
RG455 N455 0 1e6
RG456 N456 0 1e6
RG457 N457 0 1e6
RG458 N458 0 1e6
RG459 N459 0 1e6
RG460 N460 0 1e6
RG461 N461 0 1e6
RG462 N462 0 1e6
RG463 N463 0 1e6
RG464 N464 0 1e6
RG465 N465 0 1e6
RG466 N466 0 1e6
RG467 N467 0 1e6
RG468 N468 0 1e6
RG469 N469 0 1e6
RG470 N470 0 1e6
RG471 N471 0 1e6
RG472 N472 0 1e6
RG473 N473 0 1e6
RG474 N474 0 1e6
RG475 N475 0 1e6
RG476 N476 0 1e6
RG477 N477 0 1e6
RG478 N478 0 1e6
RG479 N479 0 1e6
RG480 N480 0 1e6
RG481 N481 0 1e6
RG482 N482 0 1e6
RG483 N483 0 1e6
RG484 N484 0 1e6
RG485 N485 0 1e6
RG486 N486 0 1e6
RG487 N487 0 1e6
RG488 N488 0 1e6
RG489 N489 0 1e6
RG490 N490 0 1e6
RG491 N491 0 1e6
RG492 N492 0 1e6
RG493 N493 0 1e6
RG494 N494 0 1e6
RG495 N495 0 1e6
RG496 N496 0 1e6
RG497 N497 0 1e6
RG498 N498 0 1e6
RG499 N499 0 1e6
RG500 N500 0 1e6
RG501 N501 0 1e6
RG502 N502 0 1e6
RG503 N503 0 1e6
RG504 N504 0 1e6
RG505 N505 0 1e6
RG506 N506 0 1e6
RG507 N507 0 1e6
RG508 N508 0 1e6
RG509 N509 0 1e6
RG510 N510 0 1e6
RG511 N511 0 1e6
RG512 N512 0 1e6
RG513 N513 0 1e6
RG514 N514 0 1e6
RG515 N515 0 1e6
RG516 N516 0 1e6
RG517 N517 0 1e6
RG518 N518 0 1e6
RG519 N519 0 1e6
RG520 N520 0 1e6
RG521 N521 0 1e6
RG522 N522 0 1e6
RG523 N523 0 1e6
RG524 N524 0 1e6
RG525 N525 0 1e6
RG526 N526 0 1e6
RG527 N527 0 1e6
RG528 N528 0 1e6
RG529 N529 0 1e6
RG530 N530 0 1e6
RG531 N531 0 1e6
RG532 N532 0 1e6
RG533 N533 0 1e6
RG534 N534 0 1e6
RG535 N535 0 1e6
RG536 N536 0 1e6
RG537 N537 0 1e6
RG538 N538 0 1e6
RG539 N539 0 1e6
RG540 N540 0 1e6
RG541 N541 0 1e6
RG542 N542 0 1e6
RG543 N543 0 1e6
RG544 N544 0 1e6
RG545 N545 0 1e6
RG546 N546 0 1e6
RG547 N547 0 1e6
RG548 N548 0 1e6
RG549 N549 0 1e6
RG550 N550 0 1e6
RG551 N551 0 1e6
RG552 N552 0 1e6
RG553 N553 0 1e6
RG554 N554 0 1e6
RG555 N555 0 1e6
RG556 N556 0 1e6
RG557 N557 0 1e6
RG558 N558 0 1e6
RG559 N559 0 1e6
RG560 N560 0 1e6
RG561 N561 0 1e6
RG562 N562 0 1e6
RG563 N563 0 1e6
RG564 N564 0 1e6
RG565 N565 0 1e6
RG566 N566 0 1e6
RG567 N567 0 1e6
RG568 N568 0 1e6
RG569 N569 0 1e6
RG570 N570 0 1e6
RG571 N571 0 1e6
RG572 N572 0 1e6
RG573 N573 0 1e6
RG574 N574 0 1e6
RG575 N575 0 1e6
RG576 N576 0 1e6
RG577 N577 0 1e6
RG578 N578 0 1e6
RG579 N579 0 1e6
RG580 N580 0 1e6
RG581 N581 0 1e6
RG582 N582 0 1e6
RG583 N583 0 1e6
RG584 N584 0 1e6
RG585 N585 0 1e6
RG586 N586 0 1e6
RG587 N587 0 1e6
RG588 N588 0 1e6
RG589 N589 0 1e6
RG590 N590 0 1e6
RG591 N591 0 1e6
RG592 N592 0 1e6
RG593 N593 0 1e6
RG594 N594 0 1e6
RG595 N595 0 1e6
RG596 N596 0 1e6
RG597 N597 0 1e6
RG598 N598 0 1e6
RG599 N599 0 1e6
RG600 N600 0 1e6
RG601 N601 0 1e6
RG602 N602 0 1e6
RG603 N603 0 1e6
RG604 N604 0 1e6
RG605 N605 0 1e6
RG606 N606 0 1e6
RG607 N607 0 1e6
RG608 N608 0 1e6
RG609 N609 0 1e6
RG610 N610 0 1e6
RG611 N611 0 1e6
RG612 N612 0 1e6
RG613 N613 0 1e6
RG614 N614 0 1e6
RG615 N615 0 1e6
RG616 N616 0 1e6
RG617 N617 0 1e6
RG618 N618 0 1e6
RG619 N619 0 1e6
RG620 N620 0 1e6
RG621 N621 0 1e6
RG622 N622 0 1e6
RG623 N623 0 1e6
RG624 N624 0 1e6
RG625 N625 0 1e6
RG626 N626 0 1e6
RG627 N627 0 1e6
RG628 N628 0 1e6
RG629 N629 0 1e6
RG630 N630 0 1e6
RG631 N631 0 1e6
RG632 N632 0 1e6
RG633 N633 0 1e6
RG634 N634 0 1e6
RG635 N635 0 1e6
RG636 N636 0 1e6
RG637 N637 0 1e6
RG638 N638 0 1e6
RG639 N639 0 1e6
RG640 N640 0 1e6
RG641 N641 0 1e6
RG642 N642 0 1e6
RG643 N643 0 1e6
RG644 N644 0 1e6
RG645 N645 0 1e6
RG646 N646 0 1e6
RG647 N647 0 1e6
RG648 N648 0 1e6
RG649 N649 0 1e6
RG650 N650 0 1e6
RG651 N651 0 1e6
RG652 N652 0 1e6
RG653 N653 0 1e6
RG654 N654 0 1e6
RG655 N655 0 1e6
RG656 N656 0 1e6
RG657 N657 0 1e6
RG658 N658 0 1e6
RG659 N659 0 1e6
RG660 N660 0 1e6
RG661 N661 0 1e6
RG662 N662 0 1e6
RG663 N663 0 1e6
RG664 N664 0 1e6
RG665 N665 0 1e6
RG666 N666 0 1e6
RG667 N667 0 1e6
RG668 N668 0 1e6
RG669 N669 0 1e6
RG670 N670 0 1e6
RG671 N671 0 1e6
RG672 N672 0 1e6
RG673 N673 0 1e6
RG674 N674 0 1e6
RG675 N675 0 1e6
RG676 N676 0 1e6
RG677 N677 0 1e6
RG678 N678 0 1e6
RG679 N679 0 1e6
RG680 N680 0 1e6
RG681 N681 0 1e6
RG682 N682 0 1e6
RG683 N683 0 1e6
RG684 N684 0 1e6
RG685 N685 0 1e6
RG686 N686 0 1e6
RG687 N687 0 1e6
RG688 N688 0 1e6
RG689 N689 0 1e6
RG690 N690 0 1e6
RG691 N691 0 1e6
RG692 N692 0 1e6
RG693 N693 0 1e6
RG694 N694 0 1e6
RG695 N695 0 1e6
RG696 N696 0 1e6
RG697 N697 0 1e6
RG698 N698 0 1e6
RG699 N699 0 1e6
RG700 N700 0 1e6
RG701 N701 0 1e6
RG702 N702 0 1e6
RG703 N703 0 1e6
RG704 N704 0 1e6
RG705 N705 0 1e6
RG706 N706 0 1e6
RG707 N707 0 1e6
RG708 N708 0 1e6
RG709 N709 0 1e6
RG710 N710 0 1e6
RG711 N711 0 1e6
RG712 N712 0 1e6
RG713 N713 0 1e6
RG714 N714 0 1e6
RG715 N715 0 1e6
RG716 N716 0 1e6
RG717 N717 0 1e6
RG718 N718 0 1e6
RG719 N719 0 1e6
RG720 N720 0 1e6
RG721 N721 0 1e6
RG722 N722 0 1e6
RG723 N723 0 1e6
RG724 N724 0 1e6
RG725 N725 0 1e6
RG726 N726 0 1e6
RG727 N727 0 1e6
RG728 N728 0 1e6
RG729 N729 0 1e6
RG730 N730 0 1e6
RG731 N731 0 1e6
RG732 N732 0 1e6
RG733 N733 0 1e6
RG734 N734 0 1e6
RG735 N735 0 1e6
RG736 N736 0 1e6
RG737 N737 0 1e6
RG738 N738 0 1e6
RG739 N739 0 1e6
RG740 N740 0 1e6
RG741 N741 0 1e6
RG742 N742 0 1e6
RG743 N743 0 1e6
RG744 N744 0 1e6
RG745 N745 0 1e6
RG746 N746 0 1e6
RG747 N747 0 1e6
RG748 N748 0 1e6
RG749 N749 0 1e6
RG750 N750 0 1e6
RG751 N751 0 1e6
RG752 N752 0 1e6
RG753 N753 0 1e6
RG754 N754 0 1e6
RG755 N755 0 1e6
RG756 N756 0 1e6
RG757 N757 0 1e6
RG758 N758 0 1e6
RG759 N759 0 1e6
RG760 N760 0 1e6
RG761 N761 0 1e6
RG762 N762 0 1e6
RG763 N763 0 1e6
RG764 N764 0 1e6
RG765 N765 0 1e6
RG766 N766 0 1e6
RG767 N767 0 1e6
RG768 N768 0 1e6
RG769 N769 0 1e6
RG770 N770 0 1e6
RG771 N771 0 1e6
RG772 N772 0 1e6
RG773 N773 0 1e6
RG774 N774 0 1e6
RG775 N775 0 1e6
RG776 N776 0 1e6
RG777 N777 0 1e6
RG778 N778 0 1e6
RG779 N779 0 1e6
RG780 N780 0 1e6
RG781 N781 0 1e6
RG782 N782 0 1e6
RG783 N783 0 1e6
RG784 N784 0 1e6
RG785 N785 0 1e6
RG786 N786 0 1e6
RG787 N787 0 1e6
RG788 N788 0 1e6
RG789 N789 0 1e6
RG790 N790 0 1e6
RG791 N791 0 1e6
RG792 N792 0 1e6
RG793 N793 0 1e6
RG794 N794 0 1e6
RG795 N795 0 1e6
RG796 N796 0 1e6
RG797 N797 0 1e6
RG798 N798 0 1e6
RG799 N799 0 1e6
RG800 N800 0 1e6
RG801 N801 0 1e6
RG802 N802 0 1e6
RG803 N803 0 1e6
RG804 N804 0 1e6
RG805 N805 0 1e6
RG806 N806 0 1e6
RG807 N807 0 1e6
RG808 N808 0 1e6
RG809 N809 0 1e6
RG810 N810 0 1e6
RG811 N811 0 1e6
RG812 N812 0 1e6
RG813 N813 0 1e6
RG814 N814 0 1e6
RG815 N815 0 1e6
RG816 N816 0 1e6
RG817 N817 0 1e6
RG818 N818 0 1e6
RG819 N819 0 1e6
RG820 N820 0 1e6
RG821 N821 0 1e6
RG822 N822 0 1e6
RG823 N823 0 1e6
RG824 N824 0 1e6
RG825 N825 0 1e6
RG826 N826 0 1e6
RG827 N827 0 1e6
RG828 N828 0 1e6
RG829 N829 0 1e6
RG830 N830 0 1e6
RG831 N831 0 1e6
RG832 N832 0 1e6
RG833 N833 0 1e6
RG834 N834 0 1e6
RG835 N835 0 1e6
RG836 N836 0 1e6
RG837 N837 0 1e6
RG838 N838 0 1e6
RG839 N839 0 1e6
RG840 N840 0 1e6
RG841 N841 0 1e6
RG842 N842 0 1e6
RG843 N843 0 1e6
RG844 N844 0 1e6
RG845 N845 0 1e6
RG846 N846 0 1e6
RG847 N847 0 1e6
RG848 N848 0 1e6
RG849 N849 0 1e6
RG850 N850 0 1e6
RG851 N851 0 1e6
RG852 N852 0 1e6
RG853 N853 0 1e6
RG854 N854 0 1e6
RG855 N855 0 1e6
RG856 N856 0 1e6
RG857 N857 0 1e6
RG858 N858 0 1e6
RG859 N859 0 1e6
RG860 N860 0 1e6
RG861 N861 0 1e6
RG862 N862 0 1e6
RG863 N863 0 1e6
RG864 N864 0 1e6
RG865 N865 0 1e6
RG866 N866 0 1e6
RG867 N867 0 1e6
RG868 N868 0 1e6
RG869 N869 0 1e6
RG870 N870 0 1e6
RG871 N871 0 1e6
RG872 N872 0 1e6
RG873 N873 0 1e6
RG874 N874 0 1e6
RG875 N875 0 1e6
RG876 N876 0 1e6
RG877 N877 0 1e6
RG878 N878 0 1e6
RG879 N879 0 1e6
RG880 N880 0 1e6
RG881 N881 0 1e6
RG882 N882 0 1e6
RG883 N883 0 1e6
RG884 N884 0 1e6
RG885 N885 0 1e6
RG886 N886 0 1e6
RG887 N887 0 1e6
RG888 N888 0 1e6
RG889 N889 0 1e6
RG890 N890 0 1e6
RG891 N891 0 1e6
RG892 N892 0 1e6
RG893 N893 0 1e6
RG894 N894 0 1e6
RG895 N895 0 1e6
RG896 N896 0 1e6
RG897 N897 0 1e6
RG898 N898 0 1e6
RG899 N899 0 1e6
RG900 N900 0 1e6
RG901 N901 0 1e6
RG902 N902 0 1e6
RG903 N903 0 1e6
RG904 N904 0 1e6
RG905 N905 0 1e6
RG906 N906 0 1e6
RG907 N907 0 1e6
RG908 N908 0 1e6
RG909 N909 0 1e6
RG910 N910 0 1e6
RG911 N911 0 1e6
RG912 N912 0 1e6
RG913 N913 0 1e6
RG914 N914 0 1e6
RG915 N915 0 1e6
RG916 N916 0 1e6
RG917 N917 0 1e6
RG918 N918 0 1e6
RG919 N919 0 1e6
RG920 N920 0 1e6
RG921 N921 0 1e6
RG922 N922 0 1e6
RG923 N923 0 1e6
RG924 N924 0 1e6
RG925 N925 0 1e6
RG926 N926 0 1e6
RG927 N927 0 1e6
RG928 N928 0 1e6
RG929 N929 0 1e6
RG930 N930 0 1e6
RG931 N931 0 1e6
RG932 N932 0 1e6
RG933 N933 0 1e6
RG934 N934 0 1e6
RG935 N935 0 1e6
RG936 N936 0 1e6
RG937 N937 0 1e6
RG938 N938 0 1e6
RG939 N939 0 1e6
RG940 N940 0 1e6
RG941 N941 0 1e6
RG942 N942 0 1e6
RG943 N943 0 1e6
RG944 N944 0 1e6
RG945 N945 0 1e6
RG946 N946 0 1e6
RG947 N947 0 1e6
RG948 N948 0 1e6
RG949 N949 0 1e6
RG950 N950 0 1e6
RG951 N951 0 1e6
RG952 N952 0 1e6
RG953 N953 0 1e6
RG954 N954 0 1e6
RG955 N955 0 1e6
RG956 N956 0 1e6
RG957 N957 0 1e6
RG958 N958 0 1e6
RG959 N959 0 1e6
RG960 N960 0 1e6
RG961 N961 0 1e6
RG962 N962 0 1e6
RG963 N963 0 1e6
RG964 N964 0 1e6
RG965 N965 0 1e6
RG966 N966 0 1e6
RG967 N967 0 1e6
RG968 N968 0 1e6
RG969 N969 0 1e6
RG970 N970 0 1e6
RG971 N971 0 1e6
RG972 N972 0 1e6
RG973 N973 0 1e6
RG974 N974 0 1e6
RG975 N975 0 1e6
RG976 N976 0 1e6
RG977 N977 0 1e6
RG978 N978 0 1e6
RG979 N979 0 1e6
RG980 N980 0 1e6
RG981 N981 0 1e6
RG982 N982 0 1e6
RG983 N983 0 1e6
RG984 N984 0 1e6
RG985 N985 0 1e6
RG986 N986 0 1e6
RG987 N987 0 1e6
RG988 N988 0 1e6
RG989 N989 0 1e6
RG990 N990 0 1e6
RG991 N991 0 1e6
RG992 N992 0 1e6
RG993 N993 0 1e6
RG994 N994 0 1e6
RG995 N995 0 1e6
RG996 N996 0 1e6
RG997 N997 0 1e6
RG998 N998 0 1e6
RG999 N999 0 1e6
RG1000 N1000 0 1e6
V1 N1 0 7
V2 N21 0 9
V3 N41 0 5
V4 N61 0 7
V5 N81 0 9
V6 N101 0 5
V7 N121 0 7
V8 N141 0 9
V9 N161 0 5
V10 N181 0 7
V11 N201 0 9
V12 N221 0 5
V13 N241 0 7
V14 N261 0 9
V15 N281 0 5
V16 N301 0 7
V17 N321 0 9
V18 N341 0 5
V19 N361 0 7
V20 N381 0 9
V21 N401 0 5
V22 N421 0 7
V23 N441 0 9
V24 N461 0 5
V25 N481 0 7
V26 N501 0 9
V27 N521 0 5
V28 N541 0 7
V29 N561 0 9
V30 N581 0 5
V31 N601 0 7
V32 N621 0 9
V33 N641 0 5
V34 N661 0 7
V35 N681 0 9
V36 N701 0 5
V37 N721 0 7
V38 N741 0 9
V39 N761 0 5
V40 N781 0 7
V41 N801 0 9
V42 N821 0 5
V43 N841 0 7
V44 N861 0 9
V45 N881 0 5
V46 N901 0 7
V47 N921 0 9
V48 N941 0 5
V49 N961 0 7
V50 N981 0 9
I1 N1 0 0.0009
I2 N31 0 0.0002
I3 N61 0 0.0007
I4 N91 0 0.0006
I5 N121 0 0.0010
I6 N151 0 0.0004
I7 N181 0 0.0005
I8 N211 0 0.0003
I9 N241 0 0.0002
I10 N271 0 0.0009
I11 N301 0 0.0005
I12 N331 0 0.0007
I13 N361 0 0.0007
I14 N391 0 0.0006
I15 N421 0 0.0001
I16 N451 0 0.0008
I17 N481 0 0.0003
I18 N511 0 0.0002
I19 N541 0 0.0006
I20 N571 0 0.0002
I21 N601 0 0.0008
I22 N631 0 0.0003
I23 N661 0 0.0003
I24 N691 0 0.0009
I25 N721 0 0.0004
I26 N751 0 0.0002
I27 N781 0 0.0009
I28 N811 0 0.0001
I29 N841 0 0.0009
I30 N871 0 0.0002
.DC V1 -5 5 0.1
.PLOT V(N11)
.DC V2 0 10 0.5
.PLOT V(N11)
