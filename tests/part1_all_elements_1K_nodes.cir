* SPICE netlist with 1000 Nodes

V1 n_1 0 5

R1 n_1 n_2 1e3
R2 n_2 n_3 1e3
R3 n_3 n_4 1e3
R4 n_4 n_5 1e3
R5 n_5 n_6 1e3
R6 n_6 n_7 1e3
R7 n_7 n_8 1e3
R8 n_8 n_9 1e3
R9 n_9 n_10 1e3
R10 n_10 n_11 1e3
R11 n_11 n_12 1e3
R12 n_12 n_13 1e3
R13 n_13 n_14 1e3
R14 n_14 n_15 1e3
R15 n_15 n_16 1e3
R16 n_16 n_17 1e3
R17 n_17 n_18 1e3
R18 n_18 n_19 1e3
R19 n_19 n_20 1e3
R20 n_20 n_21 1e3
R21 n_21 n_22 1e3
R22 n_22 n_23 1e3
R23 n_23 n_24 1e3
R24 n_24 n_25 1e3
R25 n_25 n_26 1e3
R26 n_26 n_27 1e3
R27 n_27 n_28 1e3
R28 n_28 n_29 1e3
R29 n_29 n_30 1e3
R30 n_30 n_31 1e3
R31 n_31 n_32 1e3
R32 n_32 n_33 1e3
R33 n_33 n_34 1e3
R34 n_34 n_35 1e3
R35 n_35 n_36 1e3
R36 n_36 n_37 1e3
R37 n_37 n_38 1e3
R38 n_38 n_39 1e3
R39 n_39 n_40 1e3
R40 n_40 n_41 1e3
R41 n_41 n_42 1e3
R42 n_42 n_43 1e3
R43 n_43 n_44 1e3
R44 n_44 n_45 1e3
R45 n_45 n_46 1e3
R46 n_46 n_47 1e3
R47 n_47 n_48 1e3
R48 n_48 n_49 1e3
R49 n_49 n_50 1e3
R50 n_50 n_51 1e3
R51 n_51 n_52 1e3
R52 n_52 n_53 1e3
R53 n_53 n_54 1e3
R54 n_54 n_55 1e3
R55 n_55 n_56 1e3
R56 n_56 n_57 1e3
R57 n_57 n_58 1e3
R58 n_58 n_59 1e3
R59 n_59 n_60 1e3
R60 n_60 n_61 1e3
R61 n_61 n_62 1e3
R62 n_62 n_63 1e3
R63 n_63 n_64 1e3
R64 n_64 n_65 1e3
R65 n_65 n_66 1e3
R66 n_66 n_67 1e3
R67 n_67 n_68 1e3
R68 n_68 n_69 1e3
R69 n_69 n_70 1e3
R70 n_70 n_71 1e3
R71 n_71 n_72 1e3
R72 n_72 n_73 1e3
R73 n_73 n_74 1e3
R74 n_74 n_75 1e3
R75 n_75 n_76 1e3
R76 n_76 n_77 1e3
R77 n_77 n_78 1e3
R78 n_78 n_79 1e3
R79 n_79 n_80 1e3
R80 n_80 n_81 1e3
R81 n_81 n_82 1e3
R82 n_82 n_83 1e3
R83 n_83 n_84 1e3
R84 n_84 n_85 1e3
R85 n_85 n_86 1e3
R86 n_86 n_87 1e3
R87 n_87 n_88 1e3
R88 n_88 n_89 1e3
R89 n_89 n_90 1e3
R90 n_90 n_91 1e3
R91 n_91 n_92 1e3
R92 n_92 n_93 1e3
R93 n_93 n_94 1e3
R94 n_94 n_95 1e3
R95 n_95 n_96 1e3
R96 n_96 n_97 1e3
R97 n_97 n_98 1e3
R98 n_98 n_99 1e3
R99 n_99 n_100 1e3
R100 n_100 n_101 1e3
R101 n_101 n_102 1e3
R102 n_102 n_103 1e3
R103 n_103 n_104 1e3
R104 n_104 n_105 1e3
R105 n_105 n_106 1e3
R106 n_106 n_107 1e3
R107 n_107 n_108 1e3
R108 n_108 n_109 1e3
R109 n_109 n_110 1e3
R110 n_110 n_111 1e3
R111 n_111 n_112 1e3
R112 n_112 n_113 1e3
R113 n_113 n_114 1e3
R114 n_114 n_115 1e3
R115 n_115 n_116 1e3
R116 n_116 n_117 1e3
R117 n_117 n_118 1e3
R118 n_118 n_119 1e3
R119 n_119 n_120 1e3
R120 n_120 n_121 1e3
R121 n_121 n_122 1e3
R122 n_122 n_123 1e3
R123 n_123 n_124 1e3
R124 n_124 n_125 1e3
R125 n_125 n_126 1e3
R126 n_126 n_127 1e3
R127 n_127 n_128 1e3
R128 n_128 n_129 1e3
R129 n_129 n_130 1e3
R130 n_130 n_131 1e3
R131 n_131 n_132 1e3
R132 n_132 n_133 1e3
R133 n_133 n_134 1e3
R134 n_134 n_135 1e3
R135 n_135 n_136 1e3
R136 n_136 n_137 1e3
R137 n_137 n_138 1e3
R138 n_138 n_139 1e3
R139 n_139 n_140 1e3
R140 n_140 n_141 1e3
R141 n_141 n_142 1e3
R142 n_142 n_143 1e3
R143 n_143 n_144 1e3
R144 n_144 n_145 1e3
R145 n_145 n_146 1e3
R146 n_146 n_147 1e3
R147 n_147 n_148 1e3
R148 n_148 n_149 1e3
R149 n_149 n_150 1e3
R150 n_150 n_151 1e3
R151 n_151 n_152 1e3
R152 n_152 n_153 1e3
R153 n_153 n_154 1e3
R154 n_154 n_155 1e3
R155 n_155 n_156 1e3
R156 n_156 n_157 1e3
R157 n_157 n_158 1e3
R158 n_158 n_159 1e3
R159 n_159 n_160 1e3
R160 n_160 n_161 1e3
R161 n_161 n_162 1e3
R162 n_162 n_163 1e3
R163 n_163 n_164 1e3
R164 n_164 n_165 1e3
R165 n_165 n_166 1e3
R166 n_166 n_167 1e3
R167 n_167 n_168 1e3
R168 n_168 n_169 1e3
R169 n_169 n_170 1e3
R170 n_170 n_171 1e3
R171 n_171 n_172 1e3
R172 n_172 n_173 1e3
R173 n_173 n_174 1e3
R174 n_174 n_175 1e3
R175 n_175 n_176 1e3
R176 n_176 n_177 1e3
R177 n_177 n_178 1e3
R178 n_178 n_179 1e3
R179 n_179 n_180 1e3
R180 n_180 n_181 1e3
R181 n_181 n_182 1e3
R182 n_182 n_183 1e3
R183 n_183 n_184 1e3
R184 n_184 n_185 1e3
R185 n_185 n_186 1e3
R186 n_186 n_187 1e3
R187 n_187 n_188 1e3
R188 n_188 n_189 1e3
R189 n_189 n_190 1e3
R190 n_190 n_191 1e3
R191 n_191 n_192 1e3
R192 n_192 n_193 1e3
R193 n_193 n_194 1e3
R194 n_194 n_195 1e3
R195 n_195 n_196 1e3
R196 n_196 n_197 1e3
R197 n_197 n_198 1e3
R198 n_198 n_199 1e3
R199 n_199 n_200 1e3
R200 n_200 n_201 1e3
R201 n_201 n_202 1e3
R202 n_202 n_203 1e3
R203 n_203 n_204 1e3
R204 n_204 n_205 1e3
R205 n_205 n_206 1e3
R206 n_206 n_207 1e3
R207 n_207 n_208 1e3
R208 n_208 n_209 1e3
R209 n_209 n_210 1e3
R210 n_210 n_211 1e3
R211 n_211 n_212 1e3
R212 n_212 n_213 1e3
R213 n_213 n_214 1e3
R214 n_214 n_215 1e3
R215 n_215 n_216 1e3
R216 n_216 n_217 1e3
R217 n_217 n_218 1e3
R218 n_218 n_219 1e3
R219 n_219 n_220 1e3
R220 n_220 n_221 1e3
R221 n_221 n_222 1e3
R222 n_222 n_223 1e3
R223 n_223 n_224 1e3
R224 n_224 n_225 1e3
R225 n_225 n_226 1e3
R226 n_226 n_227 1e3
R227 n_227 n_228 1e3
R228 n_228 n_229 1e3
R229 n_229 n_230 1e3
R230 n_230 n_231 1e3
R231 n_231 n_232 1e3
R232 n_232 n_233 1e3
R233 n_233 n_234 1e3
R234 n_234 n_235 1e3
R235 n_235 n_236 1e3
R236 n_236 n_237 1e3
R237 n_237 n_238 1e3
R238 n_238 n_239 1e3
R239 n_239 n_240 1e3
R240 n_240 n_241 1e3
R241 n_241 n_242 1e3
R242 n_242 n_243 1e3
R243 n_243 n_244 1e3
R244 n_244 n_245 1e3
R245 n_245 n_246 1e3
R246 n_246 n_247 1e3
R247 n_247 n_248 1e3
R248 n_248 n_249 1e3
R249 n_249 n_250 1e3
R250 n_250 n_251 1e3
R251 n_251 n_252 1e3
R252 n_252 n_253 1e3
R253 n_253 n_254 1e3
R254 n_254 n_255 1e3
R255 n_255 n_256 1e3
R256 n_256 n_257 1e3
R257 n_257 n_258 1e3
R258 n_258 n_259 1e3
R259 n_259 n_260 1e3
R260 n_260 n_261 1e3
R261 n_261 n_262 1e3
R262 n_262 n_263 1e3
R263 n_263 n_264 1e3
R264 n_264 n_265 1e3
R265 n_265 n_266 1e3
R266 n_266 n_267 1e3
R267 n_267 n_268 1e3
R268 n_268 n_269 1e3
R269 n_269 n_270 1e3
R270 n_270 n_271 1e3
R271 n_271 n_272 1e3
R272 n_272 n_273 1e3
R273 n_273 n_274 1e3
R274 n_274 n_275 1e3
R275 n_275 n_276 1e3
R276 n_276 n_277 1e3
R277 n_277 n_278 1e3
R278 n_278 n_279 1e3
R279 n_279 n_280 1e3
R280 n_280 n_281 1e3
R281 n_281 n_282 1e3
R282 n_282 n_283 1e3
R283 n_283 n_284 1e3
R284 n_284 n_285 1e3
R285 n_285 n_286 1e3
R286 n_286 n_287 1e3
R287 n_287 n_288 1e3
R288 n_288 n_289 1e3
R289 n_289 n_290 1e3
R290 n_290 n_291 1e3
R291 n_291 n_292 1e3
R292 n_292 n_293 1e3
R293 n_293 n_294 1e3
R294 n_294 n_295 1e3
R295 n_295 n_296 1e3
R296 n_296 n_297 1e3
R297 n_297 n_298 1e3
R298 n_298 n_299 1e3
R299 n_299 n_300 1e3
R300 n_300 n_301 1e3
R301 n_301 n_302 1e3
R302 n_302 n_303 1e3
R303 n_303 n_304 1e3
R304 n_304 n_305 1e3
R305 n_305 n_306 1e3
R306 n_306 n_307 1e3
R307 n_307 n_308 1e3
R308 n_308 n_309 1e3
R309 n_309 n_310 1e3
R310 n_310 n_311 1e3
R311 n_311 n_312 1e3
R312 n_312 n_313 1e3
R313 n_313 n_314 1e3
R314 n_314 n_315 1e3
R315 n_315 n_316 1e3
R316 n_316 n_317 1e3
R317 n_317 n_318 1e3
R318 n_318 n_319 1e3
R319 n_319 n_320 1e3
R320 n_320 n_321 1e3
R321 n_321 n_322 1e3
R322 n_322 n_323 1e3
R323 n_323 n_324 1e3
R324 n_324 n_325 1e3
R325 n_325 n_326 1e3
R326 n_326 n_327 1e3
R327 n_327 n_328 1e3
R328 n_328 n_329 1e3
R329 n_329 n_330 1e3
R330 n_330 n_331 1e3
R331 n_331 n_332 1e3
R332 n_332 n_333 1e3
R333 n_333 n_334 1e3
R334 n_334 n_335 1e3
R335 n_335 n_336 1e3
R336 n_336 n_337 1e3
R337 n_337 n_338 1e3
R338 n_338 n_339 1e3
R339 n_339 n_340 1e3
R340 n_340 n_341 1e3
R341 n_341 n_342 1e3
R342 n_342 n_343 1e3
R343 n_343 n_344 1e3
R344 n_344 n_345 1e3
R345 n_345 n_346 1e3
R346 n_346 n_347 1e3
R347 n_347 n_348 1e3
R348 n_348 n_349 1e3
R349 n_349 n_350 1e3
R350 n_350 n_351 1e3
R351 n_351 n_352 1e3
R352 n_352 n_353 1e3
R353 n_353 n_354 1e3
R354 n_354 n_355 1e3
R355 n_355 n_356 1e3
R356 n_356 n_357 1e3
R357 n_357 n_358 1e3
R358 n_358 n_359 1e3
R359 n_359 n_360 1e3
R360 n_360 n_361 1e3
R361 n_361 n_362 1e3
R362 n_362 n_363 1e3
R363 n_363 n_364 1e3
R364 n_364 n_365 1e3
R365 n_365 n_366 1e3
R366 n_366 n_367 1e3
R367 n_367 n_368 1e3
R368 n_368 n_369 1e3
R369 n_369 n_370 1e3
R370 n_370 n_371 1e3
R371 n_371 n_372 1e3
R372 n_372 n_373 1e3
R373 n_373 n_374 1e3
R374 n_374 n_375 1e3
R375 n_375 n_376 1e3
R376 n_376 n_377 1e3
R377 n_377 n_378 1e3
R378 n_378 n_379 1e3
R379 n_379 n_380 1e3
R380 n_380 n_381 1e3
R381 n_381 n_382 1e3
R382 n_382 n_383 1e3
R383 n_383 n_384 1e3
R384 n_384 n_385 1e3
R385 n_385 n_386 1e3
R386 n_386 n_387 1e3
R387 n_387 n_388 1e3
R388 n_388 n_389 1e3
R389 n_389 n_390 1e3
R390 n_390 n_391 1e3
R391 n_391 n_392 1e3
R392 n_392 n_393 1e3
R393 n_393 n_394 1e3
R394 n_394 n_395 1e3
R395 n_395 n_396 1e3
R396 n_396 n_397 1e3
R397 n_397 n_398 1e3
R398 n_398 n_399 1e3
R399 n_399 n_400 1e3
R400 n_400 n_401 1e3
R401 n_401 n_402 1e3
R402 n_402 n_403 1e3
R403 n_403 n_404 1e3
R404 n_404 n_405 1e3
R405 n_405 n_406 1e3
R406 n_406 n_407 1e3
R407 n_407 n_408 1e3
R408 n_408 n_409 1e3
R409 n_409 n_410 1e3
R410 n_410 n_411 1e3
R411 n_411 n_412 1e3
R412 n_412 n_413 1e3
R413 n_413 n_414 1e3
R414 n_414 n_415 1e3
R415 n_415 n_416 1e3
R416 n_416 n_417 1e3
R417 n_417 n_418 1e3
R418 n_418 n_419 1e3
R419 n_419 n_420 1e3
R420 n_420 n_421 1e3
R421 n_421 n_422 1e3
R422 n_422 n_423 1e3
R423 n_423 n_424 1e3
R424 n_424 n_425 1e3
R425 n_425 n_426 1e3
R426 n_426 n_427 1e3
R427 n_427 n_428 1e3
R428 n_428 n_429 1e3
R429 n_429 n_430 1e3
R430 n_430 n_431 1e3
R431 n_431 n_432 1e3
R432 n_432 n_433 1e3
R433 n_433 n_434 1e3
R434 n_434 n_435 1e3
R435 n_435 n_436 1e3
R436 n_436 n_437 1e3
R437 n_437 n_438 1e3
R438 n_438 n_439 1e3
R439 n_439 n_440 1e3
R440 n_440 n_441 1e3
R441 n_441 n_442 1e3
R442 n_442 n_443 1e3
R443 n_443 n_444 1e3
R444 n_444 n_445 1e3
R445 n_445 n_446 1e3
R446 n_446 n_447 1e3
R447 n_447 n_448 1e3
R448 n_448 n_449 1e3
R449 n_449 n_450 1e3
R450 n_450 n_451 1e3
R451 n_451 n_452 1e3
R452 n_452 n_453 1e3
R453 n_453 n_454 1e3
R454 n_454 n_455 1e3
R455 n_455 n_456 1e3
R456 n_456 n_457 1e3
R457 n_457 n_458 1e3
R458 n_458 n_459 1e3
R459 n_459 n_460 1e3
R460 n_460 n_461 1e3
R461 n_461 n_462 1e3
R462 n_462 n_463 1e3
R463 n_463 n_464 1e3
R464 n_464 n_465 1e3
R465 n_465 n_466 1e3
R466 n_466 n_467 1e3
R467 n_467 n_468 1e3
R468 n_468 n_469 1e3
R469 n_469 n_470 1e3
R470 n_470 n_471 1e3
R471 n_471 n_472 1e3
R472 n_472 n_473 1e3
R473 n_473 n_474 1e3
R474 n_474 n_475 1e3
R475 n_475 n_476 1e3
R476 n_476 n_477 1e3
R477 n_477 n_478 1e3
R478 n_478 n_479 1e3
R479 n_479 n_480 1e3
R480 n_480 n_481 1e3
R481 n_481 n_482 1e3
R482 n_482 n_483 1e3
R483 n_483 n_484 1e3
R484 n_484 n_485 1e3
R485 n_485 n_486 1e3
R486 n_486 n_487 1e3
R487 n_487 n_488 1e3
R488 n_488 n_489 1e3
R489 n_489 n_490 1e3
R490 n_490 n_491 1e3
R491 n_491 n_492 1e3
R492 n_492 n_493 1e3
R493 n_493 n_494 1e3
R494 n_494 n_495 1e3
R495 n_495 n_496 1e3
R496 n_496 n_497 1e3
R497 n_497 n_498 1e3
R498 n_498 n_499 1e3
R499 n_499 n_500 1e3
R500 n_500 n_501 1e3
R501 n_501 n_502 1e3
R502 n_502 n_503 1e3
R503 n_503 n_504 1e3
R504 n_504 n_505 1e3
R505 n_505 n_506 1e3
R506 n_506 n_507 1e3
R507 n_507 n_508 1e3
R508 n_508 n_509 1e3
R509 n_509 n_510 1e3
R510 n_510 n_511 1e3
R511 n_511 n_512 1e3
R512 n_512 n_513 1e3
R513 n_513 n_514 1e3
R514 n_514 n_515 1e3
R515 n_515 n_516 1e3
R516 n_516 n_517 1e3
R517 n_517 n_518 1e3
R518 n_518 n_519 1e3
R519 n_519 n_520 1e3
R520 n_520 n_521 1e3
R521 n_521 n_522 1e3
R522 n_522 n_523 1e3
R523 n_523 n_524 1e3
R524 n_524 n_525 1e3
R525 n_525 n_526 1e3
R526 n_526 n_527 1e3
R527 n_527 n_528 1e3
R528 n_528 n_529 1e3
R529 n_529 n_530 1e3
R530 n_530 n_531 1e3
R531 n_531 n_532 1e3
R532 n_532 n_533 1e3
R533 n_533 n_534 1e3
R534 n_534 n_535 1e3
R535 n_535 n_536 1e3
R536 n_536 n_537 1e3
R537 n_537 n_538 1e3
R538 n_538 n_539 1e3
R539 n_539 n_540 1e3
R540 n_540 n_541 1e3
R541 n_541 n_542 1e3
R542 n_542 n_543 1e3
R543 n_543 n_544 1e3
R544 n_544 n_545 1e3
R545 n_545 n_546 1e3
R546 n_546 n_547 1e3
R547 n_547 n_548 1e3
R548 n_548 n_549 1e3
R549 n_549 n_550 1e3
R550 n_550 n_551 1e3
R551 n_551 n_552 1e3
R552 n_552 n_553 1e3
R553 n_553 n_554 1e3
R554 n_554 n_555 1e3
R555 n_555 n_556 1e3
R556 n_556 n_557 1e3
R557 n_557 n_558 1e3
R558 n_558 n_559 1e3
R559 n_559 n_560 1e3
R560 n_560 n_561 1e3
R561 n_561 n_562 1e3
R562 n_562 n_563 1e3
R563 n_563 n_564 1e3
R564 n_564 n_565 1e3
R565 n_565 n_566 1e3
R566 n_566 n_567 1e3
R567 n_567 n_568 1e3
R568 n_568 n_569 1e3
R569 n_569 n_570 1e3
R570 n_570 n_571 1e3
R571 n_571 n_572 1e3
R572 n_572 n_573 1e3
R573 n_573 n_574 1e3
R574 n_574 n_575 1e3
R575 n_575 n_576 1e3
R576 n_576 n_577 1e3
R577 n_577 n_578 1e3
R578 n_578 n_579 1e3
R579 n_579 n_580 1e3
R580 n_580 n_581 1e3
R581 n_581 n_582 1e3
R582 n_582 n_583 1e3
R583 n_583 n_584 1e3
R584 n_584 n_585 1e3
R585 n_585 n_586 1e3
R586 n_586 n_587 1e3
R587 n_587 n_588 1e3
R588 n_588 n_589 1e3
R589 n_589 n_590 1e3
R590 n_590 n_591 1e3
R591 n_591 n_592 1e3
R592 n_592 n_593 1e3
R593 n_593 n_594 1e3
R594 n_594 n_595 1e3
R595 n_595 n_596 1e3
R596 n_596 n_597 1e3
R597 n_597 n_598 1e3
R598 n_598 n_599 1e3
R599 n_599 n_600 1e3
R600 n_600 n_601 1e3
R601 n_601 n_602 1e3
R602 n_602 n_603 1e3
R603 n_603 n_604 1e3
R604 n_604 n_605 1e3
R605 n_605 n_606 1e3
R606 n_606 n_607 1e3
R607 n_607 n_608 1e3
R608 n_608 n_609 1e3
R609 n_609 n_610 1e3
R610 n_610 n_611 1e3
R611 n_611 n_612 1e3
R612 n_612 n_613 1e3
R613 n_613 n_614 1e3
R614 n_614 n_615 1e3
R615 n_615 n_616 1e3
R616 n_616 n_617 1e3
R617 n_617 n_618 1e3
R618 n_618 n_619 1e3
R619 n_619 n_620 1e3
R620 n_620 n_621 1e3
R621 n_621 n_622 1e3
R622 n_622 n_623 1e3
R623 n_623 n_624 1e3
R624 n_624 n_625 1e3
R625 n_625 n_626 1e3
R626 n_626 n_627 1e3
R627 n_627 n_628 1e3
R628 n_628 n_629 1e3
R629 n_629 n_630 1e3
R630 n_630 n_631 1e3
R631 n_631 n_632 1e3
R632 n_632 n_633 1e3
R633 n_633 n_634 1e3
R634 n_634 n_635 1e3
R635 n_635 n_636 1e3
R636 n_636 n_637 1e3
R637 n_637 n_638 1e3
R638 n_638 n_639 1e3
R639 n_639 n_640 1e3
R640 n_640 n_641 1e3
R641 n_641 n_642 1e3
R642 n_642 n_643 1e3
R643 n_643 n_644 1e3
R644 n_644 n_645 1e3
R645 n_645 n_646 1e3
R646 n_646 n_647 1e3
R647 n_647 n_648 1e3
R648 n_648 n_649 1e3
R649 n_649 n_650 1e3
R650 n_650 n_651 1e3
R651 n_651 n_652 1e3
R652 n_652 n_653 1e3
R653 n_653 n_654 1e3
R654 n_654 n_655 1e3
R655 n_655 n_656 1e3
R656 n_656 n_657 1e3
R657 n_657 n_658 1e3
R658 n_658 n_659 1e3
R659 n_659 n_660 1e3
R660 n_660 n_661 1e3
R661 n_661 n_662 1e3
R662 n_662 n_663 1e3
R663 n_663 n_664 1e3
R664 n_664 n_665 1e3
R665 n_665 n_666 1e3
R666 n_666 n_667 1e3
R667 n_667 n_668 1e3
R668 n_668 n_669 1e3
R669 n_669 n_670 1e3
R670 n_670 n_671 1e3
R671 n_671 n_672 1e3
R672 n_672 n_673 1e3
R673 n_673 n_674 1e3
R674 n_674 n_675 1e3
R675 n_675 n_676 1e3
R676 n_676 n_677 1e3
R677 n_677 n_678 1e3
R678 n_678 n_679 1e3
R679 n_679 n_680 1e3
R680 n_680 n_681 1e3
R681 n_681 n_682 1e3
R682 n_682 n_683 1e3
R683 n_683 n_684 1e3
R684 n_684 n_685 1e3
R685 n_685 n_686 1e3
R686 n_686 n_687 1e3
R687 n_687 n_688 1e3
R688 n_688 n_689 1e3
R689 n_689 n_690 1e3
R690 n_690 n_691 1e3
R691 n_691 n_692 1e3
R692 n_692 n_693 1e3
R693 n_693 n_694 1e3
R694 n_694 n_695 1e3
R695 n_695 n_696 1e3
R696 n_696 n_697 1e3
R697 n_697 n_698 1e3
R698 n_698 n_699 1e3
R699 n_699 n_700 1e3
R700 n_700 n_701 1e3
R701 n_701 n_702 1e3
R702 n_702 n_703 1e3
R703 n_703 n_704 1e3
R704 n_704 n_705 1e3
R705 n_705 n_706 1e3
R706 n_706 n_707 1e3
R707 n_707 n_708 1e3
R708 n_708 n_709 1e3
R709 n_709 n_710 1e3
R710 n_710 n_711 1e3
R711 n_711 n_712 1e3
R712 n_712 n_713 1e3
R713 n_713 n_714 1e3
R714 n_714 n_715 1e3
R715 n_715 n_716 1e3
R716 n_716 n_717 1e3
R717 n_717 n_718 1e3
R718 n_718 n_719 1e3
R719 n_719 n_720 1e3
R720 n_720 n_721 1e3
R721 n_721 n_722 1e3
R722 n_722 n_723 1e3
R723 n_723 n_724 1e3
R724 n_724 n_725 1e3
R725 n_725 n_726 1e3
R726 n_726 n_727 1e3
R727 n_727 n_728 1e3
R728 n_728 n_729 1e3
R729 n_729 n_730 1e3
R730 n_730 n_731 1e3
R731 n_731 n_732 1e3
R732 n_732 n_733 1e3
R733 n_733 n_734 1e3
R734 n_734 n_735 1e3
R735 n_735 n_736 1e3
R736 n_736 n_737 1e3
R737 n_737 n_738 1e3
R738 n_738 n_739 1e3
R739 n_739 n_740 1e3
R740 n_740 n_741 1e3
R741 n_741 n_742 1e3
R742 n_742 n_743 1e3
R743 n_743 n_744 1e3
R744 n_744 n_745 1e3
R745 n_745 n_746 1e3
R746 n_746 n_747 1e3
R747 n_747 n_748 1e3
R748 n_748 n_749 1e3
R749 n_749 n_750 1e3
R750 n_750 n_751 1e3
R751 n_751 n_752 1e3
R752 n_752 n_753 1e3
R753 n_753 n_754 1e3
R754 n_754 n_755 1e3
R755 n_755 n_756 1e3
R756 n_756 n_757 1e3
R757 n_757 n_758 1e3
R758 n_758 n_759 1e3
R759 n_759 n_760 1e3
R760 n_760 n_761 1e3
R761 n_761 n_762 1e3
R762 n_762 n_763 1e3
R763 n_763 n_764 1e3
R764 n_764 n_765 1e3
R765 n_765 n_766 1e3
R766 n_766 n_767 1e3
R767 n_767 n_768 1e3
R768 n_768 n_769 1e3
R769 n_769 n_770 1e3
R770 n_770 n_771 1e3
R771 n_771 n_772 1e3
R772 n_772 n_773 1e3
R773 n_773 n_774 1e3
R774 n_774 n_775 1e3
R775 n_775 n_776 1e3
R776 n_776 n_777 1e3
R777 n_777 n_778 1e3
R778 n_778 n_779 1e3
R779 n_779 n_780 1e3
R780 n_780 n_781 1e3
R781 n_781 n_782 1e3
R782 n_782 n_783 1e3
R783 n_783 n_784 1e3
R784 n_784 n_785 1e3
R785 n_785 n_786 1e3
R786 n_786 n_787 1e3
R787 n_787 n_788 1e3
R788 n_788 n_789 1e3
R789 n_789 n_790 1e3
R790 n_790 n_791 1e3
R791 n_791 n_792 1e3
R792 n_792 n_793 1e3
R793 n_793 n_794 1e3
R794 n_794 n_795 1e3
R795 n_795 n_796 1e3
R796 n_796 n_797 1e3
R797 n_797 n_798 1e3
R798 n_798 n_799 1e3
R799 n_799 n_800 1e3
R800 n_800 n_801 1e3
R801 n_801 n_802 1e3
R802 n_802 n_803 1e3
R803 n_803 n_804 1e3
R804 n_804 n_805 1e3
R805 n_805 n_806 1e3
R806 n_806 n_807 1e3
R807 n_807 n_808 1e3
R808 n_808 n_809 1e3
R809 n_809 n_810 1e3
R810 n_810 n_811 1e3
R811 n_811 n_812 1e3
R812 n_812 n_813 1e3
R813 n_813 n_814 1e3
R814 n_814 n_815 1e3
R815 n_815 n_816 1e3
R816 n_816 n_817 1e3
R817 n_817 n_818 1e3
R818 n_818 n_819 1e3
R819 n_819 n_820 1e3
R820 n_820 n_821 1e3
R821 n_821 n_822 1e3
R822 n_822 n_823 1e3
R823 n_823 n_824 1e3
R824 n_824 n_825 1e3
R825 n_825 n_826 1e3
R826 n_826 n_827 1e3
R827 n_827 n_828 1e3
R828 n_828 n_829 1e3
R829 n_829 n_830 1e3
R830 n_830 n_831 1e3
R831 n_831 n_832 1e3
R832 n_832 n_833 1e3
R833 n_833 n_834 1e3
R834 n_834 n_835 1e3
R835 n_835 n_836 1e3
R836 n_836 n_837 1e3
R837 n_837 n_838 1e3
R838 n_838 n_839 1e3
R839 n_839 n_840 1e3
R840 n_840 n_841 1e3
R841 n_841 n_842 1e3
R842 n_842 n_843 1e3
R843 n_843 n_844 1e3
R844 n_844 n_845 1e3
R845 n_845 n_846 1e3
R846 n_846 n_847 1e3
R847 n_847 n_848 1e3
R848 n_848 n_849 1e3
R849 n_849 n_850 1e3
R850 n_850 n_851 1e3
R851 n_851 n_852 1e3
R852 n_852 n_853 1e3
R853 n_853 n_854 1e3
R854 n_854 n_855 1e3
R855 n_855 n_856 1e3
R856 n_856 n_857 1e3
R857 n_857 n_858 1e3
R858 n_858 n_859 1e3
R859 n_859 n_860 1e3
R860 n_860 n_861 1e3
R861 n_861 n_862 1e3
R862 n_862 n_863 1e3
R863 n_863 n_864 1e3
R864 n_864 n_865 1e3
R865 n_865 n_866 1e3
R866 n_866 n_867 1e3
R867 n_867 n_868 1e3
R868 n_868 n_869 1e3
R869 n_869 n_870 1e3
R870 n_870 n_871 1e3
R871 n_871 n_872 1e3
R872 n_872 n_873 1e3
R873 n_873 n_874 1e3
R874 n_874 n_875 1e3
R875 n_875 n_876 1e3
R876 n_876 n_877 1e3
R877 n_877 n_878 1e3
R878 n_878 n_879 1e3
R879 n_879 n_880 1e3
R880 n_880 n_881 1e3
R881 n_881 n_882 1e3
R882 n_882 n_883 1e3
R883 n_883 n_884 1e3
R884 n_884 n_885 1e3
R885 n_885 n_886 1e3
R886 n_886 n_887 1e3
R887 n_887 n_888 1e3
R888 n_888 n_889 1e3
R889 n_889 n_890 1e3
R890 n_890 n_891 1e3
R891 n_891 n_892 1e3
R892 n_892 n_893 1e3
R893 n_893 n_894 1e3
R894 n_894 n_895 1e3
R895 n_895 n_896 1e3
R896 n_896 n_897 1e3
R897 n_897 n_898 1e3
R898 n_898 n_899 1e3
R899 n_899 n_900 1e3
R900 n_900 n_901 1e3
R901 n_901 n_902 1e3
R902 n_902 n_903 1e3
R903 n_903 n_904 1e3
R904 n_904 n_905 1e3
R905 n_905 n_906 1e3
R906 n_906 n_907 1e3
R907 n_907 n_908 1e3
R908 n_908 n_909 1e3
R909 n_909 n_910 1e3
R910 n_910 n_911 1e3
R911 n_911 n_912 1e3
R912 n_912 n_913 1e3
R913 n_913 n_914 1e3
R914 n_914 n_915 1e3
R915 n_915 n_916 1e3
R916 n_916 n_917 1e3
R917 n_917 n_918 1e3
R918 n_918 n_919 1e3
R919 n_919 n_920 1e3
R920 n_920 n_921 1e3
R921 n_921 n_922 1e3
R922 n_922 n_923 1e3
R923 n_923 n_924 1e3
R924 n_924 n_925 1e3
R925 n_925 n_926 1e3
R926 n_926 n_927 1e3
R927 n_927 n_928 1e3
R928 n_928 n_929 1e3
R929 n_929 n_930 1e3
R930 n_930 n_931 1e3
R931 n_931 n_932 1e3
R932 n_932 n_933 1e3
R933 n_933 n_934 1e3
R934 n_934 n_935 1e3
R935 n_935 n_936 1e3
R936 n_936 n_937 1e3
R937 n_937 n_938 1e3
R938 n_938 n_939 1e3
R939 n_939 n_940 1e3
R940 n_940 n_941 1e3
R941 n_941 n_942 1e3
R942 n_942 n_943 1e3
R943 n_943 n_944 1e3
R944 n_944 n_945 1e3
R945 n_945 n_946 1e3
R946 n_946 n_947 1e3
R947 n_947 n_948 1e3
R948 n_948 n_949 1e3
R949 n_949 n_950 1e3
R950 n_950 n_951 1e3
R951 n_951 n_952 1e3
R952 n_952 n_953 1e3
R953 n_953 n_954 1e3
R954 n_954 n_955 1e3
R955 n_955 n_956 1e3
R956 n_956 n_957 1e3
R957 n_957 n_958 1e3
R958 n_958 n_959 1e3
R959 n_959 n_960 1e3
R960 n_960 n_961 1e3
R961 n_961 n_962 1e3
R962 n_962 n_963 1e3
R963 n_963 n_964 1e3
R964 n_964 n_965 1e3
R965 n_965 n_966 1e3
R966 n_966 n_967 1e3
R967 n_967 n_968 1e3
R968 n_968 n_969 1e3
R969 n_969 n_970 1e3
R970 n_970 n_971 1e3
R971 n_971 n_972 1e3
R972 n_972 n_973 1e3
R973 n_973 n_974 1e3
R974 n_974 n_975 1e3
R975 n_975 n_976 1e3
R976 n_976 n_977 1e3
R977 n_977 n_978 1e3
R978 n_978 n_979 1e3
R979 n_979 n_980 1e3
R980 n_980 n_981 1e3
R981 n_981 n_982 1e3
R982 n_982 n_983 1e3
R983 n_983 n_984 1e3
R984 n_984 n_985 1e3
R985 n_985 n_986 1e3
R986 n_986 n_987 1e3
R987 n_987 n_988 1e3
R988 n_988 n_989 1e3
R989 n_989 n_990 1e3
R990 n_990 n_991 1e3
R991 n_991 n_992 1e3
R992 n_992 n_993 1e3
R993 n_993 n_994 1e3
R994 n_994 n_995 1e3
R995 n_995 n_996 1e3
R996 n_996 n_997 1e3
R997 n_997 n_998 1e3
R998 n_998 n_999 1e3
R999 n_999 n_1000 1e3
C1 n_1 0 1e-6
C11 n_11 0 1e-6
C21 n_21 0 1e-6
C31 n_31 0 1e-6
C41 n_41 0 1e-6
C51 n_51 0 1e-6
C61 n_61 0 1e-6
C71 n_71 0 1e-6
C81 n_81 0 1e-6
C91 n_91 0 1e-6
C101 n_101 0 1e-6
C111 n_111 0 1e-6
C121 n_121 0 1e-6
C131 n_131 0 1e-6
C141 n_141 0 1e-6
C151 n_151 0 1e-6
C161 n_161 0 1e-6
C171 n_171 0 1e-6
C181 n_181 0 1e-6
C191 n_191 0 1e-6
C201 n_201 0 1e-6
C211 n_211 0 1e-6
C221 n_221 0 1e-6
C231 n_231 0 1e-6
C241 n_241 0 1e-6
C251 n_251 0 1e-6
C261 n_261 0 1e-6
C271 n_271 0 1e-6
C281 n_281 0 1e-6
C291 n_291 0 1e-6
C301 n_301 0 1e-6
C311 n_311 0 1e-6
C321 n_321 0 1e-6
C331 n_331 0 1e-6
C341 n_341 0 1e-6
C351 n_351 0 1e-6
C361 n_361 0 1e-6
C371 n_371 0 1e-6
C381 n_381 0 1e-6
C391 n_391 0 1e-6
C401 n_401 0 1e-6
C411 n_411 0 1e-6
C421 n_421 0 1e-6
C431 n_431 0 1e-6
C441 n_441 0 1e-6
C451 n_451 0 1e-6
C461 n_461 0 1e-6
C471 n_471 0 1e-6
C481 n_481 0 1e-6
C491 n_491 0 1e-6
C501 n_501 0 1e-6
C511 n_511 0 1e-6
C521 n_521 0 1e-6
C531 n_531 0 1e-6
C541 n_541 0 1e-6
C551 n_551 0 1e-6
C561 n_561 0 1e-6
C571 n_571 0 1e-6
C581 n_581 0 1e-6
C591 n_591 0 1e-6
C601 n_601 0 1e-6
C611 n_611 0 1e-6
C621 n_621 0 1e-6
C631 n_631 0 1e-6
C641 n_641 0 1e-6
C651 n_651 0 1e-6
C661 n_661 0 1e-6
C671 n_671 0 1e-6
C681 n_681 0 1e-6
C691 n_691 0 1e-6
C701 n_701 0 1e-6
C711 n_711 0 1e-6
C721 n_721 0 1e-6
C731 n_731 0 1e-6
C741 n_741 0 1e-6
C751 n_751 0 1e-6
C761 n_761 0 1e-6
C771 n_771 0 1e-6
C781 n_781 0 1e-6
C791 n_791 0 1e-6
C801 n_801 0 1e-6
C811 n_811 0 1e-6
C821 n_821 0 1e-6
C831 n_831 0 1e-6
C841 n_841 0 1e-6
C851 n_851 0 1e-6
C861 n_861 0 1e-6
C871 n_871 0 1e-6
C881 n_881 0 1e-6
C891 n_891 0 1e-6
C901 n_901 0 1e-6
C911 n_911 0 1e-6
C921 n_921 0 1e-6
C931 n_931 0 1e-6
C941 n_941 0 1e-6
C951 n_951 0 1e-6
C961 n_961 0 1e-6
C971 n_971 0 1e-6
C981 n_981 0 1e-6
C991 n_991 0 1e-6
L1 n_1 n_2 10e-3
L6 n_6 n_7 10e-3
L11 n_11 n_12 10e-3
L16 n_16 n_17 10e-3
L21 n_21 n_22 10e-3
L26 n_26 n_27 10e-3
L31 n_31 n_32 10e-3
L36 n_36 n_37 10e-3
L41 n_41 n_42 10e-3
L46 n_46 n_47 10e-3
L51 n_51 n_52 10e-3
L56 n_56 n_57 10e-3
L61 n_61 n_62 10e-3
L66 n_66 n_67 10e-3
L71 n_71 n_72 10e-3
L76 n_76 n_77 10e-3
L81 n_81 n_82 10e-3
L86 n_86 n_87 10e-3
L91 n_91 n_92 10e-3
L96 n_96 n_97 10e-3
L101 n_101 n_102 10e-3
L106 n_106 n_107 10e-3
L111 n_111 n_112 10e-3
L116 n_116 n_117 10e-3
L121 n_121 n_122 10e-3
L126 n_126 n_127 10e-3
L131 n_131 n_132 10e-3
L136 n_136 n_137 10e-3
L141 n_141 n_142 10e-3
L146 n_146 n_147 10e-3
L151 n_151 n_152 10e-3
L156 n_156 n_157 10e-3
L161 n_161 n_162 10e-3
L166 n_166 n_167 10e-3
L171 n_171 n_172 10e-3
L176 n_176 n_177 10e-3
L181 n_181 n_182 10e-3
L186 n_186 n_187 10e-3
L191 n_191 n_192 10e-3
L196 n_196 n_197 10e-3
L201 n_201 n_202 10e-3
L206 n_206 n_207 10e-3
L211 n_211 n_212 10e-3
L216 n_216 n_217 10e-3
L221 n_221 n_222 10e-3
L226 n_226 n_227 10e-3
L231 n_231 n_232 10e-3
L236 n_236 n_237 10e-3
L241 n_241 n_242 10e-3
L246 n_246 n_247 10e-3
L251 n_251 n_252 10e-3
L256 n_256 n_257 10e-3
L261 n_261 n_262 10e-3
L266 n_266 n_267 10e-3
L271 n_271 n_272 10e-3
L276 n_276 n_277 10e-3
L281 n_281 n_282 10e-3
L286 n_286 n_287 10e-3
L291 n_291 n_292 10e-3
L296 n_296 n_297 10e-3
L301 n_301 n_302 10e-3
L306 n_306 n_307 10e-3
L311 n_311 n_312 10e-3
L316 n_316 n_317 10e-3
L321 n_321 n_322 10e-3
L326 n_326 n_327 10e-3
L331 n_331 n_332 10e-3
L336 n_336 n_337 10e-3
L341 n_341 n_342 10e-3
L346 n_346 n_347 10e-3
L351 n_351 n_352 10e-3
L356 n_356 n_357 10e-3
L361 n_361 n_362 10e-3
L366 n_366 n_367 10e-3
L371 n_371 n_372 10e-3
L376 n_376 n_377 10e-3
L381 n_381 n_382 10e-3
L386 n_386 n_387 10e-3
L391 n_391 n_392 10e-3
L396 n_396 n_397 10e-3
L401 n_401 n_402 10e-3
L406 n_406 n_407 10e-3
L411 n_411 n_412 10e-3
L416 n_416 n_417 10e-3
L421 n_421 n_422 10e-3
L426 n_426 n_427 10e-3
L431 n_431 n_432 10e-3
L436 n_436 n_437 10e-3
L441 n_441 n_442 10e-3
L446 n_446 n_447 10e-3
L451 n_451 n_452 10e-3
L456 n_456 n_457 10e-3
L461 n_461 n_462 10e-3
L466 n_466 n_467 10e-3
L471 n_471 n_472 10e-3
L476 n_476 n_477 10e-3
L481 n_481 n_482 10e-3
L486 n_486 n_487 10e-3
L491 n_491 n_492 10e-3
L496 n_496 n_497 10e-3
L501 n_501 n_502 10e-3
L506 n_506 n_507 10e-3
L511 n_511 n_512 10e-3
L516 n_516 n_517 10e-3
L521 n_521 n_522 10e-3
L526 n_526 n_527 10e-3
L531 n_531 n_532 10e-3
L536 n_536 n_537 10e-3
L541 n_541 n_542 10e-3
L546 n_546 n_547 10e-3
L551 n_551 n_552 10e-3
L556 n_556 n_557 10e-3
L561 n_561 n_562 10e-3
L566 n_566 n_567 10e-3
L571 n_571 n_572 10e-3
L576 n_576 n_577 10e-3
L581 n_581 n_582 10e-3
L586 n_586 n_587 10e-3
L591 n_591 n_592 10e-3
L596 n_596 n_597 10e-3
L601 n_601 n_602 10e-3
L606 n_606 n_607 10e-3
L611 n_611 n_612 10e-3
L616 n_616 n_617 10e-3
L621 n_621 n_622 10e-3
L626 n_626 n_627 10e-3
L631 n_631 n_632 10e-3
L636 n_636 n_637 10e-3
L641 n_641 n_642 10e-3
L646 n_646 n_647 10e-3
L651 n_651 n_652 10e-3
L656 n_656 n_657 10e-3
L661 n_661 n_662 10e-3
L666 n_666 n_667 10e-3
L671 n_671 n_672 10e-3
L676 n_676 n_677 10e-3
L681 n_681 n_682 10e-3
L686 n_686 n_687 10e-3
L691 n_691 n_692 10e-3
L696 n_696 n_697 10e-3
L701 n_701 n_702 10e-3
L706 n_706 n_707 10e-3
L711 n_711 n_712 10e-3
L716 n_716 n_717 10e-3
L721 n_721 n_722 10e-3
L726 n_726 n_727 10e-3
L731 n_731 n_732 10e-3
L736 n_736 n_737 10e-3
L741 n_741 n_742 10e-3
L746 n_746 n_747 10e-3
L751 n_751 n_752 10e-3
L756 n_756 n_757 10e-3
L761 n_761 n_762 10e-3
L766 n_766 n_767 10e-3
L771 n_771 n_772 10e-3
L776 n_776 n_777 10e-3
L781 n_781 n_782 10e-3
L786 n_786 n_787 10e-3
L791 n_791 n_792 10e-3
L796 n_796 n_797 10e-3
L801 n_801 n_802 10e-3
L806 n_806 n_807 10e-3
L811 n_811 n_812 10e-3
L816 n_816 n_817 10e-3
L821 n_821 n_822 10e-3
L826 n_826 n_827 10e-3
L831 n_831 n_832 10e-3
L836 n_836 n_837 10e-3
L841 n_841 n_842 10e-3
L846 n_846 n_847 10e-3
L851 n_851 n_852 10e-3
L856 n_856 n_857 10e-3
L861 n_861 n_862 10e-3
L866 n_866 n_867 10e-3
L871 n_871 n_872 10e-3
L876 n_876 n_877 10e-3
L881 n_881 n_882 10e-3
L886 n_886 n_887 10e-3
L891 n_891 n_892 10e-3
L896 n_896 n_897 10e-3
L901 n_901 n_902 10e-3
L906 n_906 n_907 10e-3
L911 n_911 n_912 10e-3
L916 n_916 n_917 10e-3
L921 n_921 n_922 10e-3
L926 n_926 n_927 10e-3
L931 n_931 n_932 10e-3
L936 n_936 n_937 10e-3
L941 n_941 n_942 10e-3
L946 n_946 n_947 10e-3
L951 n_951 n_952 10e-3
L956 n_956 n_957 10e-3
L961 n_961 n_962 10e-3
L966 n_966 n_967 10e-3
L971 n_971 n_972 10e-3
L976 n_976 n_977 10e-3
L981 n_981 n_982 10e-3
L986 n_986 n_987 10e-3
L991 n_991 n_992 10e-3
L996 n_996 n_997 10e-3
D1 n_1 n_2 DModel
D21 n_21 n_22 DModel
D41 n_41 n_42 DModel
D61 n_61 n_62 DModel
D81 n_81 n_82 DModel
D101 n_101 n_102 DModel
D121 n_121 n_122 DModel
D141 n_141 n_142 DModel
D161 n_161 n_162 DModel
D181 n_181 n_182 DModel
D201 n_201 n_202 DModel
D221 n_221 n_222 DModel
D241 n_241 n_242 DModel
D261 n_261 n_262 DModel
D281 n_281 n_282 DModel
D301 n_301 n_302 DModel
D321 n_321 n_322 DModel
D341 n_341 n_342 DModel
D361 n_361 n_362 DModel
D381 n_381 n_382 DModel
D401 n_401 n_402 DModel
D421 n_421 n_422 DModel
D441 n_441 n_442 DModel
D461 n_461 n_462 DModel
D481 n_481 n_482 DModel
D501 n_501 n_502 DModel
D521 n_521 n_522 DModel
D541 n_541 n_542 DModel
D561 n_561 n_562 DModel
D581 n_581 n_582 DModel
D601 n_601 n_602 DModel
D621 n_621 n_622 DModel
D641 n_641 n_642 DModel
D661 n_661 n_662 DModel
D681 n_681 n_682 DModel
D701 n_701 n_702 DModel
D721 n_721 n_722 DModel
D741 n_741 n_742 DModel
D761 n_761 n_762 DModel
D781 n_781 n_782 DModel
D801 n_801 n_802 DModel
D821 n_821 n_822 DModel
D841 n_841 n_842 DModel
D861 n_861 n_862 DModel
D881 n_881 n_882 DModel
D901 n_901 n_902 DModel
D921 n_921 n_922 DModel
D941 n_941 n_942 DModel
D961 n_961 n_962 DModel
D981 n_981 n_982 DModel
M1 n_1 n_2 0 0 NMOS L=1e-6 W=10e-6
M51 n_51 n_52 0 0 NMOS L=1e-6 W=10e-6
M101 n_101 n_102 0 0 NMOS L=1e-6 W=10e-6
M151 n_151 n_152 0 0 NMOS L=1e-6 W=10e-6
M201 n_201 n_202 0 0 NMOS L=1e-6 W=10e-6
M251 n_251 n_252 0 0 NMOS L=1e-6 W=10e-6
M301 n_301 n_302 0 0 NMOS L=1e-6 W=10e-6
M351 n_351 n_352 0 0 NMOS L=1e-6 W=10e-6
M401 n_401 n_402 0 0 NMOS L=1e-6 W=10e-6
M451 n_451 n_452 0 0 NMOS L=1e-6 W=10e-6
M501 n_501 n_502 0 0 NMOS L=1e-6 W=10e-6
M551 n_551 n_552 0 0 NMOS L=1e-6 W=10e-6
M601 n_601 n_602 0 0 NMOS L=1e-6 W=10e-6
M651 n_651 n_652 0 0 NMOS L=1e-6 W=10e-6
M701 n_701 n_702 0 0 NMOS L=1e-6 W=10e-6
M751 n_751 n_752 0 0 NMOS L=1e-6 W=10e-6
M801 n_801 n_802 0 0 NMOS L=1e-6 W=10e-6
M851 n_851 n_852 0 0 NMOS L=1e-6 W=10e-6
M901 n_901 n_902 0 0 NMOS L=1e-6 W=10e-6
M951 n_951 n_952 0 0 NMOS L=1e-6 W=10e-6
Q1 n_2 n_1 0 QModel
Q101 n_102 n_101 0 QModel
Q201 n_202 n_201 0 QModel
Q301 n_302 n_301 0 QModel
Q401 n_402 n_401 0 QModel
Q501 n_502 n_501 0 QModel
Q601 n_602 n_601 0 QModel
Q701 n_702 n_701 0 QModel
Q801 n_802 n_801 0 QModel
Q901 n_902 n_901 0 QModel

*.MODEL DModel D IS=1e-14
*.MODEL NMOS NMOS LEVEL=1 VTO=0.7 KP=120u
*.MODEL QModel NPN IS=1e-15 BF=150

*.END
