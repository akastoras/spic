* Resistive network with 5000 nodes

R1 N1 N2 675.48
R2 N2 N3 122.51
R3 N3 N4 347.53
R4 N4 N5 300.89
R5 N5 N6 762.82
R6 N6 N7 709.03
R7 N7 N8 902.96
R8 N8 N9 178.24
R9 N9 N10 479.73
R10 N10 N11 126.82
R11 N11 N12 296.77
R12 N12 N13 554.82
R13 N13 N14 123.88
R14 N14 N15 278.95
R15 N15 N16 684.90
R16 N16 N17 590.45
R17 N17 N18 298.40
R18 N18 N19 630.34
R19 N19 N20 828.49
R20 N20 N21 105.85
R21 N21 N22 825.24
R22 N22 N23 728.33
R23 N23 N24 406.23
R24 N24 N25 239.93
R25 N25 N26 961.49
R26 N26 N27 402.94
R27 N27 N28 183.47
R28 N28 N29 187.04
R29 N29 N30 862.74
R30 N30 N31 643.35
R31 N31 N32 826.42
R32 N32 N33 756.76
R33 N33 N34 582.61
R34 N34 N35 975.80
R35 N35 N36 440.68
R36 N36 N37 596.84
R37 N37 N38 846.46
R38 N38 N39 656.67
R39 N39 N40 875.54
R40 N40 N41 619.62
R41 N41 N42 734.11
R42 N42 N43 141.24
R43 N43 N44 305.11
R44 N44 N45 360.45
R45 N45 N46 171.81
R46 N46 N47 309.51
R47 N47 N48 190.90
R48 N48 N49 350.18
R49 N49 N50 672.12
R50 N50 N51 428.35
R51 N51 N52 433.16
R52 N52 N53 288.56
R53 N53 N54 340.28
R54 N54 N55 942.99
R55 N55 N56 683.23
R56 N56 N57 648.22
R57 N57 N58 254.02
R58 N58 N59 756.21
R59 N59 N60 247.06
R60 N60 N61 441.51
R61 N61 N62 990.57
R62 N62 N63 676.00
R63 N63 N64 601.25
R64 N64 N65 716.15
R65 N65 N66 858.57
R66 N66 N67 798.40
R67 N67 N68 306.14
R68 N68 N69 128.89
R69 N69 N70 383.91
R70 N70 N71 340.97
R71 N71 N72 289.88
R72 N72 N73 948.62
R73 N73 N74 888.73
R74 N74 N75 383.21
R75 N75 N76 689.89
R76 N76 N77 456.07
R77 N77 N78 923.09
R78 N78 N79 512.97
R79 N79 N80 338.39
R80 N80 N81 321.96
R81 N81 N82 605.23
R82 N82 N83 336.47
R83 N83 N84 626.13
R84 N84 N85 908.04
R85 N85 N86 459.46
R86 N86 N87 297.39
R87 N87 N88 997.78
R88 N88 N89 558.57
R89 N89 N90 181.82
R90 N90 N91 142.40
R91 N91 N92 198.68
R92 N92 N93 664.70
R93 N93 N94 812.87
R94 N94 N95 479.94
R95 N95 N96 157.17
R96 N96 N97 443.46
R97 N97 N98 996.51
R98 N98 N99 576.20
R99 N99 N100 973.97
R100 N100 N101 874.70
R101 N101 N102 110.33
R102 N102 N103 748.65
R103 N103 N104 713.54
R104 N104 N105 583.27
R105 N105 N106 340.14
R106 N106 N107 676.87
R107 N107 N108 200.40
R108 N108 N109 491.29
R109 N109 N110 508.35
R110 N110 N111 958.43
R111 N111 N112 888.27
R112 N112 N113 337.05
R113 N113 N114 550.53
R114 N114 N115 260.79
R115 N115 N116 921.37
R116 N116 N117 883.47
R117 N117 N118 368.60
R118 N118 N119 675.05
R119 N119 N120 648.07
R120 N120 N121 237.56
R121 N121 N122 786.26
R122 N122 N123 585.44
R123 N123 N124 800.76
R124 N124 N125 577.32
R125 N125 N126 100.51
R126 N126 N127 391.74
R127 N127 N128 117.53
R128 N128 N129 936.19
R129 N129 N130 890.85
R130 N130 N131 848.50
R131 N131 N132 376.76
R132 N132 N133 152.13
R133 N133 N134 890.21
R134 N134 N135 952.25
R135 N135 N136 177.09
R136 N136 N137 537.39
R137 N137 N138 162.29
R138 N138 N139 784.54
R139 N139 N140 789.25
R140 N140 N141 215.55
R141 N141 N142 527.75
R142 N142 N143 594.82
R143 N143 N144 338.55
R144 N144 N145 885.19
R145 N145 N146 480.82
R146 N146 N147 290.62
R147 N147 N148 585.37
R148 N148 N149 756.94
R149 N149 N150 281.04
R150 N150 N151 380.54
R151 N151 N152 995.63
R152 N152 N153 684.89
R153 N153 N154 494.29
R154 N154 N155 565.82
R155 N155 N156 208.90
R156 N156 N157 302.23
R157 N157 N158 404.28
R158 N158 N159 629.48
R159 N159 N160 307.10
R160 N160 N161 298.20
R161 N161 N162 163.89
R162 N162 N163 667.99
R163 N163 N164 306.05
R164 N164 N165 914.88
R165 N165 N166 873.67
R166 N166 N167 163.77
R167 N167 N168 314.20
R168 N168 N169 702.08
R169 N169 N170 292.81
R170 N170 N171 219.08
R171 N171 N172 941.96
R172 N172 N173 613.94
R173 N173 N174 525.40
R174 N174 N175 806.16
R175 N175 N176 826.75
R176 N176 N177 271.37
R177 N177 N178 187.24
R178 N178 N179 487.95
R179 N179 N180 481.22
R180 N180 N181 520.32
R181 N181 N182 756.17
R182 N182 N183 706.03
R183 N183 N184 985.75
R184 N184 N185 188.58
R185 N185 N186 462.36
R186 N186 N187 405.37
R187 N187 N188 875.51
R188 N188 N189 323.79
R189 N189 N190 271.19
R190 N190 N191 503.75
R191 N191 N192 479.69
R192 N192 N193 350.69
R193 N193 N194 324.83
R194 N194 N195 930.94
R195 N195 N196 498.82
R196 N196 N197 875.21
R197 N197 N198 595.29
R198 N198 N199 145.53
R199 N199 N200 999.35
R200 N200 N201 852.42
R201 N201 N202 972.10
R202 N202 N203 933.73
R203 N203 N204 863.83
R204 N204 N205 249.68
R205 N205 N206 537.08
R206 N206 N207 292.37
R207 N207 N208 460.94
R208 N208 N209 152.77
R209 N209 N210 441.08
R210 N210 N211 986.78
R211 N211 N212 338.68
R212 N212 N213 805.66
R213 N213 N214 509.51
R214 N214 N215 480.71
R215 N215 N216 961.59
R216 N216 N217 995.88
R217 N217 N218 600.19
R218 N218 N219 746.57
R219 N219 N220 239.32
R220 N220 N221 367.04
R221 N221 N222 971.84
R222 N222 N223 621.26
R223 N223 N224 587.98
R224 N224 N225 773.18
R225 N225 N226 151.45
R226 N226 N227 625.76
R227 N227 N228 552.57
R228 N228 N229 867.45
R229 N229 N230 241.69
R230 N230 N231 964.70
R231 N231 N232 172.10
R232 N232 N233 267.24
R233 N233 N234 635.53
R234 N234 N235 707.69
R235 N235 N236 311.68
R236 N236 N237 207.90
R237 N237 N238 901.26
R238 N238 N239 321.59
R239 N239 N240 635.07
R240 N240 N241 657.44
R241 N241 N242 477.30
R242 N242 N243 625.31
R243 N243 N244 570.50
R244 N244 N245 941.24
R245 N245 N246 283.83
R246 N246 N247 744.57
R247 N247 N248 314.82
R248 N248 N249 456.21
R249 N249 N250 704.52
R250 N250 N251 370.00
R251 N251 N252 384.56
R252 N252 N253 776.68
R253 N253 N254 165.29
R254 N254 N255 512.46
R255 N255 N256 998.61
R256 N256 N257 996.49
R257 N257 N258 165.93
R258 N258 N259 291.84
R259 N259 N260 338.68
R260 N260 N261 939.93
R261 N261 N262 892.78
R262 N262 N263 891.34
R263 N263 N264 432.57
R264 N264 N265 241.97
R265 N265 N266 850.37
R266 N266 N267 733.19
R267 N267 N268 650.51
R268 N268 N269 988.51
R269 N269 N270 688.58
R270 N270 N271 107.04
R271 N271 N272 835.39
R272 N272 N273 369.44
R273 N273 N274 697.05
R274 N274 N275 945.04
R275 N275 N276 220.86
R276 N276 N277 203.89
R277 N277 N278 196.33
R278 N278 N279 597.90
R279 N279 N280 345.11
R280 N280 N281 644.35
R281 N281 N282 745.85
R282 N282 N283 283.24
R283 N283 N284 670.81
R284 N284 N285 337.59
R285 N285 N286 539.68
R286 N286 N287 914.80
R287 N287 N288 861.49
R288 N288 N289 183.07
R289 N289 N290 481.22
R290 N290 N291 349.01
R291 N291 N292 103.19
R292 N292 N293 794.01
R293 N293 N294 673.40
R294 N294 N295 335.76
R295 N295 N296 767.11
R296 N296 N297 596.51
R297 N297 N298 484.92
R298 N298 N299 108.70
R299 N299 N300 167.72
R300 N300 N301 894.80
R301 N301 N302 913.54
R302 N302 N303 591.03
R303 N303 N304 851.14
R304 N304 N305 624.26
R305 N305 N306 233.28
R306 N306 N307 214.70
R307 N307 N308 377.43
R308 N308 N309 909.08
R309 N309 N310 816.51
R310 N310 N311 874.63
R311 N311 N312 909.03
R312 N312 N313 289.07
R313 N313 N314 324.58
R314 N314 N315 192.51
R315 N315 N316 802.10
R316 N316 N317 895.72
R317 N317 N318 465.74
R318 N318 N319 658.60
R319 N319 N320 239.10
R320 N320 N321 936.89
R321 N321 N322 878.15
R322 N322 N323 978.59
R323 N323 N324 829.69
R324 N324 N325 893.27
R325 N325 N326 122.31
R326 N326 N327 762.91
R327 N327 N328 398.97
R328 N328 N329 937.73
R329 N329 N330 822.01
R330 N330 N331 877.66
R331 N331 N332 829.67
R332 N332 N333 340.13
R333 N333 N334 808.64
R334 N334 N335 197.29
R335 N335 N336 884.95
R336 N336 N337 872.73
R337 N337 N338 300.19
R338 N338 N339 834.93
R339 N339 N340 514.27
R340 N340 N341 374.67
R341 N341 N342 815.81
R342 N342 N343 304.84
R343 N343 N344 121.30
R344 N344 N345 273.82
R345 N345 N346 395.44
R346 N346 N347 877.92
R347 N347 N348 970.20
R348 N348 N349 351.21
R349 N349 N350 677.33
R350 N350 N351 459.71
R351 N351 N352 983.03
R352 N352 N353 582.59
R353 N353 N354 945.31
R354 N354 N355 203.81
R355 N355 N356 973.36
R356 N356 N357 260.71
R357 N357 N358 966.28
R358 N358 N359 338.92
R359 N359 N360 197.56
R360 N360 N361 491.11
R361 N361 N362 755.69
R362 N362 N363 382.31
R363 N363 N364 645.59
R364 N364 N365 560.28
R365 N365 N366 446.68
R366 N366 N367 618.93
R367 N367 N368 329.25
R368 N368 N369 737.91
R369 N369 N370 101.52
R370 N370 N371 933.02
R371 N371 N372 584.61
R372 N372 N373 747.49
R373 N373 N374 767.76
R374 N374 N375 703.57
R375 N375 N376 427.80
R376 N376 N377 162.98
R377 N377 N378 697.81
R378 N378 N379 397.18
R379 N379 N380 382.52
R380 N380 N381 863.21
R381 N381 N382 747.78
R382 N382 N383 370.29
R383 N383 N384 378.36
R384 N384 N385 467.55
R385 N385 N386 462.16
R386 N386 N387 366.09
R387 N387 N388 214.56
R388 N388 N389 478.40
R389 N389 N390 946.33
R390 N390 N391 709.59
R391 N391 N392 912.52
R392 N392 N393 653.96
R393 N393 N394 370.85
R394 N394 N395 593.14
R395 N395 N396 100.37
R396 N396 N397 358.22
R397 N397 N398 486.90
R398 N398 N399 621.99
R399 N399 N400 689.24
R400 N400 N401 518.49
R401 N401 N402 497.94
R402 N402 N403 292.33
R403 N403 N404 525.87
R404 N404 N405 911.06
R405 N405 N406 816.42
R406 N406 N407 252.72
R407 N407 N408 176.32
R408 N408 N409 563.91
R409 N409 N410 669.65
R410 N410 N411 401.67
R411 N411 N412 836.58
R412 N412 N413 776.02
R413 N413 N414 705.52
R414 N414 N415 302.18
R415 N415 N416 279.22
R416 N416 N417 121.98
R417 N417 N418 320.36
R418 N418 N419 527.62
R419 N419 N420 864.76
R420 N420 N421 165.55
R421 N421 N422 473.00
R422 N422 N423 666.79
R423 N423 N424 274.99
R424 N424 N425 726.72
R425 N425 N426 544.94
R426 N426 N427 319.59
R427 N427 N428 690.45
R428 N428 N429 104.99
R429 N429 N430 775.87
R430 N430 N431 793.04
R431 N431 N432 195.93
R432 N432 N433 482.63
R433 N433 N434 258.30
R434 N434 N435 962.17
R435 N435 N436 566.16
R436 N436 N437 145.20
R437 N437 N438 324.28
R438 N438 N439 863.50
R439 N439 N440 510.82
R440 N440 N441 821.27
R441 N441 N442 700.82
R442 N442 N443 989.10
R443 N443 N444 635.91
R444 N444 N445 955.04
R445 N445 N446 902.28
R446 N446 N447 651.39
R447 N447 N448 747.35
R448 N448 N449 554.30
R449 N449 N450 847.51
R450 N450 N451 593.08
R451 N451 N452 907.49
R452 N452 N453 769.29
R453 N453 N454 527.21
R454 N454 N455 333.27
R455 N455 N456 322.52
R456 N456 N457 673.90
R457 N457 N458 789.23
R458 N458 N459 569.17
R459 N459 N460 664.07
R460 N460 N461 347.14
R461 N461 N462 169.74
R462 N462 N463 357.16
R463 N463 N464 344.54
R464 N464 N465 387.74
R465 N465 N466 586.14
R466 N466 N467 224.54
R467 N467 N468 308.14
R468 N468 N469 724.55
R469 N469 N470 735.78
R470 N470 N471 157.81
R471 N471 N472 466.84
R472 N472 N473 588.35
R473 N473 N474 474.20
R474 N474 N475 286.15
R475 N475 N476 478.13
R476 N476 N477 914.35
R477 N477 N478 625.67
R478 N478 N479 725.97
R479 N479 N480 871.06
R480 N480 N481 789.04
R481 N481 N482 442.34
R482 N482 N483 105.31
R483 N483 N484 416.58
R484 N484 N485 778.13
R485 N485 N486 868.10
R486 N486 N487 958.09
R487 N487 N488 477.12
R488 N488 N489 772.76
R489 N489 N490 591.52
R490 N490 N491 642.93
R491 N491 N492 298.48
R492 N492 N493 297.48
R493 N493 N494 492.25
R494 N494 N495 126.12
R495 N495 N496 402.52
R496 N496 N497 711.23
R497 N497 N498 463.89
R498 N498 N499 248.54
R499 N499 N500 520.65
R500 N500 N501 214.87
R501 N501 N502 660.03
R502 N502 N503 124.27
R503 N503 N504 454.62
R504 N504 N505 607.95
R505 N505 N506 124.39
R506 N506 N507 678.47
R507 N507 N508 222.13
R508 N508 N509 515.53
R509 N509 N510 145.26
R510 N510 N511 441.19
R511 N511 N512 290.49
R512 N512 N513 394.16
R513 N513 N514 785.11
R514 N514 N515 441.21
R515 N515 N516 776.81
R516 N516 N517 848.73
R517 N517 N518 327.04
R518 N518 N519 173.72
R519 N519 N520 117.44
R520 N520 N521 585.48
R521 N521 N522 999.92
R522 N522 N523 414.96
R523 N523 N524 685.13
R524 N524 N525 803.11
R525 N525 N526 686.58
R526 N526 N527 778.81
R527 N527 N528 954.65
R528 N528 N529 279.42
R529 N529 N530 118.34
R530 N530 N531 237.14
R531 N531 N532 213.60
R532 N532 N533 702.51
R533 N533 N534 607.57
R534 N534 N535 296.17
R535 N535 N536 729.52
R536 N536 N537 790.21
R537 N537 N538 251.01
R538 N538 N539 646.52
R539 N539 N540 773.13
R540 N540 N541 203.08
R541 N541 N542 837.37
R542 N542 N543 968.25
R543 N543 N544 197.29
R544 N544 N545 123.11
R545 N545 N546 380.76
R546 N546 N547 709.61
R547 N547 N548 962.36
R548 N548 N549 456.99
R549 N549 N550 743.51
R550 N550 N551 168.40
R551 N551 N552 721.55
R552 N552 N553 664.52
R553 N553 N554 191.71
R554 N554 N555 795.23
R555 N555 N556 865.26
R556 N556 N557 640.37
R557 N557 N558 208.95
R558 N558 N559 985.46
R559 N559 N560 804.37
R560 N560 N561 412.48
R561 N561 N562 485.54
R562 N562 N563 433.51
R563 N563 N564 555.36
R564 N564 N565 407.11
R565 N565 N566 864.62
R566 N566 N567 840.10
R567 N567 N568 194.98
R568 N568 N569 964.71
R569 N569 N570 672.03
R570 N570 N571 845.84
R571 N571 N572 736.58
R572 N572 N573 491.94
R573 N573 N574 760.42
R574 N574 N575 968.93
R575 N575 N576 343.07
R576 N576 N577 827.38
R577 N577 N578 584.36
R578 N578 N579 535.15
R579 N579 N580 492.02
R580 N580 N581 757.92
R581 N581 N582 341.56
R582 N582 N583 866.54
R583 N583 N584 847.66
R584 N584 N585 178.00
R585 N585 N586 893.47
R586 N586 N587 319.48
R587 N587 N588 518.24
R588 N588 N589 649.30
R589 N589 N590 441.09
R590 N590 N591 125.83
R591 N591 N592 865.86
R592 N592 N593 263.66
R593 N593 N594 290.91
R594 N594 N595 818.05
R595 N595 N596 406.30
R596 N596 N597 892.29
R597 N597 N598 731.07
R598 N598 N599 348.64
R599 N599 N600 109.14
R600 N600 N601 953.26
R601 N601 N602 177.05
R602 N602 N603 748.07
R603 N603 N604 539.72
R604 N604 N605 782.35
R605 N605 N606 721.55
R606 N606 N607 681.31
R607 N607 N608 541.74
R608 N608 N609 813.64
R609 N609 N610 183.75
R610 N610 N611 299.44
R611 N611 N612 722.61
R612 N612 N613 375.59
R613 N613 N614 623.40
R614 N614 N615 525.93
R615 N615 N616 577.83
R616 N616 N617 482.95
R617 N617 N618 771.34
R618 N618 N619 397.71
R619 N619 N620 732.57
R620 N620 N621 343.82
R621 N621 N622 326.26
R622 N622 N623 208.59
R623 N623 N624 273.33
R624 N624 N625 207.60
R625 N625 N626 582.28
R626 N626 N627 785.97
R627 N627 N628 266.63
R628 N628 N629 294.75
R629 N629 N630 535.78
R630 N630 N631 752.13
R631 N631 N632 978.95
R632 N632 N633 572.17
R633 N633 N634 354.70
R634 N634 N635 190.47
R635 N635 N636 274.71
R636 N636 N637 304.73
R637 N637 N638 261.50
R638 N638 N639 112.73
R639 N639 N640 580.72
R640 N640 N641 346.88
R641 N641 N642 976.87
R642 N642 N643 598.02
R643 N643 N644 727.68
R644 N644 N645 213.65
R645 N645 N646 881.62
R646 N646 N647 541.79
R647 N647 N648 885.45
R648 N648 N649 616.66
R649 N649 N650 522.46
R650 N650 N651 496.42
R651 N651 N652 265.93
R652 N652 N653 146.24
R653 N653 N654 946.96
R654 N654 N655 529.96
R655 N655 N656 839.90
R656 N656 N657 460.64
R657 N657 N658 166.67
R658 N658 N659 666.50
R659 N659 N660 148.25
R660 N660 N661 234.28
R661 N661 N662 606.56
R662 N662 N663 373.45
R663 N663 N664 994.53
R664 N664 N665 206.61
R665 N665 N666 788.00
R666 N666 N667 645.69
R667 N667 N668 811.67
R668 N668 N669 303.12
R669 N669 N670 570.32
R670 N670 N671 505.46
R671 N671 N672 498.45
R672 N672 N673 874.15
R673 N673 N674 991.03
R674 N674 N675 374.84
R675 N675 N676 658.92
R676 N676 N677 648.67
R677 N677 N678 766.08
R678 N678 N679 952.83
R679 N679 N680 287.01
R680 N680 N681 289.92
R681 N681 N682 694.39
R682 N682 N683 241.35
R683 N683 N684 256.43
R684 N684 N685 167.56
R685 N685 N686 102.41
R686 N686 N687 505.45
R687 N687 N688 634.43
R688 N688 N689 362.13
R689 N689 N690 308.33
R690 N690 N691 736.26
R691 N691 N692 732.69
R692 N692 N693 508.63
R693 N693 N694 718.65
R694 N694 N695 931.52
R695 N695 N696 809.05
R696 N696 N697 662.55
R697 N697 N698 695.06
R698 N698 N699 940.30
R699 N699 N700 482.63
R700 N700 N701 590.11
R701 N701 N702 682.87
R702 N702 N703 917.57
R703 N703 N704 843.97
R704 N704 N705 164.27
R705 N705 N706 249.33
R706 N706 N707 376.85
R707 N707 N708 774.06
R708 N708 N709 612.29
R709 N709 N710 359.75
R710 N710 N711 211.92
R711 N711 N712 719.81
R712 N712 N713 729.76
R713 N713 N714 948.41
R714 N714 N715 550.42
R715 N715 N716 544.42
R716 N716 N717 172.40
R717 N717 N718 135.87
R718 N718 N719 488.83
R719 N719 N720 390.09
R720 N720 N721 325.33
R721 N721 N722 182.19
R722 N722 N723 965.72
R723 N723 N724 852.36
R724 N724 N725 617.68
R725 N725 N726 955.71
R726 N726 N727 999.62
R727 N727 N728 705.05
R728 N728 N729 342.56
R729 N729 N730 136.21
R730 N730 N731 780.64
R731 N731 N732 523.45
R732 N732 N733 686.36
R733 N733 N734 924.47
R734 N734 N735 263.34
R735 N735 N736 626.80
R736 N736 N737 671.31
R737 N737 N738 542.55
R738 N738 N739 182.12
R739 N739 N740 413.16
R740 N740 N741 399.98
R741 N741 N742 703.12
R742 N742 N743 871.96
R743 N743 N744 396.82
R744 N744 N745 724.31
R745 N745 N746 359.40
R746 N746 N747 950.67
R747 N747 N748 832.21
R748 N748 N749 595.09
R749 N749 N750 509.34
R750 N750 N751 383.07
R751 N751 N752 390.95
R752 N752 N753 973.17
R753 N753 N754 463.76
R754 N754 N755 563.14
R755 N755 N756 989.31
R756 N756 N757 691.89
R757 N757 N758 588.33
R758 N758 N759 471.92
R759 N759 N760 268.82
R760 N760 N761 425.60
R761 N761 N762 780.80
R762 N762 N763 662.87
R763 N763 N764 783.99
R764 N764 N765 283.20
R765 N765 N766 594.30
R766 N766 N767 934.91
R767 N767 N768 494.30
R768 N768 N769 728.43
R769 N769 N770 209.28
R770 N770 N771 975.83
R771 N771 N772 647.98
R772 N772 N773 315.37
R773 N773 N774 242.54
R774 N774 N775 595.76
R775 N775 N776 597.03
R776 N776 N777 183.89
R777 N777 N778 993.03
R778 N778 N779 921.64
R779 N779 N780 515.30
R780 N780 N781 205.72
R781 N781 N782 848.93
R782 N782 N783 548.54
R783 N783 N784 744.94
R784 N784 N785 557.98
R785 N785 N786 346.08
R786 N786 N787 851.25
R787 N787 N788 982.22
R788 N788 N789 319.36
R789 N789 N790 596.14
R790 N790 N791 445.23
R791 N791 N792 929.68
R792 N792 N793 557.42
R793 N793 N794 891.39
R794 N794 N795 877.62
R795 N795 N796 348.62
R796 N796 N797 811.01
R797 N797 N798 473.45
R798 N798 N799 940.82
R799 N799 N800 556.96
R800 N800 N801 838.49
R801 N801 N802 354.56
R802 N802 N803 368.70
R803 N803 N804 628.24
R804 N804 N805 999.01
R805 N805 N806 540.68
R806 N806 N807 233.74
R807 N807 N808 584.72
R808 N808 N809 410.61
R809 N809 N810 596.73
R810 N810 N811 589.09
R811 N811 N812 509.81
R812 N812 N813 389.60
R813 N813 N814 269.79
R814 N814 N815 727.75
R815 N815 N816 614.62
R816 N816 N817 310.21
R817 N817 N818 797.99
R818 N818 N819 139.28
R819 N819 N820 770.23
R820 N820 N821 734.71
R821 N821 N822 830.27
R822 N822 N823 447.47
R823 N823 N824 697.32
R824 N824 N825 838.67
R825 N825 N826 982.74
R826 N826 N827 545.80
R827 N827 N828 133.32
R828 N828 N829 552.06
R829 N829 N830 631.16
R830 N830 N831 882.73
R831 N831 N832 886.77
R832 N832 N833 496.28
R833 N833 N834 573.36
R834 N834 N835 511.24
R835 N835 N836 750.20
R836 N836 N837 468.98
R837 N837 N838 689.30
R838 N838 N839 238.93
R839 N839 N840 522.54
R840 N840 N841 972.28
R841 N841 N842 404.71
R842 N842 N843 723.43
R843 N843 N844 684.85
R844 N844 N845 866.59
R845 N845 N846 867.11
R846 N846 N847 873.41
R847 N847 N848 442.01
R848 N848 N849 385.00
R849 N849 N850 746.85
R850 N850 N851 783.46
R851 N851 N852 885.14
R852 N852 N853 132.31
R853 N853 N854 161.58
R854 N854 N855 668.04
R855 N855 N856 928.84
R856 N856 N857 997.68
R857 N857 N858 772.09
R858 N858 N859 490.57
R859 N859 N860 188.60
R860 N860 N861 670.37
R861 N861 N862 885.32
R862 N862 N863 499.31
R863 N863 N864 724.60
R864 N864 N865 913.08
R865 N865 N866 141.39
R866 N866 N867 816.53
R867 N867 N868 364.03
R868 N868 N869 437.36
R869 N869 N870 231.01
R870 N870 N871 578.05
R871 N871 N872 609.34
R872 N872 N873 813.27
R873 N873 N874 252.99
R874 N874 N875 171.07
R875 N875 N876 883.76
R876 N876 N877 657.74
R877 N877 N878 316.75
R878 N878 N879 921.55
R879 N879 N880 228.81
R880 N880 N881 515.03
R881 N881 N882 328.58
R882 N882 N883 329.79
R883 N883 N884 108.46
R884 N884 N885 824.17
R885 N885 N886 911.09
R886 N886 N887 709.85
R887 N887 N888 242.18
R888 N888 N889 497.56
R889 N889 N890 411.01
R890 N890 N891 628.81
R891 N891 N892 675.04
R892 N892 N893 481.88
R893 N893 N894 325.09
R894 N894 N895 860.77
R895 N895 N896 279.30
R896 N896 N897 446.22
R897 N897 N898 534.89
R898 N898 N899 313.49
R899 N899 N900 614.73
R900 N900 N901 617.33
R901 N901 N902 993.42
R902 N902 N903 365.71
R903 N903 N904 980.15
R904 N904 N905 692.41
R905 N905 N906 347.03
R906 N906 N907 609.34
R907 N907 N908 717.22
R908 N908 N909 770.20
R909 N909 N910 144.14
R910 N910 N911 645.77
R911 N911 N912 547.05
R912 N912 N913 913.74
R913 N913 N914 357.57
R914 N914 N915 818.97
R915 N915 N916 646.36
R916 N916 N917 417.09
R917 N917 N918 672.96
R918 N918 N919 658.80
R919 N919 N920 709.99
R920 N920 N921 748.84
R921 N921 N922 693.26
R922 N922 N923 854.50
R923 N923 N924 665.42
R924 N924 N925 913.06
R925 N925 N926 681.71
R926 N926 N927 378.04
R927 N927 N928 496.74
R928 N928 N929 621.62
R929 N929 N930 759.12
R930 N930 N931 181.12
R931 N931 N932 365.60
R932 N932 N933 772.73
R933 N933 N934 258.08
R934 N934 N935 218.94
R935 N935 N936 585.47
R936 N936 N937 974.34
R937 N937 N938 577.77
R938 N938 N939 922.14
R939 N939 N940 847.43
R940 N940 N941 331.27
R941 N941 N942 842.22
R942 N942 N943 533.66
R943 N943 N944 825.84
R944 N944 N945 771.90
R945 N945 N946 404.84
R946 N946 N947 203.65
R947 N947 N948 966.60
R948 N948 N949 226.68
R949 N949 N950 969.85
R950 N950 N951 874.13
R951 N951 N952 751.80
R952 N952 N953 981.95
R953 N953 N954 970.54
R954 N954 N955 824.13
R955 N955 N956 429.20
R956 N956 N957 811.61
R957 N957 N958 112.53
R958 N958 N959 582.92
R959 N959 N960 509.31
R960 N960 N961 705.55
R961 N961 N962 705.11
R962 N962 N963 626.10
R963 N963 N964 840.18
R964 N964 N965 946.26
R965 N965 N966 197.51
R966 N966 N967 310.44
R967 N967 N968 122.52
R968 N968 N969 895.81
R969 N969 N970 605.27
R970 N970 N971 923.73
R971 N971 N972 299.23
R972 N972 N973 156.90
R973 N973 N974 841.47
R974 N974 N975 918.45
R975 N975 N976 371.97
R976 N976 N977 467.47
R977 N977 N978 225.80
R978 N978 N979 951.64
R979 N979 N980 373.93
R980 N980 N981 543.36
R981 N981 N982 187.47
R982 N982 N983 898.53
R983 N983 N984 222.10
R984 N984 N985 508.28
R985 N985 N986 703.44
R986 N986 N987 768.83
R987 N987 N988 951.38
R988 N988 N989 477.21
R989 N989 N990 768.04
R990 N990 N991 239.07
R991 N991 N992 473.40
R992 N992 N993 189.12
R993 N993 N994 540.41
R994 N994 N995 467.30
R995 N995 N996 956.37
R996 N996 N997 129.44
R997 N997 N998 433.48
R998 N998 N999 499.04
R999 N999 N1000 955.50
R1000 N1000 N1001 869.91
R1001 N1001 N1002 189.42
R1002 N1002 N1003 717.11
R1003 N1003 N1004 590.02
R1004 N1004 N1005 980.06
R1005 N1005 N1006 422.81
R1006 N1006 N1007 458.33
R1007 N1007 N1008 270.83
R1008 N1008 N1009 209.94
R1009 N1009 N1010 863.23
R1010 N1010 N1011 509.25
R1011 N1011 N1012 696.49
R1012 N1012 N1013 677.53
R1013 N1013 N1014 637.43
R1014 N1014 N1015 119.22
R1015 N1015 N1016 808.12
R1016 N1016 N1017 319.21
R1017 N1017 N1018 213.33
R1018 N1018 N1019 608.12
R1019 N1019 N1020 161.75
R1020 N1020 N1021 788.64
R1021 N1021 N1022 286.44
R1022 N1022 N1023 294.36
R1023 N1023 N1024 882.73
R1024 N1024 N1025 395.70
R1025 N1025 N1026 232.80
R1026 N1026 N1027 910.48
R1027 N1027 N1028 102.55
R1028 N1028 N1029 872.57
R1029 N1029 N1030 230.22
R1030 N1030 N1031 216.99
R1031 N1031 N1032 325.59
R1032 N1032 N1033 257.05
R1033 N1033 N1034 694.95
R1034 N1034 N1035 123.20
R1035 N1035 N1036 113.37
R1036 N1036 N1037 810.99
R1037 N1037 N1038 314.14
R1038 N1038 N1039 391.39
R1039 N1039 N1040 256.82
R1040 N1040 N1041 147.16
R1041 N1041 N1042 767.55
R1042 N1042 N1043 573.48
R1043 N1043 N1044 771.10
R1044 N1044 N1045 528.62
R1045 N1045 N1046 800.22
R1046 N1046 N1047 561.91
R1047 N1047 N1048 198.15
R1048 N1048 N1049 553.45
R1049 N1049 N1050 950.87
R1050 N1050 N1051 139.03
R1051 N1051 N1052 804.90
R1052 N1052 N1053 880.28
R1053 N1053 N1054 569.31
R1054 N1054 N1055 512.24
R1055 N1055 N1056 967.62
R1056 N1056 N1057 154.74
R1057 N1057 N1058 531.08
R1058 N1058 N1059 461.46
R1059 N1059 N1060 717.49
R1060 N1060 N1061 541.24
R1061 N1061 N1062 918.73
R1062 N1062 N1063 166.14
R1063 N1063 N1064 172.71
R1064 N1064 N1065 647.47
R1065 N1065 N1066 159.11
R1066 N1066 N1067 347.51
R1067 N1067 N1068 669.77
R1068 N1068 N1069 593.52
R1069 N1069 N1070 392.67
R1070 N1070 N1071 995.16
R1071 N1071 N1072 577.50
R1072 N1072 N1073 508.34
R1073 N1073 N1074 644.88
R1074 N1074 N1075 189.26
R1075 N1075 N1076 731.60
R1076 N1076 N1077 867.51
R1077 N1077 N1078 685.82
R1078 N1078 N1079 792.07
R1079 N1079 N1080 748.76
R1080 N1080 N1081 293.52
R1081 N1081 N1082 506.40
R1082 N1082 N1083 305.64
R1083 N1083 N1084 405.04
R1084 N1084 N1085 508.15
R1085 N1085 N1086 474.39
R1086 N1086 N1087 185.58
R1087 N1087 N1088 484.09
R1088 N1088 N1089 698.60
R1089 N1089 N1090 436.87
R1090 N1090 N1091 237.38
R1091 N1091 N1092 930.69
R1092 N1092 N1093 160.42
R1093 N1093 N1094 848.59
R1094 N1094 N1095 183.91
R1095 N1095 N1096 186.91
R1096 N1096 N1097 764.92
R1097 N1097 N1098 830.59
R1098 N1098 N1099 600.73
R1099 N1099 N1100 627.82
R1100 N1100 N1101 605.43
R1101 N1101 N1102 396.68
R1102 N1102 N1103 210.01
R1103 N1103 N1104 418.24
R1104 N1104 N1105 698.81
R1105 N1105 N1106 775.26
R1106 N1106 N1107 881.28
R1107 N1107 N1108 748.95
R1108 N1108 N1109 971.56
R1109 N1109 N1110 640.37
R1110 N1110 N1111 416.48
R1111 N1111 N1112 620.13
R1112 N1112 N1113 291.46
R1113 N1113 N1114 691.06
R1114 N1114 N1115 301.82
R1115 N1115 N1116 197.40
R1116 N1116 N1117 860.84
R1117 N1117 N1118 430.80
R1118 N1118 N1119 786.35
R1119 N1119 N1120 616.69
R1120 N1120 N1121 826.50
R1121 N1121 N1122 860.64
R1122 N1122 N1123 977.09
R1123 N1123 N1124 836.58
R1124 N1124 N1125 652.22
R1125 N1125 N1126 678.43
R1126 N1126 N1127 123.63
R1127 N1127 N1128 936.18
R1128 N1128 N1129 846.51
R1129 N1129 N1130 340.70
R1130 N1130 N1131 262.37
R1131 N1131 N1132 732.43
R1132 N1132 N1133 378.09
R1133 N1133 N1134 405.84
R1134 N1134 N1135 105.50
R1135 N1135 N1136 882.88
R1136 N1136 N1137 609.69
R1137 N1137 N1138 460.71
R1138 N1138 N1139 227.69
R1139 N1139 N1140 669.85
R1140 N1140 N1141 127.59
R1141 N1141 N1142 771.50
R1142 N1142 N1143 293.62
R1143 N1143 N1144 477.85
R1144 N1144 N1145 406.81
R1145 N1145 N1146 433.05
R1146 N1146 N1147 749.44
R1147 N1147 N1148 799.15
R1148 N1148 N1149 610.83
R1149 N1149 N1150 176.46
R1150 N1150 N1151 147.35
R1151 N1151 N1152 241.67
R1152 N1152 N1153 656.05
R1153 N1153 N1154 706.57
R1154 N1154 N1155 344.89
R1155 N1155 N1156 695.74
R1156 N1156 N1157 537.10
R1157 N1157 N1158 497.84
R1158 N1158 N1159 345.85
R1159 N1159 N1160 779.45
R1160 N1160 N1161 202.44
R1161 N1161 N1162 486.92
R1162 N1162 N1163 354.92
R1163 N1163 N1164 710.64
R1164 N1164 N1165 537.97
R1165 N1165 N1166 700.42
R1166 N1166 N1167 140.88
R1167 N1167 N1168 455.74
R1168 N1168 N1169 639.39
R1169 N1169 N1170 106.92
R1170 N1170 N1171 371.28
R1171 N1171 N1172 290.11
R1172 N1172 N1173 223.51
R1173 N1173 N1174 329.97
R1174 N1174 N1175 395.31
R1175 N1175 N1176 106.96
R1176 N1176 N1177 772.31
R1177 N1177 N1178 258.13
R1178 N1178 N1179 442.19
R1179 N1179 N1180 733.30
R1180 N1180 N1181 550.24
R1181 N1181 N1182 850.02
R1182 N1182 N1183 825.58
R1183 N1183 N1184 164.87
R1184 N1184 N1185 875.59
R1185 N1185 N1186 138.07
R1186 N1186 N1187 116.87
R1187 N1187 N1188 929.05
R1188 N1188 N1189 875.90
R1189 N1189 N1190 618.18
R1190 N1190 N1191 616.06
R1191 N1191 N1192 738.55
R1192 N1192 N1193 475.92
R1193 N1193 N1194 203.66
R1194 N1194 N1195 118.77
R1195 N1195 N1196 392.29
R1196 N1196 N1197 821.19
R1197 N1197 N1198 656.31
R1198 N1198 N1199 848.82
R1199 N1199 N1200 927.79
R1200 N1200 N1201 179.32
R1201 N1201 N1202 860.04
R1202 N1202 N1203 318.98
R1203 N1203 N1204 629.98
R1204 N1204 N1205 571.57
R1205 N1205 N1206 456.19
R1206 N1206 N1207 379.25
R1207 N1207 N1208 405.56
R1208 N1208 N1209 399.76
R1209 N1209 N1210 251.32
R1210 N1210 N1211 559.43
R1211 N1211 N1212 202.62
R1212 N1212 N1213 558.96
R1213 N1213 N1214 915.33
R1214 N1214 N1215 414.44
R1215 N1215 N1216 754.64
R1216 N1216 N1217 837.05
R1217 N1217 N1218 833.53
R1218 N1218 N1219 312.64
R1219 N1219 N1220 231.80
R1220 N1220 N1221 277.54
R1221 N1221 N1222 642.16
R1222 N1222 N1223 784.19
R1223 N1223 N1224 689.96
R1224 N1224 N1225 259.43
R1225 N1225 N1226 795.56
R1226 N1226 N1227 544.71
R1227 N1227 N1228 779.00
R1228 N1228 N1229 783.89
R1229 N1229 N1230 504.01
R1230 N1230 N1231 931.74
R1231 N1231 N1232 608.04
R1232 N1232 N1233 671.77
R1233 N1233 N1234 662.07
R1234 N1234 N1235 877.82
R1235 N1235 N1236 664.50
R1236 N1236 N1237 235.86
R1237 N1237 N1238 161.46
R1238 N1238 N1239 497.99
R1239 N1239 N1240 372.54
R1240 N1240 N1241 347.21
R1241 N1241 N1242 150.55
R1242 N1242 N1243 556.60
R1243 N1243 N1244 379.37
R1244 N1244 N1245 506.72
R1245 N1245 N1246 151.20
R1246 N1246 N1247 848.53
R1247 N1247 N1248 169.06
R1248 N1248 N1249 877.83
R1249 N1249 N1250 869.76
R1250 N1250 N1251 653.51
R1251 N1251 N1252 556.36
R1252 N1252 N1253 516.44
R1253 N1253 N1254 598.88
R1254 N1254 N1255 812.64
R1255 N1255 N1256 906.29
R1256 N1256 N1257 504.76
R1257 N1257 N1258 828.83
R1258 N1258 N1259 686.65
R1259 N1259 N1260 389.37
R1260 N1260 N1261 528.07
R1261 N1261 N1262 235.77
R1262 N1262 N1263 155.69
R1263 N1263 N1264 193.15
R1264 N1264 N1265 909.21
R1265 N1265 N1266 409.09
R1266 N1266 N1267 742.88
R1267 N1267 N1268 554.09
R1268 N1268 N1269 255.30
R1269 N1269 N1270 322.97
R1270 N1270 N1271 493.98
R1271 N1271 N1272 495.48
R1272 N1272 N1273 570.47
R1273 N1273 N1274 242.87
R1274 N1274 N1275 435.57
R1275 N1275 N1276 354.60
R1276 N1276 N1277 467.89
R1277 N1277 N1278 404.53
R1278 N1278 N1279 638.10
R1279 N1279 N1280 810.30
R1280 N1280 N1281 682.57
R1281 N1281 N1282 159.32
R1282 N1282 N1283 185.06
R1283 N1283 N1284 710.54
R1284 N1284 N1285 355.73
R1285 N1285 N1286 751.36
R1286 N1286 N1287 690.91
R1287 N1287 N1288 915.71
R1288 N1288 N1289 885.95
R1289 N1289 N1290 400.03
R1290 N1290 N1291 624.47
R1291 N1291 N1292 227.29
R1292 N1292 N1293 414.84
R1293 N1293 N1294 970.93
R1294 N1294 N1295 728.63
R1295 N1295 N1296 452.76
R1296 N1296 N1297 635.54
R1297 N1297 N1298 944.20
R1298 N1298 N1299 378.62
R1299 N1299 N1300 439.01
R1300 N1300 N1301 812.50
R1301 N1301 N1302 831.87
R1302 N1302 N1303 703.10
R1303 N1303 N1304 846.06
R1304 N1304 N1305 764.90
R1305 N1305 N1306 716.87
R1306 N1306 N1307 573.75
R1307 N1307 N1308 681.42
R1308 N1308 N1309 481.07
R1309 N1309 N1310 425.65
R1310 N1310 N1311 426.34
R1311 N1311 N1312 262.24
R1312 N1312 N1313 292.77
R1313 N1313 N1314 952.90
R1314 N1314 N1315 537.64
R1315 N1315 N1316 303.89
R1316 N1316 N1317 223.81
R1317 N1317 N1318 169.45
R1318 N1318 N1319 859.99
R1319 N1319 N1320 191.03
R1320 N1320 N1321 793.79
R1321 N1321 N1322 851.61
R1322 N1322 N1323 895.31
R1323 N1323 N1324 133.97
R1324 N1324 N1325 403.09
R1325 N1325 N1326 789.68
R1326 N1326 N1327 217.94
R1327 N1327 N1328 439.05
R1328 N1328 N1329 246.02
R1329 N1329 N1330 848.21
R1330 N1330 N1331 793.99
R1331 N1331 N1332 828.14
R1332 N1332 N1333 248.99
R1333 N1333 N1334 493.91
R1334 N1334 N1335 469.77
R1335 N1335 N1336 708.73
R1336 N1336 N1337 313.78
R1337 N1337 N1338 499.78
R1338 N1338 N1339 356.44
R1339 N1339 N1340 773.68
R1340 N1340 N1341 504.04
R1341 N1341 N1342 580.61
R1342 N1342 N1343 378.52
R1343 N1343 N1344 827.76
R1344 N1344 N1345 522.11
R1345 N1345 N1346 851.60
R1346 N1346 N1347 431.06
R1347 N1347 N1348 952.42
R1348 N1348 N1349 986.00
R1349 N1349 N1350 515.51
R1350 N1350 N1351 353.59
R1351 N1351 N1352 443.69
R1352 N1352 N1353 574.71
R1353 N1353 N1354 969.64
R1354 N1354 N1355 835.20
R1355 N1355 N1356 821.13
R1356 N1356 N1357 224.56
R1357 N1357 N1358 325.00
R1358 N1358 N1359 677.06
R1359 N1359 N1360 886.71
R1360 N1360 N1361 599.09
R1361 N1361 N1362 192.33
R1362 N1362 N1363 861.30
R1363 N1363 N1364 866.05
R1364 N1364 N1365 356.56
R1365 N1365 N1366 786.81
R1366 N1366 N1367 345.51
R1367 N1367 N1368 914.78
R1368 N1368 N1369 232.61
R1369 N1369 N1370 493.73
R1370 N1370 N1371 951.77
R1371 N1371 N1372 299.83
R1372 N1372 N1373 506.02
R1373 N1373 N1374 414.63
R1374 N1374 N1375 124.00
R1375 N1375 N1376 147.93
R1376 N1376 N1377 551.81
R1377 N1377 N1378 312.20
R1378 N1378 N1379 995.07
R1379 N1379 N1380 437.42
R1380 N1380 N1381 125.37
R1381 N1381 N1382 937.74
R1382 N1382 N1383 855.26
R1383 N1383 N1384 684.96
R1384 N1384 N1385 812.24
R1385 N1385 N1386 223.84
R1386 N1386 N1387 358.19
R1387 N1387 N1388 846.79
R1388 N1388 N1389 726.46
R1389 N1389 N1390 224.91
R1390 N1390 N1391 734.98
R1391 N1391 N1392 503.74
R1392 N1392 N1393 104.73
R1393 N1393 N1394 171.30
R1394 N1394 N1395 330.33
R1395 N1395 N1396 851.47
R1396 N1396 N1397 593.92
R1397 N1397 N1398 754.51
R1398 N1398 N1399 574.99
R1399 N1399 N1400 200.07
R1400 N1400 N1401 359.29
R1401 N1401 N1402 371.04
R1402 N1402 N1403 142.97
R1403 N1403 N1404 477.84
R1404 N1404 N1405 814.51
R1405 N1405 N1406 511.40
R1406 N1406 N1407 199.77
R1407 N1407 N1408 914.63
R1408 N1408 N1409 637.07
R1409 N1409 N1410 114.79
R1410 N1410 N1411 563.84
R1411 N1411 N1412 317.74
R1412 N1412 N1413 229.22
R1413 N1413 N1414 486.32
R1414 N1414 N1415 653.33
R1415 N1415 N1416 316.51
R1416 N1416 N1417 474.91
R1417 N1417 N1418 697.93
R1418 N1418 N1419 177.05
R1419 N1419 N1420 977.19
R1420 N1420 N1421 160.91
R1421 N1421 N1422 573.45
R1422 N1422 N1423 556.59
R1423 N1423 N1424 989.50
R1424 N1424 N1425 598.74
R1425 N1425 N1426 451.41
R1426 N1426 N1427 523.12
R1427 N1427 N1428 672.10
R1428 N1428 N1429 982.94
R1429 N1429 N1430 328.29
R1430 N1430 N1431 114.62
R1431 N1431 N1432 809.67
R1432 N1432 N1433 410.32
R1433 N1433 N1434 759.65
R1434 N1434 N1435 665.43
R1435 N1435 N1436 794.35
R1436 N1436 N1437 761.67
R1437 N1437 N1438 399.27
R1438 N1438 N1439 139.90
R1439 N1439 N1440 591.41
R1440 N1440 N1441 832.16
R1441 N1441 N1442 257.58
R1442 N1442 N1443 801.23
R1443 N1443 N1444 518.16
R1444 N1444 N1445 725.85
R1445 N1445 N1446 668.56
R1446 N1446 N1447 830.35
R1447 N1447 N1448 156.79
R1448 N1448 N1449 798.57
R1449 N1449 N1450 511.91
R1450 N1450 N1451 364.10
R1451 N1451 N1452 139.43
R1452 N1452 N1453 279.52
R1453 N1453 N1454 137.72
R1454 N1454 N1455 940.03
R1455 N1455 N1456 563.85
R1456 N1456 N1457 990.21
R1457 N1457 N1458 588.73
R1458 N1458 N1459 327.98
R1459 N1459 N1460 777.96
R1460 N1460 N1461 271.99
R1461 N1461 N1462 421.28
R1462 N1462 N1463 802.76
R1463 N1463 N1464 879.22
R1464 N1464 N1465 398.73
R1465 N1465 N1466 212.03
R1466 N1466 N1467 431.22
R1467 N1467 N1468 900.54
R1468 N1468 N1469 768.98
R1469 N1469 N1470 905.17
R1470 N1470 N1471 447.98
R1471 N1471 N1472 976.35
R1472 N1472 N1473 546.58
R1473 N1473 N1474 547.77
R1474 N1474 N1475 931.88
R1475 N1475 N1476 567.35
R1476 N1476 N1477 821.03
R1477 N1477 N1478 754.37
R1478 N1478 N1479 171.03
R1479 N1479 N1480 642.21
R1480 N1480 N1481 840.11
R1481 N1481 N1482 590.93
R1482 N1482 N1483 389.09
R1483 N1483 N1484 172.06
R1484 N1484 N1485 694.83
R1485 N1485 N1486 375.85
R1486 N1486 N1487 642.36
R1487 N1487 N1488 483.50
R1488 N1488 N1489 720.79
R1489 N1489 N1490 416.39
R1490 N1490 N1491 138.12
R1491 N1491 N1492 883.03
R1492 N1492 N1493 417.30
R1493 N1493 N1494 998.34
R1494 N1494 N1495 347.10
R1495 N1495 N1496 982.02
R1496 N1496 N1497 953.11
R1497 N1497 N1498 167.54
R1498 N1498 N1499 673.76
R1499 N1499 N1500 426.98
R1500 N1500 N1501 820.99
R1501 N1501 N1502 711.47
R1502 N1502 N1503 957.51
R1503 N1503 N1504 228.50
R1504 N1504 N1505 646.82
R1505 N1505 N1506 803.18
R1506 N1506 N1507 131.32
R1507 N1507 N1508 160.51
R1508 N1508 N1509 800.66
R1509 N1509 N1510 429.70
R1510 N1510 N1511 444.57
R1511 N1511 N1512 610.52
R1512 N1512 N1513 644.59
R1513 N1513 N1514 711.16
R1514 N1514 N1515 953.94
R1515 N1515 N1516 434.81
R1516 N1516 N1517 786.78
R1517 N1517 N1518 616.53
R1518 N1518 N1519 576.51
R1519 N1519 N1520 458.23
R1520 N1520 N1521 684.60
R1521 N1521 N1522 324.65
R1522 N1522 N1523 202.10
R1523 N1523 N1524 762.11
R1524 N1524 N1525 549.14
R1525 N1525 N1526 448.29
R1526 N1526 N1527 605.51
R1527 N1527 N1528 335.60
R1528 N1528 N1529 334.26
R1529 N1529 N1530 501.65
R1530 N1530 N1531 996.73
R1531 N1531 N1532 357.02
R1532 N1532 N1533 924.83
R1533 N1533 N1534 542.08
R1534 N1534 N1535 210.37
R1535 N1535 N1536 867.54
R1536 N1536 N1537 506.84
R1537 N1537 N1538 908.81
R1538 N1538 N1539 500.60
R1539 N1539 N1540 179.01
R1540 N1540 N1541 713.74
R1541 N1541 N1542 860.97
R1542 N1542 N1543 387.63
R1543 N1543 N1544 412.68
R1544 N1544 N1545 158.45
R1545 N1545 N1546 587.95
R1546 N1546 N1547 902.20
R1547 N1547 N1548 866.23
R1548 N1548 N1549 740.63
R1549 N1549 N1550 934.59
R1550 N1550 N1551 673.93
R1551 N1551 N1552 814.33
R1552 N1552 N1553 557.88
R1553 N1553 N1554 209.23
R1554 N1554 N1555 280.88
R1555 N1555 N1556 224.99
R1556 N1556 N1557 811.34
R1557 N1557 N1558 123.66
R1558 N1558 N1559 598.62
R1559 N1559 N1560 432.02
R1560 N1560 N1561 823.30
R1561 N1561 N1562 596.48
R1562 N1562 N1563 650.75
R1563 N1563 N1564 177.59
R1564 N1564 N1565 378.36
R1565 N1565 N1566 999.64
R1566 N1566 N1567 746.98
R1567 N1567 N1568 573.13
R1568 N1568 N1569 792.25
R1569 N1569 N1570 841.01
R1570 N1570 N1571 166.38
R1571 N1571 N1572 975.14
R1572 N1572 N1573 678.10
R1573 N1573 N1574 504.98
R1574 N1574 N1575 712.10
R1575 N1575 N1576 410.06
R1576 N1576 N1577 890.16
R1577 N1577 N1578 802.24
R1578 N1578 N1579 675.81
R1579 N1579 N1580 263.77
R1580 N1580 N1581 969.64
R1581 N1581 N1582 489.36
R1582 N1582 N1583 919.64
R1583 N1583 N1584 149.87
R1584 N1584 N1585 211.75
R1585 N1585 N1586 237.71
R1586 N1586 N1587 248.19
R1587 N1587 N1588 390.39
R1588 N1588 N1589 738.40
R1589 N1589 N1590 411.42
R1590 N1590 N1591 946.81
R1591 N1591 N1592 905.43
R1592 N1592 N1593 861.34
R1593 N1593 N1594 325.54
R1594 N1594 N1595 671.55
R1595 N1595 N1596 595.76
R1596 N1596 N1597 212.65
R1597 N1597 N1598 372.54
R1598 N1598 N1599 580.13
R1599 N1599 N1600 552.32
R1600 N1600 N1601 251.77
R1601 N1601 N1602 947.45
R1602 N1602 N1603 238.77
R1603 N1603 N1604 692.86
R1604 N1604 N1605 748.57
R1605 N1605 N1606 644.63
R1606 N1606 N1607 858.28
R1607 N1607 N1608 607.26
R1608 N1608 N1609 842.71
R1609 N1609 N1610 125.54
R1610 N1610 N1611 140.92
R1611 N1611 N1612 677.31
R1612 N1612 N1613 619.09
R1613 N1613 N1614 686.02
R1614 N1614 N1615 790.26
R1615 N1615 N1616 474.93
R1616 N1616 N1617 675.09
R1617 N1617 N1618 548.23
R1618 N1618 N1619 664.45
R1619 N1619 N1620 360.70
R1620 N1620 N1621 960.99
R1621 N1621 N1622 534.65
R1622 N1622 N1623 824.22
R1623 N1623 N1624 716.49
R1624 N1624 N1625 367.69
R1625 N1625 N1626 165.68
R1626 N1626 N1627 153.92
R1627 N1627 N1628 495.64
R1628 N1628 N1629 535.83
R1629 N1629 N1630 283.62
R1630 N1630 N1631 645.99
R1631 N1631 N1632 381.32
R1632 N1632 N1633 746.53
R1633 N1633 N1634 760.78
R1634 N1634 N1635 874.70
R1635 N1635 N1636 977.84
R1636 N1636 N1637 217.69
R1637 N1637 N1638 433.49
R1638 N1638 N1639 605.49
R1639 N1639 N1640 387.20
R1640 N1640 N1641 519.83
R1641 N1641 N1642 340.72
R1642 N1642 N1643 323.13
R1643 N1643 N1644 187.13
R1644 N1644 N1645 361.19
R1645 N1645 N1646 445.73
R1646 N1646 N1647 653.84
R1647 N1647 N1648 323.44
R1648 N1648 N1649 878.78
R1649 N1649 N1650 243.73
R1650 N1650 N1651 394.69
R1651 N1651 N1652 619.92
R1652 N1652 N1653 381.44
R1653 N1653 N1654 786.81
R1654 N1654 N1655 548.44
R1655 N1655 N1656 563.25
R1656 N1656 N1657 548.88
R1657 N1657 N1658 377.69
R1658 N1658 N1659 120.86
R1659 N1659 N1660 950.71
R1660 N1660 N1661 554.90
R1661 N1661 N1662 970.02
R1662 N1662 N1663 293.63
R1663 N1663 N1664 417.61
R1664 N1664 N1665 145.49
R1665 N1665 N1666 545.40
R1666 N1666 N1667 894.11
R1667 N1667 N1668 688.83
R1668 N1668 N1669 523.53
R1669 N1669 N1670 583.02
R1670 N1670 N1671 862.46
R1671 N1671 N1672 487.83
R1672 N1672 N1673 894.21
R1673 N1673 N1674 754.76
R1674 N1674 N1675 787.47
R1675 N1675 N1676 429.34
R1676 N1676 N1677 460.52
R1677 N1677 N1678 613.25
R1678 N1678 N1679 275.19
R1679 N1679 N1680 597.90
R1680 N1680 N1681 166.18
R1681 N1681 N1682 553.83
R1682 N1682 N1683 787.96
R1683 N1683 N1684 351.75
R1684 N1684 N1685 990.18
R1685 N1685 N1686 712.36
R1686 N1686 N1687 206.93
R1687 N1687 N1688 977.57
R1688 N1688 N1689 454.51
R1689 N1689 N1690 815.41
R1690 N1690 N1691 405.18
R1691 N1691 N1692 945.05
R1692 N1692 N1693 779.47
R1693 N1693 N1694 279.15
R1694 N1694 N1695 558.21
R1695 N1695 N1696 550.07
R1696 N1696 N1697 140.77
R1697 N1697 N1698 223.33
R1698 N1698 N1699 399.74
R1699 N1699 N1700 526.37
R1700 N1700 N1701 511.29
R1701 N1701 N1702 645.63
R1702 N1702 N1703 563.96
R1703 N1703 N1704 395.17
R1704 N1704 N1705 651.76
R1705 N1705 N1706 246.25
R1706 N1706 N1707 991.55
R1707 N1707 N1708 765.39
R1708 N1708 N1709 369.31
R1709 N1709 N1710 402.74
R1710 N1710 N1711 845.46
R1711 N1711 N1712 579.11
R1712 N1712 N1713 737.87
R1713 N1713 N1714 369.81
R1714 N1714 N1715 834.17
R1715 N1715 N1716 431.52
R1716 N1716 N1717 706.43
R1717 N1717 N1718 981.91
R1718 N1718 N1719 625.33
R1719 N1719 N1720 817.08
R1720 N1720 N1721 752.79
R1721 N1721 N1722 719.24
R1722 N1722 N1723 123.98
R1723 N1723 N1724 527.13
R1724 N1724 N1725 970.36
R1725 N1725 N1726 804.61
R1726 N1726 N1727 798.55
R1727 N1727 N1728 619.87
R1728 N1728 N1729 749.26
R1729 N1729 N1730 625.17
R1730 N1730 N1731 253.46
R1731 N1731 N1732 666.12
R1732 N1732 N1733 657.76
R1733 N1733 N1734 857.05
R1734 N1734 N1735 233.00
R1735 N1735 N1736 712.65
R1736 N1736 N1737 128.41
R1737 N1737 N1738 953.38
R1738 N1738 N1739 198.91
R1739 N1739 N1740 117.04
R1740 N1740 N1741 382.32
R1741 N1741 N1742 236.29
R1742 N1742 N1743 721.45
R1743 N1743 N1744 469.34
R1744 N1744 N1745 797.48
R1745 N1745 N1746 928.47
R1746 N1746 N1747 885.54
R1747 N1747 N1748 762.25
R1748 N1748 N1749 156.05
R1749 N1749 N1750 224.27
R1750 N1750 N1751 286.61
R1751 N1751 N1752 392.54
R1752 N1752 N1753 696.00
R1753 N1753 N1754 572.93
R1754 N1754 N1755 382.38
R1755 N1755 N1756 255.86
R1756 N1756 N1757 920.91
R1757 N1757 N1758 408.09
R1758 N1758 N1759 418.86
R1759 N1759 N1760 794.79
R1760 N1760 N1761 748.83
R1761 N1761 N1762 678.98
R1762 N1762 N1763 723.98
R1763 N1763 N1764 649.07
R1764 N1764 N1765 273.04
R1765 N1765 N1766 321.87
R1766 N1766 N1767 602.28
R1767 N1767 N1768 302.38
R1768 N1768 N1769 975.62
R1769 N1769 N1770 367.85
R1770 N1770 N1771 360.10
R1771 N1771 N1772 286.55
R1772 N1772 N1773 734.49
R1773 N1773 N1774 385.34
R1774 N1774 N1775 413.92
R1775 N1775 N1776 940.33
R1776 N1776 N1777 815.86
R1777 N1777 N1778 346.11
R1778 N1778 N1779 209.69
R1779 N1779 N1780 708.96
R1780 N1780 N1781 441.72
R1781 N1781 N1782 982.14
R1782 N1782 N1783 836.54
R1783 N1783 N1784 959.15
R1784 N1784 N1785 824.15
R1785 N1785 N1786 361.41
R1786 N1786 N1787 358.87
R1787 N1787 N1788 742.73
R1788 N1788 N1789 411.73
R1789 N1789 N1790 498.14
R1790 N1790 N1791 330.80
R1791 N1791 N1792 531.17
R1792 N1792 N1793 281.86
R1793 N1793 N1794 584.72
R1794 N1794 N1795 939.72
R1795 N1795 N1796 726.55
R1796 N1796 N1797 223.55
R1797 N1797 N1798 654.11
R1798 N1798 N1799 628.15
R1799 N1799 N1800 318.21
R1800 N1800 N1801 702.85
R1801 N1801 N1802 577.94
R1802 N1802 N1803 674.15
R1803 N1803 N1804 147.24
R1804 N1804 N1805 471.97
R1805 N1805 N1806 745.62
R1806 N1806 N1807 190.49
R1807 N1807 N1808 793.69
R1808 N1808 N1809 104.66
R1809 N1809 N1810 595.32
R1810 N1810 N1811 936.19
R1811 N1811 N1812 466.22
R1812 N1812 N1813 941.53
R1813 N1813 N1814 890.56
R1814 N1814 N1815 529.70
R1815 N1815 N1816 279.51
R1816 N1816 N1817 967.52
R1817 N1817 N1818 389.05
R1818 N1818 N1819 681.31
R1819 N1819 N1820 917.14
R1820 N1820 N1821 180.51
R1821 N1821 N1822 616.72
R1822 N1822 N1823 581.64
R1823 N1823 N1824 750.81
R1824 N1824 N1825 943.00
R1825 N1825 N1826 921.91
R1826 N1826 N1827 257.56
R1827 N1827 N1828 894.02
R1828 N1828 N1829 258.21
R1829 N1829 N1830 927.67
R1830 N1830 N1831 997.45
R1831 N1831 N1832 457.30
R1832 N1832 N1833 545.85
R1833 N1833 N1834 942.95
R1834 N1834 N1835 965.92
R1835 N1835 N1836 933.44
R1836 N1836 N1837 889.07
R1837 N1837 N1838 108.34
R1838 N1838 N1839 611.17
R1839 N1839 N1840 196.57
R1840 N1840 N1841 984.69
R1841 N1841 N1842 356.11
R1842 N1842 N1843 990.19
R1843 N1843 N1844 588.97
R1844 N1844 N1845 544.52
R1845 N1845 N1846 944.70
R1846 N1846 N1847 865.95
R1847 N1847 N1848 521.22
R1848 N1848 N1849 273.53
R1849 N1849 N1850 201.38
R1850 N1850 N1851 246.24
R1851 N1851 N1852 513.02
R1852 N1852 N1853 331.54
R1853 N1853 N1854 267.58
R1854 N1854 N1855 762.96
R1855 N1855 N1856 811.69
R1856 N1856 N1857 611.00
R1857 N1857 N1858 781.55
R1858 N1858 N1859 257.95
R1859 N1859 N1860 870.53
R1860 N1860 N1861 907.34
R1861 N1861 N1862 844.29
R1862 N1862 N1863 563.75
R1863 N1863 N1864 178.06
R1864 N1864 N1865 702.33
R1865 N1865 N1866 266.30
R1866 N1866 N1867 226.55
R1867 N1867 N1868 391.24
R1868 N1868 N1869 323.24
R1869 N1869 N1870 334.71
R1870 N1870 N1871 311.97
R1871 N1871 N1872 778.38
R1872 N1872 N1873 958.63
R1873 N1873 N1874 371.75
R1874 N1874 N1875 750.59
R1875 N1875 N1876 110.29
R1876 N1876 N1877 688.32
R1877 N1877 N1878 723.49
R1878 N1878 N1879 155.91
R1879 N1879 N1880 206.40
R1880 N1880 N1881 376.13
R1881 N1881 N1882 464.87
R1882 N1882 N1883 552.27
R1883 N1883 N1884 905.61
R1884 N1884 N1885 733.20
R1885 N1885 N1886 379.88
R1886 N1886 N1887 205.67
R1887 N1887 N1888 924.52
R1888 N1888 N1889 365.53
R1889 N1889 N1890 653.16
R1890 N1890 N1891 297.22
R1891 N1891 N1892 220.21
R1892 N1892 N1893 237.87
R1893 N1893 N1894 772.96
R1894 N1894 N1895 645.17
R1895 N1895 N1896 474.26
R1896 N1896 N1897 594.31
R1897 N1897 N1898 523.75
R1898 N1898 N1899 583.77
R1899 N1899 N1900 697.68
R1900 N1900 N1901 296.57
R1901 N1901 N1902 322.72
R1902 N1902 N1903 779.27
R1903 N1903 N1904 885.82
R1904 N1904 N1905 173.68
R1905 N1905 N1906 502.07
R1906 N1906 N1907 733.39
R1907 N1907 N1908 170.29
R1908 N1908 N1909 607.75
R1909 N1909 N1910 155.58
R1910 N1910 N1911 592.88
R1911 N1911 N1912 554.94
R1912 N1912 N1913 615.43
R1913 N1913 N1914 234.87
R1914 N1914 N1915 395.31
R1915 N1915 N1916 568.31
R1916 N1916 N1917 204.62
R1917 N1917 N1918 284.86
R1918 N1918 N1919 624.83
R1919 N1919 N1920 181.85
R1920 N1920 N1921 559.34
R1921 N1921 N1922 827.82
R1922 N1922 N1923 508.09
R1923 N1923 N1924 561.92
R1924 N1924 N1925 511.12
R1925 N1925 N1926 151.96
R1926 N1926 N1927 516.14
R1927 N1927 N1928 826.22
R1928 N1928 N1929 750.95
R1929 N1929 N1930 456.35
R1930 N1930 N1931 834.81
R1931 N1931 N1932 771.22
R1932 N1932 N1933 620.48
R1933 N1933 N1934 140.76
R1934 N1934 N1935 410.08
R1935 N1935 N1936 157.38
R1936 N1936 N1937 994.71
R1937 N1937 N1938 941.12
R1938 N1938 N1939 162.12
R1939 N1939 N1940 940.40
R1940 N1940 N1941 128.56
R1941 N1941 N1942 467.98
R1942 N1942 N1943 792.07
R1943 N1943 N1944 789.24
R1944 N1944 N1945 980.50
R1945 N1945 N1946 681.29
R1946 N1946 N1947 478.33
R1947 N1947 N1948 993.57
R1948 N1948 N1949 444.23
R1949 N1949 N1950 882.66
R1950 N1950 N1951 916.09
R1951 N1951 N1952 438.08
R1952 N1952 N1953 714.46
R1953 N1953 N1954 695.61
R1954 N1954 N1955 585.37
R1955 N1955 N1956 688.18
R1956 N1956 N1957 412.99
R1957 N1957 N1958 260.63
R1958 N1958 N1959 583.53
R1959 N1959 N1960 575.96
R1960 N1960 N1961 755.07
R1961 N1961 N1962 300.42
R1962 N1962 N1963 103.13
R1963 N1963 N1964 120.46
R1964 N1964 N1965 368.53
R1965 N1965 N1966 706.15
R1966 N1966 N1967 590.00
R1967 N1967 N1968 578.74
R1968 N1968 N1969 841.02
R1969 N1969 N1970 322.76
R1970 N1970 N1971 411.54
R1971 N1971 N1972 348.08
R1972 N1972 N1973 943.67
R1973 N1973 N1974 752.52
R1974 N1974 N1975 201.56
R1975 N1975 N1976 828.53
R1976 N1976 N1977 477.32
R1977 N1977 N1978 789.45
R1978 N1978 N1979 895.38
R1979 N1979 N1980 114.08
R1980 N1980 N1981 285.47
R1981 N1981 N1982 190.81
R1982 N1982 N1983 130.22
R1983 N1983 N1984 638.01
R1984 N1984 N1985 732.96
R1985 N1985 N1986 143.81
R1986 N1986 N1987 766.49
R1987 N1987 N1988 462.04
R1988 N1988 N1989 310.91
R1989 N1989 N1990 295.54
R1990 N1990 N1991 877.36
R1991 N1991 N1992 150.80
R1992 N1992 N1993 553.51
R1993 N1993 N1994 360.34
R1994 N1994 N1995 834.21
R1995 N1995 N1996 758.37
R1996 N1996 N1997 387.01
R1997 N1997 N1998 638.13
R1998 N1998 N1999 705.28
R1999 N1999 N2000 388.60
R2000 N2000 N2001 371.59
R2001 N2001 N2002 228.93
R2002 N2002 N2003 694.19
R2003 N2003 N2004 298.94
R2004 N2004 N2005 370.45
R2005 N2005 N2006 154.86
R2006 N2006 N2007 953.67
R2007 N2007 N2008 891.74
R2008 N2008 N2009 920.42
R2009 N2009 N2010 663.39
R2010 N2010 N2011 484.48
R2011 N2011 N2012 546.06
R2012 N2012 N2013 975.06
R2013 N2013 N2014 947.43
R2014 N2014 N2015 704.21
R2015 N2015 N2016 807.22
R2016 N2016 N2017 386.86
R2017 N2017 N2018 474.69
R2018 N2018 N2019 234.30
R2019 N2019 N2020 438.81
R2020 N2020 N2021 778.97
R2021 N2021 N2022 526.17
R2022 N2022 N2023 864.41
R2023 N2023 N2024 370.66
R2024 N2024 N2025 736.82
R2025 N2025 N2026 825.20
R2026 N2026 N2027 923.27
R2027 N2027 N2028 606.15
R2028 N2028 N2029 971.01
R2029 N2029 N2030 601.56
R2030 N2030 N2031 220.68
R2031 N2031 N2032 318.57
R2032 N2032 N2033 283.00
R2033 N2033 N2034 682.04
R2034 N2034 N2035 930.00
R2035 N2035 N2036 862.42
R2036 N2036 N2037 183.22
R2037 N2037 N2038 752.13
R2038 N2038 N2039 271.43
R2039 N2039 N2040 341.62
R2040 N2040 N2041 706.30
R2041 N2041 N2042 642.63
R2042 N2042 N2043 886.26
R2043 N2043 N2044 269.35
R2044 N2044 N2045 785.53
R2045 N2045 N2046 751.87
R2046 N2046 N2047 602.97
R2047 N2047 N2048 531.45
R2048 N2048 N2049 882.53
R2049 N2049 N2050 399.67
R2050 N2050 N2051 961.32
R2051 N2051 N2052 113.80
R2052 N2052 N2053 943.44
R2053 N2053 N2054 965.87
R2054 N2054 N2055 205.58
R2055 N2055 N2056 999.61
R2056 N2056 N2057 531.03
R2057 N2057 N2058 318.33
R2058 N2058 N2059 643.96
R2059 N2059 N2060 284.06
R2060 N2060 N2061 923.61
R2061 N2061 N2062 596.87
R2062 N2062 N2063 797.96
R2063 N2063 N2064 442.60
R2064 N2064 N2065 580.29
R2065 N2065 N2066 423.33
R2066 N2066 N2067 335.41
R2067 N2067 N2068 561.53
R2068 N2068 N2069 547.55
R2069 N2069 N2070 188.75
R2070 N2070 N2071 983.19
R2071 N2071 N2072 522.54
R2072 N2072 N2073 855.76
R2073 N2073 N2074 922.90
R2074 N2074 N2075 433.63
R2075 N2075 N2076 472.54
R2076 N2076 N2077 606.27
R2077 N2077 N2078 299.15
R2078 N2078 N2079 231.33
R2079 N2079 N2080 334.70
R2080 N2080 N2081 941.28
R2081 N2081 N2082 621.23
R2082 N2082 N2083 475.82
R2083 N2083 N2084 237.17
R2084 N2084 N2085 396.88
R2085 N2085 N2086 441.86
R2086 N2086 N2087 850.03
R2087 N2087 N2088 549.37
R2088 N2088 N2089 689.15
R2089 N2089 N2090 716.36
R2090 N2090 N2091 331.59
R2091 N2091 N2092 839.43
R2092 N2092 N2093 969.86
R2093 N2093 N2094 677.53
R2094 N2094 N2095 541.54
R2095 N2095 N2096 251.41
R2096 N2096 N2097 815.48
R2097 N2097 N2098 252.34
R2098 N2098 N2099 748.28
R2099 N2099 N2100 539.48
R2100 N2100 N2101 925.21
R2101 N2101 N2102 587.92
R2102 N2102 N2103 677.63
R2103 N2103 N2104 152.86
R2104 N2104 N2105 130.44
R2105 N2105 N2106 862.03
R2106 N2106 N2107 950.67
R2107 N2107 N2108 701.39
R2108 N2108 N2109 787.90
R2109 N2109 N2110 471.15
R2110 N2110 N2111 858.29
R2111 N2111 N2112 308.29
R2112 N2112 N2113 736.45
R2113 N2113 N2114 108.23
R2114 N2114 N2115 555.16
R2115 N2115 N2116 435.88
R2116 N2116 N2117 656.05
R2117 N2117 N2118 700.08
R2118 N2118 N2119 654.87
R2119 N2119 N2120 534.88
R2120 N2120 N2121 539.07
R2121 N2121 N2122 105.95
R2122 N2122 N2123 596.48
R2123 N2123 N2124 110.67
R2124 N2124 N2125 576.48
R2125 N2125 N2126 347.27
R2126 N2126 N2127 979.73
R2127 N2127 N2128 115.43
R2128 N2128 N2129 831.84
R2129 N2129 N2130 706.63
R2130 N2130 N2131 825.55
R2131 N2131 N2132 918.80
R2132 N2132 N2133 196.31
R2133 N2133 N2134 186.68
R2134 N2134 N2135 234.01
R2135 N2135 N2136 272.74
R2136 N2136 N2137 573.81
R2137 N2137 N2138 833.69
R2138 N2138 N2139 340.59
R2139 N2139 N2140 457.21
R2140 N2140 N2141 435.75
R2141 N2141 N2142 465.42
R2142 N2142 N2143 608.50
R2143 N2143 N2144 991.21
R2144 N2144 N2145 303.27
R2145 N2145 N2146 715.64
R2146 N2146 N2147 863.08
R2147 N2147 N2148 688.36
R2148 N2148 N2149 872.40
R2149 N2149 N2150 783.63
R2150 N2150 N2151 184.15
R2151 N2151 N2152 441.34
R2152 N2152 N2153 597.43
R2153 N2153 N2154 150.50
R2154 N2154 N2155 108.51
R2155 N2155 N2156 254.25
R2156 N2156 N2157 549.87
R2157 N2157 N2158 490.52
R2158 N2158 N2159 805.94
R2159 N2159 N2160 609.27
R2160 N2160 N2161 872.16
R2161 N2161 N2162 185.83
R2162 N2162 N2163 575.34
R2163 N2163 N2164 138.30
R2164 N2164 N2165 290.28
R2165 N2165 N2166 881.31
R2166 N2166 N2167 898.80
R2167 N2167 N2168 527.95
R2168 N2168 N2169 141.91
R2169 N2169 N2170 166.91
R2170 N2170 N2171 933.03
R2171 N2171 N2172 909.38
R2172 N2172 N2173 607.16
R2173 N2173 N2174 129.61
R2174 N2174 N2175 935.89
R2175 N2175 N2176 383.04
R2176 N2176 N2177 965.32
R2177 N2177 N2178 628.33
R2178 N2178 N2179 777.03
R2179 N2179 N2180 741.44
R2180 N2180 N2181 458.47
R2181 N2181 N2182 169.24
R2182 N2182 N2183 246.21
R2183 N2183 N2184 316.42
R2184 N2184 N2185 851.19
R2185 N2185 N2186 450.24
R2186 N2186 N2187 906.87
R2187 N2187 N2188 398.56
R2188 N2188 N2189 780.05
R2189 N2189 N2190 225.96
R2190 N2190 N2191 989.63
R2191 N2191 N2192 751.75
R2192 N2192 N2193 550.71
R2193 N2193 N2194 976.89
R2194 N2194 N2195 148.33
R2195 N2195 N2196 493.38
R2196 N2196 N2197 854.81
R2197 N2197 N2198 406.53
R2198 N2198 N2199 792.11
R2199 N2199 N2200 959.37
R2200 N2200 N2201 457.03
R2201 N2201 N2202 796.20
R2202 N2202 N2203 126.66
R2203 N2203 N2204 345.99
R2204 N2204 N2205 993.33
R2205 N2205 N2206 541.54
R2206 N2206 N2207 420.23
R2207 N2207 N2208 947.03
R2208 N2208 N2209 488.66
R2209 N2209 N2210 711.73
R2210 N2210 N2211 694.60
R2211 N2211 N2212 177.12
R2212 N2212 N2213 656.75
R2213 N2213 N2214 818.25
R2214 N2214 N2215 741.80
R2215 N2215 N2216 173.83
R2216 N2216 N2217 238.80
R2217 N2217 N2218 740.51
R2218 N2218 N2219 670.51
R2219 N2219 N2220 765.69
R2220 N2220 N2221 385.01
R2221 N2221 N2222 195.90
R2222 N2222 N2223 104.68
R2223 N2223 N2224 377.44
R2224 N2224 N2225 423.93
R2225 N2225 N2226 342.79
R2226 N2226 N2227 219.26
R2227 N2227 N2228 268.65
R2228 N2228 N2229 503.96
R2229 N2229 N2230 599.27
R2230 N2230 N2231 467.24
R2231 N2231 N2232 123.64
R2232 N2232 N2233 418.52
R2233 N2233 N2234 183.76
R2234 N2234 N2235 638.24
R2235 N2235 N2236 391.99
R2236 N2236 N2237 446.71
R2237 N2237 N2238 362.66
R2238 N2238 N2239 449.02
R2239 N2239 N2240 176.23
R2240 N2240 N2241 911.02
R2241 N2241 N2242 914.69
R2242 N2242 N2243 980.36
R2243 N2243 N2244 614.76
R2244 N2244 N2245 252.62
R2245 N2245 N2246 442.66
R2246 N2246 N2247 224.96
R2247 N2247 N2248 371.02
R2248 N2248 N2249 543.81
R2249 N2249 N2250 156.94
R2250 N2250 N2251 491.21
R2251 N2251 N2252 478.99
R2252 N2252 N2253 535.81
R2253 N2253 N2254 169.23
R2254 N2254 N2255 326.53
R2255 N2255 N2256 321.93
R2256 N2256 N2257 662.53
R2257 N2257 N2258 634.43
R2258 N2258 N2259 275.99
R2259 N2259 N2260 196.28
R2260 N2260 N2261 374.19
R2261 N2261 N2262 953.94
R2262 N2262 N2263 399.00
R2263 N2263 N2264 658.17
R2264 N2264 N2265 823.67
R2265 N2265 N2266 396.59
R2266 N2266 N2267 401.26
R2267 N2267 N2268 833.93
R2268 N2268 N2269 873.56
R2269 N2269 N2270 976.80
R2270 N2270 N2271 222.51
R2271 N2271 N2272 388.60
R2272 N2272 N2273 952.55
R2273 N2273 N2274 280.77
R2274 N2274 N2275 382.76
R2275 N2275 N2276 968.12
R2276 N2276 N2277 971.85
R2277 N2277 N2278 362.30
R2278 N2278 N2279 725.46
R2279 N2279 N2280 541.91
R2280 N2280 N2281 618.29
R2281 N2281 N2282 318.18
R2282 N2282 N2283 438.45
R2283 N2283 N2284 834.85
R2284 N2284 N2285 453.64
R2285 N2285 N2286 202.50
R2286 N2286 N2287 607.47
R2287 N2287 N2288 633.00
R2288 N2288 N2289 591.07
R2289 N2289 N2290 713.54
R2290 N2290 N2291 595.09
R2291 N2291 N2292 957.70
R2292 N2292 N2293 515.46
R2293 N2293 N2294 737.53
R2294 N2294 N2295 494.61
R2295 N2295 N2296 362.20
R2296 N2296 N2297 723.55
R2297 N2297 N2298 837.07
R2298 N2298 N2299 816.09
R2299 N2299 N2300 468.23
R2300 N2300 N2301 549.37
R2301 N2301 N2302 670.00
R2302 N2302 N2303 317.82
R2303 N2303 N2304 692.80
R2304 N2304 N2305 743.71
R2305 N2305 N2306 810.17
R2306 N2306 N2307 166.57
R2307 N2307 N2308 991.63
R2308 N2308 N2309 531.31
R2309 N2309 N2310 460.72
R2310 N2310 N2311 555.95
R2311 N2311 N2312 928.35
R2312 N2312 N2313 722.54
R2313 N2313 N2314 589.28
R2314 N2314 N2315 811.65
R2315 N2315 N2316 423.58
R2316 N2316 N2317 905.95
R2317 N2317 N2318 583.22
R2318 N2318 N2319 674.36
R2319 N2319 N2320 176.48
R2320 N2320 N2321 792.06
R2321 N2321 N2322 691.84
R2322 N2322 N2323 419.51
R2323 N2323 N2324 682.30
R2324 N2324 N2325 139.87
R2325 N2325 N2326 985.25
R2326 N2326 N2327 709.72
R2327 N2327 N2328 459.66
R2328 N2328 N2329 777.41
R2329 N2329 N2330 969.15
R2330 N2330 N2331 487.41
R2331 N2331 N2332 109.49
R2332 N2332 N2333 332.86
R2333 N2333 N2334 559.61
R2334 N2334 N2335 566.92
R2335 N2335 N2336 622.47
R2336 N2336 N2337 617.71
R2337 N2337 N2338 501.20
R2338 N2338 N2339 452.02
R2339 N2339 N2340 795.11
R2340 N2340 N2341 629.73
R2341 N2341 N2342 550.42
R2342 N2342 N2343 410.47
R2343 N2343 N2344 122.11
R2344 N2344 N2345 194.09
R2345 N2345 N2346 474.38
R2346 N2346 N2347 965.56
R2347 N2347 N2348 204.46
R2348 N2348 N2349 946.61
R2349 N2349 N2350 227.51
R2350 N2350 N2351 380.70
R2351 N2351 N2352 509.80
R2352 N2352 N2353 286.18
R2353 N2353 N2354 534.63
R2354 N2354 N2355 528.55
R2355 N2355 N2356 494.35
R2356 N2356 N2357 727.09
R2357 N2357 N2358 387.02
R2358 N2358 N2359 370.24
R2359 N2359 N2360 829.17
R2360 N2360 N2361 203.58
R2361 N2361 N2362 864.26
R2362 N2362 N2363 683.17
R2363 N2363 N2364 709.43
R2364 N2364 N2365 247.92
R2365 N2365 N2366 985.51
R2366 N2366 N2367 319.52
R2367 N2367 N2368 257.01
R2368 N2368 N2369 244.12
R2369 N2369 N2370 603.86
R2370 N2370 N2371 962.62
R2371 N2371 N2372 308.67
R2372 N2372 N2373 464.54
R2373 N2373 N2374 266.01
R2374 N2374 N2375 676.43
R2375 N2375 N2376 488.92
R2376 N2376 N2377 126.27
R2377 N2377 N2378 652.70
R2378 N2378 N2379 277.59
R2379 N2379 N2380 632.98
R2380 N2380 N2381 449.95
R2381 N2381 N2382 734.26
R2382 N2382 N2383 285.21
R2383 N2383 N2384 777.09
R2384 N2384 N2385 827.86
R2385 N2385 N2386 156.31
R2386 N2386 N2387 191.58
R2387 N2387 N2388 884.78
R2388 N2388 N2389 268.26
R2389 N2389 N2390 393.39
R2390 N2390 N2391 511.80
R2391 N2391 N2392 336.12
R2392 N2392 N2393 876.37
R2393 N2393 N2394 574.94
R2394 N2394 N2395 675.20
R2395 N2395 N2396 637.27
R2396 N2396 N2397 650.18
R2397 N2397 N2398 628.30
R2398 N2398 N2399 413.13
R2399 N2399 N2400 860.97
R2400 N2400 N2401 655.63
R2401 N2401 N2402 832.36
R2402 N2402 N2403 735.39
R2403 N2403 N2404 367.70
R2404 N2404 N2405 653.04
R2405 N2405 N2406 176.28
R2406 N2406 N2407 220.55
R2407 N2407 N2408 206.08
R2408 N2408 N2409 374.84
R2409 N2409 N2410 264.74
R2410 N2410 N2411 724.09
R2411 N2411 N2412 559.74
R2412 N2412 N2413 476.42
R2413 N2413 N2414 224.08
R2414 N2414 N2415 445.34
R2415 N2415 N2416 267.18
R2416 N2416 N2417 671.95
R2417 N2417 N2418 724.09
R2418 N2418 N2419 680.73
R2419 N2419 N2420 999.91
R2420 N2420 N2421 599.42
R2421 N2421 N2422 540.68
R2422 N2422 N2423 226.27
R2423 N2423 N2424 383.12
R2424 N2424 N2425 505.90
R2425 N2425 N2426 148.25
R2426 N2426 N2427 423.14
R2427 N2427 N2428 108.63
R2428 N2428 N2429 222.88
R2429 N2429 N2430 833.69
R2430 N2430 N2431 967.45
R2431 N2431 N2432 554.89
R2432 N2432 N2433 545.47
R2433 N2433 N2434 716.23
R2434 N2434 N2435 474.07
R2435 N2435 N2436 855.90
R2436 N2436 N2437 539.83
R2437 N2437 N2438 174.40
R2438 N2438 N2439 127.77
R2439 N2439 N2440 784.95
R2440 N2440 N2441 362.88
R2441 N2441 N2442 347.37
R2442 N2442 N2443 583.85
R2443 N2443 N2444 251.39
R2444 N2444 N2445 511.59
R2445 N2445 N2446 768.27
R2446 N2446 N2447 789.33
R2447 N2447 N2448 594.75
R2448 N2448 N2449 201.89
R2449 N2449 N2450 202.79
R2450 N2450 N2451 797.60
R2451 N2451 N2452 840.95
R2452 N2452 N2453 430.18
R2453 N2453 N2454 840.35
R2454 N2454 N2455 137.45
R2455 N2455 N2456 747.08
R2456 N2456 N2457 591.72
R2457 N2457 N2458 990.80
R2458 N2458 N2459 192.17
R2459 N2459 N2460 847.06
R2460 N2460 N2461 776.21
R2461 N2461 N2462 367.94
R2462 N2462 N2463 999.38
R2463 N2463 N2464 504.76
R2464 N2464 N2465 413.72
R2465 N2465 N2466 835.06
R2466 N2466 N2467 495.16
R2467 N2467 N2468 994.56
R2468 N2468 N2469 798.07
R2469 N2469 N2470 313.25
R2470 N2470 N2471 829.63
R2471 N2471 N2472 629.13
R2472 N2472 N2473 415.57
R2473 N2473 N2474 739.68
R2474 N2474 N2475 669.49
R2475 N2475 N2476 249.38
R2476 N2476 N2477 225.31
R2477 N2477 N2478 285.96
R2478 N2478 N2479 286.25
R2479 N2479 N2480 153.42
R2480 N2480 N2481 415.73
R2481 N2481 N2482 352.98
R2482 N2482 N2483 584.89
R2483 N2483 N2484 391.29
R2484 N2484 N2485 733.65
R2485 N2485 N2486 360.40
R2486 N2486 N2487 340.61
R2487 N2487 N2488 872.22
R2488 N2488 N2489 986.94
R2489 N2489 N2490 711.37
R2490 N2490 N2491 185.70
R2491 N2491 N2492 966.49
R2492 N2492 N2493 807.12
R2493 N2493 N2494 926.89
R2494 N2494 N2495 993.24
R2495 N2495 N2496 880.34
R2496 N2496 N2497 214.20
R2497 N2497 N2498 879.47
R2498 N2498 N2499 324.71
R2499 N2499 N2500 740.26
R2500 N2500 N2501 845.63
R2501 N2501 N2502 785.33
R2502 N2502 N2503 708.61
R2503 N2503 N2504 540.51
R2504 N2504 N2505 619.68
R2505 N2505 N2506 341.85
R2506 N2506 N2507 472.80
R2507 N2507 N2508 506.79
R2508 N2508 N2509 670.26
R2509 N2509 N2510 892.11
R2510 N2510 N2511 183.79
R2511 N2511 N2512 564.05
R2512 N2512 N2513 350.40
R2513 N2513 N2514 942.70
R2514 N2514 N2515 432.16
R2515 N2515 N2516 955.23
R2516 N2516 N2517 394.56
R2517 N2517 N2518 102.23
R2518 N2518 N2519 796.72
R2519 N2519 N2520 759.45
R2520 N2520 N2521 757.84
R2521 N2521 N2522 512.60
R2522 N2522 N2523 697.73
R2523 N2523 N2524 422.40
R2524 N2524 N2525 157.00
R2525 N2525 N2526 580.98
R2526 N2526 N2527 296.05
R2527 N2527 N2528 486.68
R2528 N2528 N2529 290.67
R2529 N2529 N2530 341.68
R2530 N2530 N2531 845.51
R2531 N2531 N2532 403.98
R2532 N2532 N2533 620.14
R2533 N2533 N2534 609.53
R2534 N2534 N2535 536.80
R2535 N2535 N2536 409.37
R2536 N2536 N2537 714.30
R2537 N2537 N2538 143.57
R2538 N2538 N2539 189.62
R2539 N2539 N2540 805.50
R2540 N2540 N2541 513.62
R2541 N2541 N2542 211.81
R2542 N2542 N2543 871.89
R2543 N2543 N2544 497.16
R2544 N2544 N2545 100.61
R2545 N2545 N2546 962.23
R2546 N2546 N2547 282.09
R2547 N2547 N2548 719.73
R2548 N2548 N2549 218.72
R2549 N2549 N2550 685.00
R2550 N2550 N2551 243.08
R2551 N2551 N2552 939.45
R2552 N2552 N2553 346.62
R2553 N2553 N2554 689.13
R2554 N2554 N2555 325.35
R2555 N2555 N2556 434.66
R2556 N2556 N2557 913.42
R2557 N2557 N2558 248.97
R2558 N2558 N2559 456.71
R2559 N2559 N2560 374.96
R2560 N2560 N2561 729.50
R2561 N2561 N2562 310.73
R2562 N2562 N2563 689.94
R2563 N2563 N2564 733.33
R2564 N2564 N2565 100.98
R2565 N2565 N2566 529.13
R2566 N2566 N2567 219.43
R2567 N2567 N2568 303.57
R2568 N2568 N2569 711.98
R2569 N2569 N2570 108.36
R2570 N2570 N2571 726.04
R2571 N2571 N2572 835.40
R2572 N2572 N2573 989.34
R2573 N2573 N2574 480.08
R2574 N2574 N2575 218.96
R2575 N2575 N2576 163.75
R2576 N2576 N2577 444.76
R2577 N2577 N2578 757.69
R2578 N2578 N2579 192.18
R2579 N2579 N2580 382.02
R2580 N2580 N2581 892.89
R2581 N2581 N2582 223.42
R2582 N2582 N2583 796.11
R2583 N2583 N2584 777.84
R2584 N2584 N2585 219.83
R2585 N2585 N2586 993.65
R2586 N2586 N2587 228.57
R2587 N2587 N2588 577.46
R2588 N2588 N2589 107.63
R2589 N2589 N2590 685.02
R2590 N2590 N2591 496.09
R2591 N2591 N2592 750.19
R2592 N2592 N2593 665.27
R2593 N2593 N2594 236.24
R2594 N2594 N2595 470.54
R2595 N2595 N2596 717.91
R2596 N2596 N2597 873.97
R2597 N2597 N2598 178.02
R2598 N2598 N2599 190.42
R2599 N2599 N2600 777.20
R2600 N2600 N2601 630.62
R2601 N2601 N2602 445.63
R2602 N2602 N2603 966.92
R2603 N2603 N2604 383.05
R2604 N2604 N2605 225.85
R2605 N2605 N2606 349.27
R2606 N2606 N2607 175.82
R2607 N2607 N2608 598.06
R2608 N2608 N2609 640.01
R2609 N2609 N2610 646.83
R2610 N2610 N2611 801.07
R2611 N2611 N2612 721.43
R2612 N2612 N2613 863.10
R2613 N2613 N2614 692.56
R2614 N2614 N2615 371.48
R2615 N2615 N2616 565.97
R2616 N2616 N2617 558.57
R2617 N2617 N2618 773.06
R2618 N2618 N2619 365.99
R2619 N2619 N2620 149.11
R2620 N2620 N2621 908.12
R2621 N2621 N2622 959.20
R2622 N2622 N2623 545.40
R2623 N2623 N2624 201.47
R2624 N2624 N2625 549.62
R2625 N2625 N2626 634.54
R2626 N2626 N2627 575.46
R2627 N2627 N2628 979.93
R2628 N2628 N2629 988.19
R2629 N2629 N2630 940.53
R2630 N2630 N2631 218.78
R2631 N2631 N2632 874.73
R2632 N2632 N2633 611.54
R2633 N2633 N2634 428.87
R2634 N2634 N2635 714.65
R2635 N2635 N2636 786.45
R2636 N2636 N2637 959.01
R2637 N2637 N2638 793.33
R2638 N2638 N2639 115.02
R2639 N2639 N2640 160.78
R2640 N2640 N2641 335.97
R2641 N2641 N2642 135.84
R2642 N2642 N2643 154.42
R2643 N2643 N2644 810.36
R2644 N2644 N2645 555.95
R2645 N2645 N2646 665.71
R2646 N2646 N2647 550.94
R2647 N2647 N2648 473.89
R2648 N2648 N2649 731.63
R2649 N2649 N2650 174.19
R2650 N2650 N2651 582.91
R2651 N2651 N2652 654.44
R2652 N2652 N2653 349.72
R2653 N2653 N2654 378.92
R2654 N2654 N2655 560.17
R2655 N2655 N2656 282.88
R2656 N2656 N2657 827.25
R2657 N2657 N2658 582.75
R2658 N2658 N2659 451.66
R2659 N2659 N2660 670.86
R2660 N2660 N2661 851.07
R2661 N2661 N2662 712.95
R2662 N2662 N2663 159.50
R2663 N2663 N2664 728.81
R2664 N2664 N2665 756.96
R2665 N2665 N2666 861.82
R2666 N2666 N2667 152.12
R2667 N2667 N2668 177.59
R2668 N2668 N2669 491.04
R2669 N2669 N2670 508.03
R2670 N2670 N2671 647.95
R2671 N2671 N2672 378.36
R2672 N2672 N2673 767.52
R2673 N2673 N2674 766.59
R2674 N2674 N2675 207.50
R2675 N2675 N2676 737.11
R2676 N2676 N2677 731.35
R2677 N2677 N2678 247.45
R2678 N2678 N2679 957.71
R2679 N2679 N2680 570.70
R2680 N2680 N2681 804.69
R2681 N2681 N2682 748.69
R2682 N2682 N2683 250.27
R2683 N2683 N2684 214.24
R2684 N2684 N2685 803.01
R2685 N2685 N2686 341.89
R2686 N2686 N2687 897.77
R2687 N2687 N2688 794.29
R2688 N2688 N2689 126.42
R2689 N2689 N2690 826.40
R2690 N2690 N2691 344.78
R2691 N2691 N2692 157.48
R2692 N2692 N2693 741.09
R2693 N2693 N2694 618.99
R2694 N2694 N2695 169.36
R2695 N2695 N2696 509.68
R2696 N2696 N2697 424.11
R2697 N2697 N2698 549.65
R2698 N2698 N2699 610.20
R2699 N2699 N2700 430.92
R2700 N2700 N2701 329.60
R2701 N2701 N2702 192.61
R2702 N2702 N2703 616.52
R2703 N2703 N2704 750.50
R2704 N2704 N2705 305.56
R2705 N2705 N2706 557.94
R2706 N2706 N2707 139.63
R2707 N2707 N2708 876.64
R2708 N2708 N2709 320.10
R2709 N2709 N2710 524.59
R2710 N2710 N2711 444.68
R2711 N2711 N2712 235.08
R2712 N2712 N2713 938.04
R2713 N2713 N2714 871.74
R2714 N2714 N2715 597.58
R2715 N2715 N2716 922.55
R2716 N2716 N2717 766.60
R2717 N2717 N2718 477.43
R2718 N2718 N2719 389.62
R2719 N2719 N2720 474.63
R2720 N2720 N2721 748.26
R2721 N2721 N2722 344.13
R2722 N2722 N2723 170.10
R2723 N2723 N2724 435.53
R2724 N2724 N2725 551.84
R2725 N2725 N2726 911.75
R2726 N2726 N2727 261.41
R2727 N2727 N2728 823.90
R2728 N2728 N2729 983.27
R2729 N2729 N2730 958.67
R2730 N2730 N2731 162.03
R2731 N2731 N2732 518.58
R2732 N2732 N2733 354.08
R2733 N2733 N2734 860.36
R2734 N2734 N2735 394.57
R2735 N2735 N2736 597.78
R2736 N2736 N2737 107.17
R2737 N2737 N2738 280.60
R2738 N2738 N2739 607.43
R2739 N2739 N2740 373.52
R2740 N2740 N2741 660.45
R2741 N2741 N2742 517.53
R2742 N2742 N2743 632.52
R2743 N2743 N2744 544.02
R2744 N2744 N2745 795.35
R2745 N2745 N2746 275.88
R2746 N2746 N2747 910.40
R2747 N2747 N2748 784.43
R2748 N2748 N2749 320.61
R2749 N2749 N2750 105.74
R2750 N2750 N2751 469.03
R2751 N2751 N2752 309.70
R2752 N2752 N2753 411.78
R2753 N2753 N2754 855.62
R2754 N2754 N2755 889.48
R2755 N2755 N2756 955.89
R2756 N2756 N2757 101.32
R2757 N2757 N2758 691.57
R2758 N2758 N2759 864.11
R2759 N2759 N2760 754.49
R2760 N2760 N2761 193.55
R2761 N2761 N2762 576.83
R2762 N2762 N2763 314.35
R2763 N2763 N2764 542.83
R2764 N2764 N2765 153.91
R2765 N2765 N2766 997.26
R2766 N2766 N2767 740.49
R2767 N2767 N2768 183.72
R2768 N2768 N2769 929.15
R2769 N2769 N2770 907.56
R2770 N2770 N2771 567.78
R2771 N2771 N2772 730.76
R2772 N2772 N2773 435.24
R2773 N2773 N2774 977.10
R2774 N2774 N2775 176.41
R2775 N2775 N2776 186.02
R2776 N2776 N2777 220.16
R2777 N2777 N2778 837.97
R2778 N2778 N2779 167.35
R2779 N2779 N2780 611.04
R2780 N2780 N2781 491.48
R2781 N2781 N2782 967.80
R2782 N2782 N2783 313.09
R2783 N2783 N2784 334.89
R2784 N2784 N2785 383.51
R2785 N2785 N2786 820.74
R2786 N2786 N2787 730.65
R2787 N2787 N2788 761.82
R2788 N2788 N2789 386.25
R2789 N2789 N2790 344.76
R2790 N2790 N2791 167.22
R2791 N2791 N2792 282.44
R2792 N2792 N2793 801.94
R2793 N2793 N2794 626.24
R2794 N2794 N2795 239.87
R2795 N2795 N2796 247.94
R2796 N2796 N2797 519.45
R2797 N2797 N2798 465.86
R2798 N2798 N2799 582.33
R2799 N2799 N2800 968.17
R2800 N2800 N2801 286.87
R2801 N2801 N2802 377.48
R2802 N2802 N2803 338.51
R2803 N2803 N2804 207.92
R2804 N2804 N2805 241.85
R2805 N2805 N2806 717.45
R2806 N2806 N2807 843.75
R2807 N2807 N2808 727.19
R2808 N2808 N2809 136.30
R2809 N2809 N2810 852.33
R2810 N2810 N2811 395.01
R2811 N2811 N2812 182.09
R2812 N2812 N2813 323.40
R2813 N2813 N2814 420.17
R2814 N2814 N2815 562.11
R2815 N2815 N2816 709.47
R2816 N2816 N2817 334.15
R2817 N2817 N2818 991.61
R2818 N2818 N2819 127.97
R2819 N2819 N2820 463.95
R2820 N2820 N2821 506.98
R2821 N2821 N2822 773.27
R2822 N2822 N2823 324.87
R2823 N2823 N2824 515.84
R2824 N2824 N2825 823.51
R2825 N2825 N2826 225.81
R2826 N2826 N2827 110.76
R2827 N2827 N2828 847.34
R2828 N2828 N2829 984.31
R2829 N2829 N2830 217.64
R2830 N2830 N2831 841.31
R2831 N2831 N2832 435.02
R2832 N2832 N2833 667.27
R2833 N2833 N2834 680.22
R2834 N2834 N2835 624.09
R2835 N2835 N2836 332.94
R2836 N2836 N2837 831.47
R2837 N2837 N2838 119.62
R2838 N2838 N2839 158.02
R2839 N2839 N2840 912.25
R2840 N2840 N2841 499.09
R2841 N2841 N2842 215.91
R2842 N2842 N2843 914.57
R2843 N2843 N2844 846.42
R2844 N2844 N2845 398.39
R2845 N2845 N2846 138.43
R2846 N2846 N2847 514.90
R2847 N2847 N2848 251.19
R2848 N2848 N2849 616.50
R2849 N2849 N2850 839.52
R2850 N2850 N2851 455.50
R2851 N2851 N2852 126.53
R2852 N2852 N2853 714.89
R2853 N2853 N2854 255.53
R2854 N2854 N2855 293.24
R2855 N2855 N2856 268.44
R2856 N2856 N2857 351.87
R2857 N2857 N2858 895.08
R2858 N2858 N2859 131.18
R2859 N2859 N2860 657.26
R2860 N2860 N2861 321.21
R2861 N2861 N2862 365.59
R2862 N2862 N2863 470.79
R2863 N2863 N2864 595.62
R2864 N2864 N2865 154.88
R2865 N2865 N2866 351.80
R2866 N2866 N2867 223.51
R2867 N2867 N2868 279.51
R2868 N2868 N2869 896.19
R2869 N2869 N2870 573.23
R2870 N2870 N2871 667.68
R2871 N2871 N2872 821.95
R2872 N2872 N2873 815.36
R2873 N2873 N2874 990.46
R2874 N2874 N2875 803.72
R2875 N2875 N2876 423.20
R2876 N2876 N2877 590.07
R2877 N2877 N2878 536.21
R2878 N2878 N2879 921.41
R2879 N2879 N2880 552.15
R2880 N2880 N2881 449.54
R2881 N2881 N2882 261.83
R2882 N2882 N2883 386.99
R2883 N2883 N2884 297.12
R2884 N2884 N2885 906.19
R2885 N2885 N2886 800.68
R2886 N2886 N2887 152.73
R2887 N2887 N2888 992.38
R2888 N2888 N2889 576.49
R2889 N2889 N2890 790.16
R2890 N2890 N2891 999.65
R2891 N2891 N2892 976.58
R2892 N2892 N2893 190.12
R2893 N2893 N2894 691.18
R2894 N2894 N2895 339.87
R2895 N2895 N2896 834.66
R2896 N2896 N2897 925.53
R2897 N2897 N2898 150.32
R2898 N2898 N2899 996.75
R2899 N2899 N2900 297.47
R2900 N2900 N2901 861.85
R2901 N2901 N2902 817.65
R2902 N2902 N2903 419.32
R2903 N2903 N2904 855.30
R2904 N2904 N2905 860.70
R2905 N2905 N2906 258.49
R2906 N2906 N2907 633.27
R2907 N2907 N2908 825.59
R2908 N2908 N2909 727.86
R2909 N2909 N2910 922.58
R2910 N2910 N2911 125.39
R2911 N2911 N2912 730.50
R2912 N2912 N2913 952.80
R2913 N2913 N2914 607.25
R2914 N2914 N2915 606.80
R2915 N2915 N2916 269.41
R2916 N2916 N2917 989.21
R2917 N2917 N2918 893.46
R2918 N2918 N2919 543.00
R2919 N2919 N2920 378.15
R2920 N2920 N2921 541.39
R2921 N2921 N2922 181.23
R2922 N2922 N2923 309.36
R2923 N2923 N2924 296.93
R2924 N2924 N2925 573.80
R2925 N2925 N2926 100.62
R2926 N2926 N2927 926.11
R2927 N2927 N2928 281.32
R2928 N2928 N2929 217.44
R2929 N2929 N2930 745.24
R2930 N2930 N2931 926.90
R2931 N2931 N2932 859.86
R2932 N2932 N2933 391.23
R2933 N2933 N2934 119.72
R2934 N2934 N2935 627.95
R2935 N2935 N2936 925.50
R2936 N2936 N2937 796.93
R2937 N2937 N2938 861.83
R2938 N2938 N2939 874.60
R2939 N2939 N2940 964.50
R2940 N2940 N2941 436.23
R2941 N2941 N2942 947.73
R2942 N2942 N2943 456.04
R2943 N2943 N2944 190.93
R2944 N2944 N2945 371.59
R2945 N2945 N2946 222.81
R2946 N2946 N2947 241.75
R2947 N2947 N2948 953.82
R2948 N2948 N2949 812.66
R2949 N2949 N2950 964.60
R2950 N2950 N2951 684.26
R2951 N2951 N2952 256.78
R2952 N2952 N2953 971.87
R2953 N2953 N2954 724.20
R2954 N2954 N2955 935.96
R2955 N2955 N2956 808.29
R2956 N2956 N2957 300.91
R2957 N2957 N2958 630.06
R2958 N2958 N2959 257.82
R2959 N2959 N2960 376.14
R2960 N2960 N2961 719.65
R2961 N2961 N2962 214.61
R2962 N2962 N2963 755.95
R2963 N2963 N2964 953.91
R2964 N2964 N2965 953.83
R2965 N2965 N2966 452.44
R2966 N2966 N2967 994.85
R2967 N2967 N2968 968.67
R2968 N2968 N2969 129.14
R2969 N2969 N2970 642.15
R2970 N2970 N2971 928.93
R2971 N2971 N2972 970.78
R2972 N2972 N2973 298.81
R2973 N2973 N2974 609.00
R2974 N2974 N2975 943.02
R2975 N2975 N2976 226.58
R2976 N2976 N2977 770.81
R2977 N2977 N2978 314.20
R2978 N2978 N2979 984.14
R2979 N2979 N2980 251.10
R2980 N2980 N2981 896.79
R2981 N2981 N2982 179.85
R2982 N2982 N2983 738.07
R2983 N2983 N2984 675.19
R2984 N2984 N2985 897.99
R2985 N2985 N2986 501.97
R2986 N2986 N2987 338.69
R2987 N2987 N2988 324.59
R2988 N2988 N2989 161.02
R2989 N2989 N2990 330.99
R2990 N2990 N2991 197.23
R2991 N2991 N2992 101.15
R2992 N2992 N2993 447.34
R2993 N2993 N2994 759.33
R2994 N2994 N2995 972.19
R2995 N2995 N2996 896.10
R2996 N2996 N2997 543.77
R2997 N2997 N2998 440.84
R2998 N2998 N2999 591.42
R2999 N2999 N3000 191.29
R3000 N3000 N3001 531.54
R3001 N3001 N3002 877.65
R3002 N3002 N3003 685.87
R3003 N3003 N3004 718.44
R3004 N3004 N3005 246.39
R3005 N3005 N3006 166.34
R3006 N3006 N3007 861.19
R3007 N3007 N3008 365.42
R3008 N3008 N3009 386.85
R3009 N3009 N3010 956.50
R3010 N3010 N3011 166.78
R3011 N3011 N3012 253.09
R3012 N3012 N3013 437.91
R3013 N3013 N3014 758.79
R3014 N3014 N3015 592.34
R3015 N3015 N3016 908.31
R3016 N3016 N3017 183.79
R3017 N3017 N3018 634.63
R3018 N3018 N3019 652.28
R3019 N3019 N3020 534.46
R3020 N3020 N3021 127.89
R3021 N3021 N3022 948.20
R3022 N3022 N3023 248.50
R3023 N3023 N3024 900.78
R3024 N3024 N3025 241.39
R3025 N3025 N3026 191.13
R3026 N3026 N3027 285.00
R3027 N3027 N3028 270.99
R3028 N3028 N3029 727.48
R3029 N3029 N3030 749.83
R3030 N3030 N3031 756.98
R3031 N3031 N3032 338.74
R3032 N3032 N3033 353.37
R3033 N3033 N3034 313.79
R3034 N3034 N3035 144.67
R3035 N3035 N3036 614.59
R3036 N3036 N3037 855.87
R3037 N3037 N3038 238.23
R3038 N3038 N3039 424.75
R3039 N3039 N3040 484.85
R3040 N3040 N3041 365.09
R3041 N3041 N3042 695.82
R3042 N3042 N3043 640.19
R3043 N3043 N3044 279.71
R3044 N3044 N3045 123.16
R3045 N3045 N3046 253.75
R3046 N3046 N3047 362.63
R3047 N3047 N3048 173.74
R3048 N3048 N3049 859.39
R3049 N3049 N3050 377.52
R3050 N3050 N3051 457.72
R3051 N3051 N3052 540.19
R3052 N3052 N3053 694.94
R3053 N3053 N3054 182.02
R3054 N3054 N3055 589.71
R3055 N3055 N3056 266.39
R3056 N3056 N3057 896.94
R3057 N3057 N3058 432.46
R3058 N3058 N3059 501.20
R3059 N3059 N3060 336.97
R3060 N3060 N3061 518.55
R3061 N3061 N3062 303.62
R3062 N3062 N3063 341.71
R3063 N3063 N3064 155.48
R3064 N3064 N3065 777.01
R3065 N3065 N3066 700.72
R3066 N3066 N3067 177.14
R3067 N3067 N3068 409.41
R3068 N3068 N3069 587.30
R3069 N3069 N3070 973.63
R3070 N3070 N3071 630.75
R3071 N3071 N3072 598.24
R3072 N3072 N3073 856.72
R3073 N3073 N3074 836.56
R3074 N3074 N3075 476.77
R3075 N3075 N3076 581.96
R3076 N3076 N3077 880.20
R3077 N3077 N3078 527.34
R3078 N3078 N3079 893.49
R3079 N3079 N3080 528.64
R3080 N3080 N3081 171.06
R3081 N3081 N3082 912.50
R3082 N3082 N3083 742.88
R3083 N3083 N3084 551.89
R3084 N3084 N3085 910.41
R3085 N3085 N3086 820.41
R3086 N3086 N3087 709.78
R3087 N3087 N3088 658.25
R3088 N3088 N3089 208.25
R3089 N3089 N3090 781.47
R3090 N3090 N3091 255.59
R3091 N3091 N3092 985.93
R3092 N3092 N3093 974.95
R3093 N3093 N3094 827.61
R3094 N3094 N3095 213.57
R3095 N3095 N3096 481.04
R3096 N3096 N3097 989.45
R3097 N3097 N3098 491.85
R3098 N3098 N3099 997.54
R3099 N3099 N3100 664.50
R3100 N3100 N3101 850.70
R3101 N3101 N3102 332.10
R3102 N3102 N3103 919.72
R3103 N3103 N3104 922.76
R3104 N3104 N3105 160.31
R3105 N3105 N3106 449.29
R3106 N3106 N3107 457.62
R3107 N3107 N3108 393.51
R3108 N3108 N3109 348.58
R3109 N3109 N3110 512.34
R3110 N3110 N3111 886.12
R3111 N3111 N3112 807.90
R3112 N3112 N3113 660.75
R3113 N3113 N3114 570.31
R3114 N3114 N3115 477.63
R3115 N3115 N3116 473.00
R3116 N3116 N3117 233.38
R3117 N3117 N3118 629.14
R3118 N3118 N3119 782.54
R3119 N3119 N3120 945.68
R3120 N3120 N3121 932.44
R3121 N3121 N3122 606.42
R3122 N3122 N3123 190.89
R3123 N3123 N3124 357.48
R3124 N3124 N3125 582.07
R3125 N3125 N3126 409.48
R3126 N3126 N3127 469.80
R3127 N3127 N3128 444.74
R3128 N3128 N3129 537.03
R3129 N3129 N3130 648.07
R3130 N3130 N3131 133.72
R3131 N3131 N3132 347.87
R3132 N3132 N3133 229.47
R3133 N3133 N3134 647.79
R3134 N3134 N3135 724.30
R3135 N3135 N3136 134.90
R3136 N3136 N3137 900.62
R3137 N3137 N3138 398.34
R3138 N3138 N3139 313.82
R3139 N3139 N3140 771.17
R3140 N3140 N3141 928.75
R3141 N3141 N3142 907.33
R3142 N3142 N3143 118.21
R3143 N3143 N3144 835.65
R3144 N3144 N3145 372.75
R3145 N3145 N3146 352.31
R3146 N3146 N3147 542.46
R3147 N3147 N3148 726.56
R3148 N3148 N3149 188.40
R3149 N3149 N3150 882.01
R3150 N3150 N3151 220.95
R3151 N3151 N3152 976.80
R3152 N3152 N3153 498.80
R3153 N3153 N3154 843.24
R3154 N3154 N3155 342.48
R3155 N3155 N3156 475.10
R3156 N3156 N3157 681.00
R3157 N3157 N3158 269.14
R3158 N3158 N3159 290.25
R3159 N3159 N3160 841.57
R3160 N3160 N3161 766.85
R3161 N3161 N3162 783.54
R3162 N3162 N3163 880.47
R3163 N3163 N3164 838.92
R3164 N3164 N3165 563.74
R3165 N3165 N3166 243.08
R3166 N3166 N3167 380.01
R3167 N3167 N3168 556.12
R3168 N3168 N3169 222.08
R3169 N3169 N3170 866.17
R3170 N3170 N3171 891.40
R3171 N3171 N3172 126.05
R3172 N3172 N3173 273.49
R3173 N3173 N3174 849.64
R3174 N3174 N3175 853.28
R3175 N3175 N3176 324.54
R3176 N3176 N3177 510.80
R3177 N3177 N3178 926.23
R3178 N3178 N3179 734.17
R3179 N3179 N3180 346.58
R3180 N3180 N3181 841.16
R3181 N3181 N3182 554.61
R3182 N3182 N3183 671.87
R3183 N3183 N3184 211.49
R3184 N3184 N3185 127.51
R3185 N3185 N3186 435.22
R3186 N3186 N3187 634.64
R3187 N3187 N3188 259.83
R3188 N3188 N3189 883.43
R3189 N3189 N3190 628.19
R3190 N3190 N3191 414.78
R3191 N3191 N3192 247.16
R3192 N3192 N3193 905.04
R3193 N3193 N3194 774.07
R3194 N3194 N3195 719.97
R3195 N3195 N3196 356.56
R3196 N3196 N3197 447.91
R3197 N3197 N3198 246.62
R3198 N3198 N3199 615.03
R3199 N3199 N3200 968.43
R3200 N3200 N3201 871.40
R3201 N3201 N3202 682.64
R3202 N3202 N3203 709.93
R3203 N3203 N3204 342.18
R3204 N3204 N3205 468.56
R3205 N3205 N3206 118.05
R3206 N3206 N3207 802.27
R3207 N3207 N3208 790.82
R3208 N3208 N3209 108.01
R3209 N3209 N3210 920.36
R3210 N3210 N3211 682.63
R3211 N3211 N3212 641.03
R3212 N3212 N3213 107.62
R3213 N3213 N3214 327.15
R3214 N3214 N3215 824.58
R3215 N3215 N3216 374.91
R3216 N3216 N3217 970.32
R3217 N3217 N3218 678.47
R3218 N3218 N3219 481.43
R3219 N3219 N3220 438.83
R3220 N3220 N3221 413.84
R3221 N3221 N3222 326.80
R3222 N3222 N3223 520.03
R3223 N3223 N3224 709.48
R3224 N3224 N3225 841.88
R3225 N3225 N3226 457.44
R3226 N3226 N3227 192.08
R3227 N3227 N3228 560.36
R3228 N3228 N3229 696.12
R3229 N3229 N3230 858.96
R3230 N3230 N3231 436.81
R3231 N3231 N3232 682.61
R3232 N3232 N3233 648.15
R3233 N3233 N3234 368.63
R3234 N3234 N3235 197.29
R3235 N3235 N3236 157.45
R3236 N3236 N3237 989.52
R3237 N3237 N3238 676.54
R3238 N3238 N3239 875.34
R3239 N3239 N3240 335.03
R3240 N3240 N3241 739.98
R3241 N3241 N3242 903.14
R3242 N3242 N3243 368.91
R3243 N3243 N3244 234.94
R3244 N3244 N3245 788.93
R3245 N3245 N3246 909.72
R3246 N3246 N3247 824.89
R3247 N3247 N3248 822.13
R3248 N3248 N3249 640.03
R3249 N3249 N3250 694.48
R3250 N3250 N3251 712.68
R3251 N3251 N3252 749.15
R3252 N3252 N3253 689.86
R3253 N3253 N3254 997.72
R3254 N3254 N3255 333.48
R3255 N3255 N3256 476.71
R3256 N3256 N3257 449.45
R3257 N3257 N3258 131.79
R3258 N3258 N3259 737.26
R3259 N3259 N3260 614.84
R3260 N3260 N3261 270.92
R3261 N3261 N3262 753.89
R3262 N3262 N3263 300.13
R3263 N3263 N3264 581.17
R3264 N3264 N3265 806.41
R3265 N3265 N3266 915.87
R3266 N3266 N3267 704.68
R3267 N3267 N3268 556.58
R3268 N3268 N3269 860.88
R3269 N3269 N3270 856.57
R3270 N3270 N3271 888.85
R3271 N3271 N3272 263.02
R3272 N3272 N3273 187.84
R3273 N3273 N3274 215.15
R3274 N3274 N3275 332.79
R3275 N3275 N3276 827.51
R3276 N3276 N3277 786.63
R3277 N3277 N3278 264.76
R3278 N3278 N3279 711.74
R3279 N3279 N3280 402.07
R3280 N3280 N3281 180.37
R3281 N3281 N3282 419.76
R3282 N3282 N3283 769.79
R3283 N3283 N3284 376.38
R3284 N3284 N3285 809.28
R3285 N3285 N3286 398.19
R3286 N3286 N3287 334.50
R3287 N3287 N3288 364.65
R3288 N3288 N3289 866.09
R3289 N3289 N3290 523.48
R3290 N3290 N3291 879.75
R3291 N3291 N3292 625.22
R3292 N3292 N3293 949.87
R3293 N3293 N3294 164.09
R3294 N3294 N3295 900.48
R3295 N3295 N3296 550.43
R3296 N3296 N3297 880.75
R3297 N3297 N3298 443.50
R3298 N3298 N3299 368.52
R3299 N3299 N3300 148.66
R3300 N3300 N3301 868.82
R3301 N3301 N3302 223.63
R3302 N3302 N3303 280.27
R3303 N3303 N3304 468.27
R3304 N3304 N3305 612.46
R3305 N3305 N3306 915.96
R3306 N3306 N3307 511.81
R3307 N3307 N3308 384.75
R3308 N3308 N3309 744.10
R3309 N3309 N3310 801.05
R3310 N3310 N3311 538.82
R3311 N3311 N3312 667.93
R3312 N3312 N3313 259.14
R3313 N3313 N3314 671.05
R3314 N3314 N3315 104.24
R3315 N3315 N3316 346.18
R3316 N3316 N3317 785.07
R3317 N3317 N3318 251.75
R3318 N3318 N3319 788.04
R3319 N3319 N3320 540.62
R3320 N3320 N3321 787.21
R3321 N3321 N3322 179.24
R3322 N3322 N3323 653.03
R3323 N3323 N3324 670.14
R3324 N3324 N3325 463.05
R3325 N3325 N3326 968.80
R3326 N3326 N3327 444.98
R3327 N3327 N3328 133.95
R3328 N3328 N3329 279.47
R3329 N3329 N3330 435.79
R3330 N3330 N3331 112.67
R3331 N3331 N3332 389.99
R3332 N3332 N3333 849.91
R3333 N3333 N3334 271.52
R3334 N3334 N3335 709.07
R3335 N3335 N3336 664.02
R3336 N3336 N3337 323.94
R3337 N3337 N3338 724.17
R3338 N3338 N3339 409.91
R3339 N3339 N3340 216.04
R3340 N3340 N3341 445.20
R3341 N3341 N3342 629.80
R3342 N3342 N3343 250.32
R3343 N3343 N3344 841.46
R3344 N3344 N3345 368.38
R3345 N3345 N3346 361.75
R3346 N3346 N3347 755.05
R3347 N3347 N3348 636.73
R3348 N3348 N3349 404.05
R3349 N3349 N3350 899.18
R3350 N3350 N3351 995.93
R3351 N3351 N3352 408.46
R3352 N3352 N3353 911.25
R3353 N3353 N3354 423.33
R3354 N3354 N3355 269.58
R3355 N3355 N3356 953.28
R3356 N3356 N3357 926.38
R3357 N3357 N3358 463.05
R3358 N3358 N3359 305.58
R3359 N3359 N3360 754.45
R3360 N3360 N3361 218.09
R3361 N3361 N3362 760.67
R3362 N3362 N3363 630.72
R3363 N3363 N3364 252.09
R3364 N3364 N3365 429.93
R3365 N3365 N3366 685.49
R3366 N3366 N3367 133.63
R3367 N3367 N3368 888.89
R3368 N3368 N3369 330.21
R3369 N3369 N3370 581.26
R3370 N3370 N3371 143.73
R3371 N3371 N3372 995.21
R3372 N3372 N3373 695.77
R3373 N3373 N3374 688.21
R3374 N3374 N3375 117.77
R3375 N3375 N3376 720.77
R3376 N3376 N3377 475.10
R3377 N3377 N3378 442.23
R3378 N3378 N3379 592.55
R3379 N3379 N3380 526.96
R3380 N3380 N3381 237.81
R3381 N3381 N3382 725.67
R3382 N3382 N3383 667.28
R3383 N3383 N3384 371.00
R3384 N3384 N3385 695.50
R3385 N3385 N3386 696.23
R3386 N3386 N3387 342.98
R3387 N3387 N3388 645.07
R3388 N3388 N3389 223.45
R3389 N3389 N3390 847.59
R3390 N3390 N3391 194.42
R3391 N3391 N3392 746.89
R3392 N3392 N3393 205.96
R3393 N3393 N3394 202.61
R3394 N3394 N3395 195.64
R3395 N3395 N3396 278.78
R3396 N3396 N3397 279.77
R3397 N3397 N3398 336.69
R3398 N3398 N3399 570.83
R3399 N3399 N3400 281.51
R3400 N3400 N3401 733.09
R3401 N3401 N3402 365.82
R3402 N3402 N3403 135.47
R3403 N3403 N3404 546.72
R3404 N3404 N3405 286.92
R3405 N3405 N3406 939.81
R3406 N3406 N3407 397.54
R3407 N3407 N3408 102.46
R3408 N3408 N3409 704.47
R3409 N3409 N3410 916.19
R3410 N3410 N3411 851.71
R3411 N3411 N3412 702.12
R3412 N3412 N3413 234.23
R3413 N3413 N3414 181.07
R3414 N3414 N3415 560.53
R3415 N3415 N3416 751.21
R3416 N3416 N3417 191.16
R3417 N3417 N3418 330.30
R3418 N3418 N3419 308.04
R3419 N3419 N3420 989.80
R3420 N3420 N3421 366.42
R3421 N3421 N3422 517.85
R3422 N3422 N3423 189.83
R3423 N3423 N3424 257.23
R3424 N3424 N3425 135.50
R3425 N3425 N3426 361.51
R3426 N3426 N3427 821.44
R3427 N3427 N3428 381.44
R3428 N3428 N3429 764.69
R3429 N3429 N3430 185.50
R3430 N3430 N3431 782.38
R3431 N3431 N3432 141.30
R3432 N3432 N3433 866.80
R3433 N3433 N3434 697.02
R3434 N3434 N3435 253.46
R3435 N3435 N3436 421.77
R3436 N3436 N3437 493.94
R3437 N3437 N3438 659.63
R3438 N3438 N3439 890.63
R3439 N3439 N3440 183.66
R3440 N3440 N3441 833.47
R3441 N3441 N3442 264.58
R3442 N3442 N3443 460.70
R3443 N3443 N3444 966.08
R3444 N3444 N3445 344.65
R3445 N3445 N3446 447.14
R3446 N3446 N3447 865.60
R3447 N3447 N3448 819.91
R3448 N3448 N3449 683.96
R3449 N3449 N3450 817.22
R3450 N3450 N3451 201.75
R3451 N3451 N3452 726.55
R3452 N3452 N3453 152.78
R3453 N3453 N3454 948.22
R3454 N3454 N3455 243.46
R3455 N3455 N3456 474.42
R3456 N3456 N3457 631.68
R3457 N3457 N3458 822.04
R3458 N3458 N3459 710.55
R3459 N3459 N3460 263.13
R3460 N3460 N3461 441.78
R3461 N3461 N3462 422.74
R3462 N3462 N3463 125.93
R3463 N3463 N3464 716.02
R3464 N3464 N3465 854.68
R3465 N3465 N3466 976.10
R3466 N3466 N3467 217.59
R3467 N3467 N3468 928.36
R3468 N3468 N3469 201.64
R3469 N3469 N3470 470.16
R3470 N3470 N3471 141.38
R3471 N3471 N3472 335.45
R3472 N3472 N3473 382.81
R3473 N3473 N3474 734.11
R3474 N3474 N3475 710.14
R3475 N3475 N3476 790.78
R3476 N3476 N3477 618.98
R3477 N3477 N3478 608.51
R3478 N3478 N3479 980.11
R3479 N3479 N3480 702.86
R3480 N3480 N3481 404.47
R3481 N3481 N3482 570.79
R3482 N3482 N3483 730.52
R3483 N3483 N3484 185.72
R3484 N3484 N3485 695.54
R3485 N3485 N3486 323.72
R3486 N3486 N3487 411.17
R3487 N3487 N3488 708.67
R3488 N3488 N3489 446.39
R3489 N3489 N3490 855.13
R3490 N3490 N3491 602.51
R3491 N3491 N3492 989.01
R3492 N3492 N3493 149.11
R3493 N3493 N3494 679.06
R3494 N3494 N3495 241.23
R3495 N3495 N3496 863.96
R3496 N3496 N3497 866.68
R3497 N3497 N3498 882.47
R3498 N3498 N3499 167.38
R3499 N3499 N3500 542.48
R3500 N3500 N3501 316.80
R3501 N3501 N3502 973.13
R3502 N3502 N3503 145.32
R3503 N3503 N3504 300.44
R3504 N3504 N3505 678.99
R3505 N3505 N3506 462.95
R3506 N3506 N3507 311.50
R3507 N3507 N3508 513.19
R3508 N3508 N3509 821.14
R3509 N3509 N3510 503.29
R3510 N3510 N3511 870.93
R3511 N3511 N3512 502.36
R3512 N3512 N3513 206.84
R3513 N3513 N3514 547.64
R3514 N3514 N3515 688.04
R3515 N3515 N3516 192.38
R3516 N3516 N3517 471.10
R3517 N3517 N3518 601.42
R3518 N3518 N3519 100.15
R3519 N3519 N3520 181.81
R3520 N3520 N3521 643.78
R3521 N3521 N3522 657.16
R3522 N3522 N3523 374.14
R3523 N3523 N3524 557.50
R3524 N3524 N3525 286.17
R3525 N3525 N3526 704.33
R3526 N3526 N3527 955.32
R3527 N3527 N3528 427.01
R3528 N3528 N3529 148.85
R3529 N3529 N3530 300.63
R3530 N3530 N3531 509.01
R3531 N3531 N3532 604.14
R3532 N3532 N3533 657.78
R3533 N3533 N3534 525.82
R3534 N3534 N3535 691.45
R3535 N3535 N3536 744.32
R3536 N3536 N3537 202.62
R3537 N3537 N3538 783.39
R3538 N3538 N3539 299.57
R3539 N3539 N3540 407.22
R3540 N3540 N3541 846.90
R3541 N3541 N3542 967.99
R3542 N3542 N3543 362.79
R3543 N3543 N3544 569.79
R3544 N3544 N3545 731.89
R3545 N3545 N3546 141.20
R3546 N3546 N3547 247.74
R3547 N3547 N3548 226.40
R3548 N3548 N3549 745.17
R3549 N3549 N3550 749.40
R3550 N3550 N3551 196.27
R3551 N3551 N3552 649.77
R3552 N3552 N3553 268.79
R3553 N3553 N3554 937.19
R3554 N3554 N3555 453.61
R3555 N3555 N3556 511.34
R3556 N3556 N3557 803.28
R3557 N3557 N3558 745.11
R3558 N3558 N3559 196.99
R3559 N3559 N3560 473.02
R3560 N3560 N3561 933.96
R3561 N3561 N3562 853.72
R3562 N3562 N3563 629.93
R3563 N3563 N3564 794.93
R3564 N3564 N3565 505.45
R3565 N3565 N3566 692.61
R3566 N3566 N3567 960.57
R3567 N3567 N3568 221.17
R3568 N3568 N3569 548.95
R3569 N3569 N3570 577.33
R3570 N3570 N3571 143.71
R3571 N3571 N3572 941.78
R3572 N3572 N3573 854.93
R3573 N3573 N3574 534.64
R3574 N3574 N3575 557.50
R3575 N3575 N3576 929.05
R3576 N3576 N3577 259.48
R3577 N3577 N3578 620.70
R3578 N3578 N3579 757.45
R3579 N3579 N3580 215.54
R3580 N3580 N3581 448.67
R3581 N3581 N3582 640.49
R3582 N3582 N3583 894.43
R3583 N3583 N3584 553.70
R3584 N3584 N3585 446.20
R3585 N3585 N3586 981.55
R3586 N3586 N3587 924.32
R3587 N3587 N3588 786.14
R3588 N3588 N3589 346.24
R3589 N3589 N3590 967.23
R3590 N3590 N3591 973.44
R3591 N3591 N3592 507.56
R3592 N3592 N3593 220.03
R3593 N3593 N3594 471.47
R3594 N3594 N3595 730.01
R3595 N3595 N3596 773.58
R3596 N3596 N3597 369.02
R3597 N3597 N3598 731.34
R3598 N3598 N3599 874.64
R3599 N3599 N3600 740.69
R3600 N3600 N3601 941.96
R3601 N3601 N3602 669.32
R3602 N3602 N3603 280.80
R3603 N3603 N3604 661.75
R3604 N3604 N3605 361.52
R3605 N3605 N3606 410.76
R3606 N3606 N3607 705.14
R3607 N3607 N3608 983.20
R3608 N3608 N3609 685.08
R3609 N3609 N3610 962.49
R3610 N3610 N3611 553.50
R3611 N3611 N3612 724.88
R3612 N3612 N3613 390.14
R3613 N3613 N3614 203.86
R3614 N3614 N3615 417.01
R3615 N3615 N3616 532.33
R3616 N3616 N3617 613.57
R3617 N3617 N3618 700.44
R3618 N3618 N3619 475.73
R3619 N3619 N3620 773.08
R3620 N3620 N3621 857.25
R3621 N3621 N3622 357.34
R3622 N3622 N3623 862.57
R3623 N3623 N3624 827.47
R3624 N3624 N3625 570.46
R3625 N3625 N3626 122.74
R3626 N3626 N3627 230.79
R3627 N3627 N3628 703.23
R3628 N3628 N3629 279.91
R3629 N3629 N3630 775.17
R3630 N3630 N3631 244.84
R3631 N3631 N3632 357.95
R3632 N3632 N3633 325.50
R3633 N3633 N3634 855.44
R3634 N3634 N3635 721.54
R3635 N3635 N3636 365.63
R3636 N3636 N3637 778.23
R3637 N3637 N3638 129.08
R3638 N3638 N3639 832.62
R3639 N3639 N3640 192.23
R3640 N3640 N3641 881.23
R3641 N3641 N3642 765.54
R3642 N3642 N3643 878.36
R3643 N3643 N3644 768.17
R3644 N3644 N3645 605.14
R3645 N3645 N3646 313.84
R3646 N3646 N3647 805.88
R3647 N3647 N3648 818.94
R3648 N3648 N3649 358.87
R3649 N3649 N3650 698.04
R3650 N3650 N3651 933.84
R3651 N3651 N3652 448.80
R3652 N3652 N3653 961.03
R3653 N3653 N3654 978.24
R3654 N3654 N3655 381.39
R3655 N3655 N3656 596.91
R3656 N3656 N3657 111.67
R3657 N3657 N3658 326.21
R3658 N3658 N3659 658.51
R3659 N3659 N3660 802.83
R3660 N3660 N3661 883.11
R3661 N3661 N3662 846.99
R3662 N3662 N3663 920.34
R3663 N3663 N3664 734.17
R3664 N3664 N3665 682.87
R3665 N3665 N3666 779.60
R3666 N3666 N3667 591.95
R3667 N3667 N3668 643.05
R3668 N3668 N3669 798.53
R3669 N3669 N3670 967.86
R3670 N3670 N3671 364.76
R3671 N3671 N3672 259.68
R3672 N3672 N3673 714.39
R3673 N3673 N3674 268.28
R3674 N3674 N3675 256.42
R3675 N3675 N3676 562.46
R3676 N3676 N3677 439.48
R3677 N3677 N3678 485.66
R3678 N3678 N3679 600.94
R3679 N3679 N3680 217.06
R3680 N3680 N3681 625.59
R3681 N3681 N3682 329.51
R3682 N3682 N3683 397.51
R3683 N3683 N3684 738.72
R3684 N3684 N3685 239.33
R3685 N3685 N3686 238.33
R3686 N3686 N3687 390.37
R3687 N3687 N3688 145.77
R3688 N3688 N3689 939.14
R3689 N3689 N3690 654.05
R3690 N3690 N3691 695.70
R3691 N3691 N3692 541.50
R3692 N3692 N3693 615.41
R3693 N3693 N3694 422.28
R3694 N3694 N3695 805.63
R3695 N3695 N3696 386.07
R3696 N3696 N3697 297.97
R3697 N3697 N3698 265.48
R3698 N3698 N3699 161.36
R3699 N3699 N3700 554.63
R3700 N3700 N3701 474.34
R3701 N3701 N3702 583.33
R3702 N3702 N3703 182.75
R3703 N3703 N3704 299.08
R3704 N3704 N3705 292.02
R3705 N3705 N3706 398.70
R3706 N3706 N3707 424.72
R3707 N3707 N3708 296.60
R3708 N3708 N3709 777.39
R3709 N3709 N3710 577.45
R3710 N3710 N3711 996.97
R3711 N3711 N3712 841.32
R3712 N3712 N3713 983.02
R3713 N3713 N3714 107.92
R3714 N3714 N3715 702.04
R3715 N3715 N3716 501.10
R3716 N3716 N3717 914.05
R3717 N3717 N3718 652.33
R3718 N3718 N3719 659.02
R3719 N3719 N3720 963.01
R3720 N3720 N3721 714.30
R3721 N3721 N3722 388.84
R3722 N3722 N3723 924.34
R3723 N3723 N3724 950.49
R3724 N3724 N3725 447.29
R3725 N3725 N3726 586.21
R3726 N3726 N3727 354.55
R3727 N3727 N3728 920.20
R3728 N3728 N3729 839.90
R3729 N3729 N3730 437.46
R3730 N3730 N3731 822.54
R3731 N3731 N3732 501.00
R3732 N3732 N3733 139.47
R3733 N3733 N3734 908.45
R3734 N3734 N3735 273.26
R3735 N3735 N3736 562.51
R3736 N3736 N3737 953.39
R3737 N3737 N3738 250.66
R3738 N3738 N3739 960.65
R3739 N3739 N3740 584.18
R3740 N3740 N3741 106.60
R3741 N3741 N3742 158.92
R3742 N3742 N3743 703.30
R3743 N3743 N3744 796.22
R3744 N3744 N3745 878.46
R3745 N3745 N3746 481.79
R3746 N3746 N3747 193.53
R3747 N3747 N3748 583.98
R3748 N3748 N3749 732.47
R3749 N3749 N3750 978.60
R3750 N3750 N3751 797.69
R3751 N3751 N3752 681.91
R3752 N3752 N3753 945.78
R3753 N3753 N3754 772.20
R3754 N3754 N3755 238.38
R3755 N3755 N3756 513.30
R3756 N3756 N3757 398.54
R3757 N3757 N3758 178.77
R3758 N3758 N3759 148.84
R3759 N3759 N3760 814.79
R3760 N3760 N3761 602.28
R3761 N3761 N3762 617.47
R3762 N3762 N3763 304.88
R3763 N3763 N3764 332.78
R3764 N3764 N3765 449.23
R3765 N3765 N3766 667.20
R3766 N3766 N3767 489.72
R3767 N3767 N3768 115.20
R3768 N3768 N3769 705.97
R3769 N3769 N3770 581.35
R3770 N3770 N3771 677.28
R3771 N3771 N3772 656.51
R3772 N3772 N3773 780.36
R3773 N3773 N3774 627.05
R3774 N3774 N3775 730.79
R3775 N3775 N3776 165.33
R3776 N3776 N3777 935.24
R3777 N3777 N3778 195.52
R3778 N3778 N3779 808.20
R3779 N3779 N3780 371.22
R3780 N3780 N3781 177.85
R3781 N3781 N3782 788.75
R3782 N3782 N3783 493.91
R3783 N3783 N3784 455.60
R3784 N3784 N3785 694.65
R3785 N3785 N3786 526.59
R3786 N3786 N3787 580.12
R3787 N3787 N3788 222.74
R3788 N3788 N3789 451.89
R3789 N3789 N3790 817.74
R3790 N3790 N3791 591.15
R3791 N3791 N3792 964.12
R3792 N3792 N3793 229.67
R3793 N3793 N3794 709.56
R3794 N3794 N3795 922.75
R3795 N3795 N3796 815.52
R3796 N3796 N3797 756.39
R3797 N3797 N3798 435.82
R3798 N3798 N3799 954.52
R3799 N3799 N3800 598.17
R3800 N3800 N3801 599.56
R3801 N3801 N3802 210.91
R3802 N3802 N3803 104.53
R3803 N3803 N3804 636.99
R3804 N3804 N3805 583.44
R3805 N3805 N3806 952.28
R3806 N3806 N3807 374.22
R3807 N3807 N3808 773.47
R3808 N3808 N3809 913.19
R3809 N3809 N3810 409.47
R3810 N3810 N3811 471.39
R3811 N3811 N3812 681.34
R3812 N3812 N3813 561.30
R3813 N3813 N3814 244.86
R3814 N3814 N3815 298.71
R3815 N3815 N3816 851.27
R3816 N3816 N3817 274.89
R3817 N3817 N3818 263.22
R3818 N3818 N3819 819.69
R3819 N3819 N3820 867.03
R3820 N3820 N3821 866.25
R3821 N3821 N3822 939.13
R3822 N3822 N3823 994.88
R3823 N3823 N3824 515.14
R3824 N3824 N3825 594.70
R3825 N3825 N3826 361.59
R3826 N3826 N3827 160.63
R3827 N3827 N3828 188.38
R3828 N3828 N3829 753.03
R3829 N3829 N3830 538.47
R3830 N3830 N3831 397.77
R3831 N3831 N3832 215.39
R3832 N3832 N3833 689.93
R3833 N3833 N3834 190.04
R3834 N3834 N3835 657.56
R3835 N3835 N3836 910.11
R3836 N3836 N3837 386.01
R3837 N3837 N3838 505.58
R3838 N3838 N3839 654.71
R3839 N3839 N3840 375.11
R3840 N3840 N3841 625.75
R3841 N3841 N3842 609.00
R3842 N3842 N3843 428.04
R3843 N3843 N3844 384.70
R3844 N3844 N3845 485.48
R3845 N3845 N3846 104.35
R3846 N3846 N3847 321.56
R3847 N3847 N3848 299.37
R3848 N3848 N3849 765.83
R3849 N3849 N3850 492.51
R3850 N3850 N3851 856.10
R3851 N3851 N3852 220.88
R3852 N3852 N3853 759.68
R3853 N3853 N3854 890.10
R3854 N3854 N3855 516.56
R3855 N3855 N3856 422.87
R3856 N3856 N3857 374.92
R3857 N3857 N3858 596.50
R3858 N3858 N3859 258.19
R3859 N3859 N3860 645.96
R3860 N3860 N3861 857.61
R3861 N3861 N3862 872.84
R3862 N3862 N3863 226.00
R3863 N3863 N3864 584.76
R3864 N3864 N3865 336.91
R3865 N3865 N3866 897.70
R3866 N3866 N3867 168.82
R3867 N3867 N3868 167.86
R3868 N3868 N3869 116.77
R3869 N3869 N3870 556.46
R3870 N3870 N3871 128.07
R3871 N3871 N3872 623.70
R3872 N3872 N3873 464.62
R3873 N3873 N3874 631.03
R3874 N3874 N3875 915.67
R3875 N3875 N3876 596.43
R3876 N3876 N3877 589.12
R3877 N3877 N3878 998.86
R3878 N3878 N3879 524.89
R3879 N3879 N3880 797.68
R3880 N3880 N3881 429.24
R3881 N3881 N3882 300.98
R3882 N3882 N3883 794.93
R3883 N3883 N3884 759.90
R3884 N3884 N3885 361.90
R3885 N3885 N3886 518.23
R3886 N3886 N3887 559.37
R3887 N3887 N3888 457.11
R3888 N3888 N3889 551.95
R3889 N3889 N3890 696.41
R3890 N3890 N3891 863.18
R3891 N3891 N3892 825.89
R3892 N3892 N3893 652.63
R3893 N3893 N3894 249.26
R3894 N3894 N3895 562.72
R3895 N3895 N3896 501.60
R3896 N3896 N3897 261.23
R3897 N3897 N3898 953.84
R3898 N3898 N3899 693.47
R3899 N3899 N3900 970.96
R3900 N3900 N3901 762.33
R3901 N3901 N3902 535.15
R3902 N3902 N3903 422.92
R3903 N3903 N3904 296.94
R3904 N3904 N3905 538.88
R3905 N3905 N3906 156.58
R3906 N3906 N3907 432.49
R3907 N3907 N3908 138.53
R3908 N3908 N3909 286.10
R3909 N3909 N3910 916.95
R3910 N3910 N3911 425.13
R3911 N3911 N3912 522.71
R3912 N3912 N3913 509.18
R3913 N3913 N3914 141.79
R3914 N3914 N3915 982.53
R3915 N3915 N3916 391.66
R3916 N3916 N3917 733.36
R3917 N3917 N3918 569.24
R3918 N3918 N3919 846.68
R3919 N3919 N3920 851.39
R3920 N3920 N3921 336.98
R3921 N3921 N3922 589.92
R3922 N3922 N3923 256.46
R3923 N3923 N3924 688.31
R3924 N3924 N3925 428.77
R3925 N3925 N3926 688.00
R3926 N3926 N3927 851.92
R3927 N3927 N3928 565.00
R3928 N3928 N3929 438.70
R3929 N3929 N3930 916.52
R3930 N3930 N3931 564.73
R3931 N3931 N3932 417.61
R3932 N3932 N3933 880.95
R3933 N3933 N3934 538.18
R3934 N3934 N3935 533.90
R3935 N3935 N3936 643.79
R3936 N3936 N3937 551.65
R3937 N3937 N3938 225.07
R3938 N3938 N3939 249.05
R3939 N3939 N3940 169.38
R3940 N3940 N3941 679.13
R3941 N3941 N3942 290.37
R3942 N3942 N3943 268.22
R3943 N3943 N3944 426.00
R3944 N3944 N3945 745.57
R3945 N3945 N3946 206.50
R3946 N3946 N3947 307.31
R3947 N3947 N3948 830.06
R3948 N3948 N3949 748.23
R3949 N3949 N3950 533.36
R3950 N3950 N3951 530.93
R3951 N3951 N3952 289.63
R3952 N3952 N3953 245.12
R3953 N3953 N3954 850.03
R3954 N3954 N3955 120.20
R3955 N3955 N3956 138.83
R3956 N3956 N3957 616.14
R3957 N3957 N3958 245.02
R3958 N3958 N3959 666.59
R3959 N3959 N3960 135.27
R3960 N3960 N3961 615.04
R3961 N3961 N3962 150.32
R3962 N3962 N3963 332.43
R3963 N3963 N3964 262.03
R3964 N3964 N3965 962.41
R3965 N3965 N3966 639.42
R3966 N3966 N3967 607.24
R3967 N3967 N3968 116.76
R3968 N3968 N3969 747.59
R3969 N3969 N3970 695.57
R3970 N3970 N3971 355.11
R3971 N3971 N3972 177.17
R3972 N3972 N3973 504.28
R3973 N3973 N3974 993.50
R3974 N3974 N3975 880.57
R3975 N3975 N3976 253.51
R3976 N3976 N3977 847.33
R3977 N3977 N3978 640.75
R3978 N3978 N3979 815.15
R3979 N3979 N3980 838.41
R3980 N3980 N3981 263.70
R3981 N3981 N3982 693.68
R3982 N3982 N3983 338.07
R3983 N3983 N3984 751.77
R3984 N3984 N3985 408.40
R3985 N3985 N3986 508.12
R3986 N3986 N3987 631.54
R3987 N3987 N3988 306.83
R3988 N3988 N3989 446.92
R3989 N3989 N3990 197.71
R3990 N3990 N3991 282.11
R3991 N3991 N3992 873.63
R3992 N3992 N3993 553.92
R3993 N3993 N3994 477.82
R3994 N3994 N3995 234.61
R3995 N3995 N3996 186.67
R3996 N3996 N3997 528.28
R3997 N3997 N3998 653.27
R3998 N3998 N3999 135.13
R3999 N3999 N4000 805.48
R4000 N4000 N4001 553.00
R4001 N4001 N4002 205.76
R4002 N4002 N4003 534.02
R4003 N4003 N4004 217.30
R4004 N4004 N4005 643.13
R4005 N4005 N4006 844.77
R4006 N4006 N4007 907.27
R4007 N4007 N4008 797.38
R4008 N4008 N4009 684.31
R4009 N4009 N4010 569.84
R4010 N4010 N4011 433.34
R4011 N4011 N4012 139.09
R4012 N4012 N4013 576.83
R4013 N4013 N4014 306.54
R4014 N4014 N4015 822.07
R4015 N4015 N4016 810.60
R4016 N4016 N4017 443.11
R4017 N4017 N4018 630.14
R4018 N4018 N4019 767.25
R4019 N4019 N4020 785.39
R4020 N4020 N4021 727.04
R4021 N4021 N4022 187.95
R4022 N4022 N4023 220.49
R4023 N4023 N4024 529.43
R4024 N4024 N4025 309.26
R4025 N4025 N4026 873.15
R4026 N4026 N4027 354.94
R4027 N4027 N4028 889.09
R4028 N4028 N4029 467.78
R4029 N4029 N4030 270.12
R4030 N4030 N4031 738.23
R4031 N4031 N4032 810.48
R4032 N4032 N4033 620.19
R4033 N4033 N4034 206.05
R4034 N4034 N4035 106.47
R4035 N4035 N4036 689.09
R4036 N4036 N4037 718.99
R4037 N4037 N4038 384.31
R4038 N4038 N4039 426.04
R4039 N4039 N4040 239.30
R4040 N4040 N4041 686.42
R4041 N4041 N4042 328.27
R4042 N4042 N4043 869.48
R4043 N4043 N4044 481.21
R4044 N4044 N4045 429.08
R4045 N4045 N4046 348.00
R4046 N4046 N4047 712.55
R4047 N4047 N4048 779.47
R4048 N4048 N4049 471.91
R4049 N4049 N4050 805.41
R4050 N4050 N4051 534.22
R4051 N4051 N4052 433.19
R4052 N4052 N4053 599.42
R4053 N4053 N4054 328.40
R4054 N4054 N4055 375.99
R4055 N4055 N4056 409.92
R4056 N4056 N4057 734.95
R4057 N4057 N4058 762.20
R4058 N4058 N4059 869.50
R4059 N4059 N4060 693.35
R4060 N4060 N4061 773.03
R4061 N4061 N4062 501.94
R4062 N4062 N4063 729.38
R4063 N4063 N4064 245.62
R4064 N4064 N4065 293.01
R4065 N4065 N4066 460.50
R4066 N4066 N4067 404.59
R4067 N4067 N4068 595.52
R4068 N4068 N4069 727.35
R4069 N4069 N4070 736.11
R4070 N4070 N4071 244.66
R4071 N4071 N4072 968.11
R4072 N4072 N4073 104.76
R4073 N4073 N4074 181.98
R4074 N4074 N4075 230.80
R4075 N4075 N4076 933.28
R4076 N4076 N4077 491.84
R4077 N4077 N4078 157.67
R4078 N4078 N4079 299.59
R4079 N4079 N4080 172.04
R4080 N4080 N4081 133.98
R4081 N4081 N4082 445.89
R4082 N4082 N4083 986.00
R4083 N4083 N4084 652.57
R4084 N4084 N4085 568.90
R4085 N4085 N4086 740.45
R4086 N4086 N4087 637.73
R4087 N4087 N4088 951.14
R4088 N4088 N4089 838.21
R4089 N4089 N4090 676.26
R4090 N4090 N4091 495.07
R4091 N4091 N4092 281.54
R4092 N4092 N4093 691.20
R4093 N4093 N4094 823.52
R4094 N4094 N4095 357.41
R4095 N4095 N4096 130.25
R4096 N4096 N4097 639.56
R4097 N4097 N4098 564.23
R4098 N4098 N4099 308.50
R4099 N4099 N4100 252.53
R4100 N4100 N4101 132.46
R4101 N4101 N4102 315.33
R4102 N4102 N4103 100.26
R4103 N4103 N4104 241.70
R4104 N4104 N4105 997.14
R4105 N4105 N4106 801.71
R4106 N4106 N4107 417.81
R4107 N4107 N4108 455.63
R4108 N4108 N4109 627.47
R4109 N4109 N4110 565.97
R4110 N4110 N4111 763.23
R4111 N4111 N4112 161.76
R4112 N4112 N4113 181.15
R4113 N4113 N4114 356.04
R4114 N4114 N4115 846.79
R4115 N4115 N4116 923.51
R4116 N4116 N4117 413.29
R4117 N4117 N4118 966.96
R4118 N4118 N4119 348.86
R4119 N4119 N4120 645.73
R4120 N4120 N4121 275.07
R4121 N4121 N4122 936.74
R4122 N4122 N4123 617.42
R4123 N4123 N4124 335.00
R4124 N4124 N4125 466.42
R4125 N4125 N4126 195.82
R4126 N4126 N4127 165.15
R4127 N4127 N4128 364.83
R4128 N4128 N4129 952.31
R4129 N4129 N4130 822.65
R4130 N4130 N4131 961.04
R4131 N4131 N4132 888.50
R4132 N4132 N4133 831.83
R4133 N4133 N4134 617.40
R4134 N4134 N4135 724.77
R4135 N4135 N4136 969.45
R4136 N4136 N4137 606.85
R4137 N4137 N4138 792.97
R4138 N4138 N4139 781.73
R4139 N4139 N4140 965.11
R4140 N4140 N4141 512.96
R4141 N4141 N4142 514.65
R4142 N4142 N4143 628.14
R4143 N4143 N4144 124.62
R4144 N4144 N4145 204.64
R4145 N4145 N4146 160.80
R4146 N4146 N4147 670.30
R4147 N4147 N4148 994.78
R4148 N4148 N4149 709.22
R4149 N4149 N4150 306.94
R4150 N4150 N4151 384.16
R4151 N4151 N4152 959.90
R4152 N4152 N4153 564.85
R4153 N4153 N4154 108.75
R4154 N4154 N4155 848.96
R4155 N4155 N4156 323.43
R4156 N4156 N4157 183.71
R4157 N4157 N4158 706.33
R4158 N4158 N4159 838.97
R4159 N4159 N4160 168.43
R4160 N4160 N4161 938.26
R4161 N4161 N4162 528.90
R4162 N4162 N4163 418.18
R4163 N4163 N4164 904.88
R4164 N4164 N4165 342.17
R4165 N4165 N4166 952.41
R4166 N4166 N4167 714.80
R4167 N4167 N4168 918.93
R4168 N4168 N4169 549.10
R4169 N4169 N4170 279.70
R4170 N4170 N4171 761.89
R4171 N4171 N4172 885.47
R4172 N4172 N4173 286.10
R4173 N4173 N4174 282.49
R4174 N4174 N4175 324.73
R4175 N4175 N4176 656.74
R4176 N4176 N4177 240.40
R4177 N4177 N4178 196.02
R4178 N4178 N4179 928.17
R4179 N4179 N4180 708.23
R4180 N4180 N4181 697.08
R4181 N4181 N4182 652.44
R4182 N4182 N4183 787.82
R4183 N4183 N4184 587.33
R4184 N4184 N4185 138.04
R4185 N4185 N4186 534.06
R4186 N4186 N4187 658.60
R4187 N4187 N4188 543.11
R4188 N4188 N4189 986.83
R4189 N4189 N4190 907.30
R4190 N4190 N4191 881.89
R4191 N4191 N4192 541.72
R4192 N4192 N4193 985.96
R4193 N4193 N4194 924.41
R4194 N4194 N4195 352.24
R4195 N4195 N4196 299.88
R4196 N4196 N4197 619.00
R4197 N4197 N4198 148.73
R4198 N4198 N4199 819.34
R4199 N4199 N4200 530.49
R4200 N4200 N4201 586.69
R4201 N4201 N4202 552.23
R4202 N4202 N4203 454.35
R4203 N4203 N4204 717.70
R4204 N4204 N4205 257.32
R4205 N4205 N4206 978.86
R4206 N4206 N4207 728.42
R4207 N4207 N4208 514.06
R4208 N4208 N4209 720.29
R4209 N4209 N4210 110.64
R4210 N4210 N4211 289.68
R4211 N4211 N4212 622.91
R4212 N4212 N4213 392.89
R4213 N4213 N4214 651.50
R4214 N4214 N4215 333.73
R4215 N4215 N4216 593.71
R4216 N4216 N4217 313.43
R4217 N4217 N4218 524.21
R4218 N4218 N4219 651.78
R4219 N4219 N4220 429.33
R4220 N4220 N4221 548.89
R4221 N4221 N4222 289.48
R4222 N4222 N4223 730.64
R4223 N4223 N4224 435.08
R4224 N4224 N4225 868.89
R4225 N4225 N4226 351.67
R4226 N4226 N4227 261.90
R4227 N4227 N4228 218.03
R4228 N4228 N4229 618.30
R4229 N4229 N4230 305.71
R4230 N4230 N4231 189.88
R4231 N4231 N4232 342.95
R4232 N4232 N4233 312.22
R4233 N4233 N4234 489.00
R4234 N4234 N4235 442.80
R4235 N4235 N4236 231.26
R4236 N4236 N4237 963.23
R4237 N4237 N4238 234.59
R4238 N4238 N4239 825.10
R4239 N4239 N4240 258.95
R4240 N4240 N4241 549.64
R4241 N4241 N4242 996.01
R4242 N4242 N4243 864.45
R4243 N4243 N4244 565.31
R4244 N4244 N4245 748.50
R4245 N4245 N4246 806.80
R4246 N4246 N4247 370.03
R4247 N4247 N4248 605.92
R4248 N4248 N4249 611.05
R4249 N4249 N4250 458.56
R4250 N4250 N4251 721.49
R4251 N4251 N4252 154.03
R4252 N4252 N4253 832.44
R4253 N4253 N4254 528.89
R4254 N4254 N4255 666.88
R4255 N4255 N4256 504.87
R4256 N4256 N4257 401.19
R4257 N4257 N4258 424.87
R4258 N4258 N4259 604.32
R4259 N4259 N4260 938.66
R4260 N4260 N4261 331.94
R4261 N4261 N4262 117.85
R4262 N4262 N4263 209.11
R4263 N4263 N4264 880.63
R4264 N4264 N4265 966.80
R4265 N4265 N4266 279.06
R4266 N4266 N4267 618.31
R4267 N4267 N4268 684.22
R4268 N4268 N4269 257.08
R4269 N4269 N4270 802.28
R4270 N4270 N4271 419.60
R4271 N4271 N4272 705.87
R4272 N4272 N4273 538.74
R4273 N4273 N4274 762.87
R4274 N4274 N4275 900.67
R4275 N4275 N4276 442.96
R4276 N4276 N4277 357.87
R4277 N4277 N4278 668.54
R4278 N4278 N4279 230.36
R4279 N4279 N4280 250.82
R4280 N4280 N4281 826.95
R4281 N4281 N4282 403.65
R4282 N4282 N4283 668.15
R4283 N4283 N4284 614.47
R4284 N4284 N4285 864.01
R4285 N4285 N4286 164.21
R4286 N4286 N4287 245.80
R4287 N4287 N4288 305.40
R4288 N4288 N4289 385.19
R4289 N4289 N4290 362.22
R4290 N4290 N4291 340.73
R4291 N4291 N4292 680.18
R4292 N4292 N4293 344.12
R4293 N4293 N4294 500.41
R4294 N4294 N4295 876.53
R4295 N4295 N4296 426.85
R4296 N4296 N4297 628.23
R4297 N4297 N4298 968.97
R4298 N4298 N4299 472.59
R4299 N4299 N4300 265.50
R4300 N4300 N4301 120.79
R4301 N4301 N4302 755.00
R4302 N4302 N4303 695.82
R4303 N4303 N4304 946.39
R4304 N4304 N4305 730.63
R4305 N4305 N4306 172.06
R4306 N4306 N4307 250.22
R4307 N4307 N4308 192.71
R4308 N4308 N4309 157.41
R4309 N4309 N4310 890.82
R4310 N4310 N4311 593.59
R4311 N4311 N4312 123.73
R4312 N4312 N4313 457.31
R4313 N4313 N4314 788.50
R4314 N4314 N4315 174.93
R4315 N4315 N4316 336.21
R4316 N4316 N4317 239.75
R4317 N4317 N4318 689.35
R4318 N4318 N4319 896.92
R4319 N4319 N4320 378.43
R4320 N4320 N4321 322.66
R4321 N4321 N4322 355.76
R4322 N4322 N4323 663.83
R4323 N4323 N4324 218.15
R4324 N4324 N4325 854.67
R4325 N4325 N4326 125.71
R4326 N4326 N4327 697.19
R4327 N4327 N4328 874.33
R4328 N4328 N4329 392.68
R4329 N4329 N4330 528.54
R4330 N4330 N4331 977.48
R4331 N4331 N4332 586.53
R4332 N4332 N4333 345.17
R4333 N4333 N4334 500.36
R4334 N4334 N4335 972.59
R4335 N4335 N4336 727.86
R4336 N4336 N4337 259.33
R4337 N4337 N4338 637.83
R4338 N4338 N4339 667.94
R4339 N4339 N4340 672.27
R4340 N4340 N4341 607.59
R4341 N4341 N4342 571.11
R4342 N4342 N4343 675.58
R4343 N4343 N4344 378.70
R4344 N4344 N4345 412.45
R4345 N4345 N4346 585.70
R4346 N4346 N4347 824.24
R4347 N4347 N4348 497.67
R4348 N4348 N4349 429.20
R4349 N4349 N4350 333.83
R4350 N4350 N4351 373.22
R4351 N4351 N4352 100.08
R4352 N4352 N4353 833.84
R4353 N4353 N4354 863.15
R4354 N4354 N4355 409.50
R4355 N4355 N4356 522.28
R4356 N4356 N4357 107.49
R4357 N4357 N4358 929.88
R4358 N4358 N4359 952.26
R4359 N4359 N4360 529.36
R4360 N4360 N4361 108.22
R4361 N4361 N4362 487.39
R4362 N4362 N4363 363.63
R4363 N4363 N4364 308.09
R4364 N4364 N4365 106.50
R4365 N4365 N4366 436.28
R4366 N4366 N4367 470.56
R4367 N4367 N4368 604.50
R4368 N4368 N4369 455.28
R4369 N4369 N4370 246.94
R4370 N4370 N4371 763.41
R4371 N4371 N4372 450.75
R4372 N4372 N4373 440.52
R4373 N4373 N4374 336.68
R4374 N4374 N4375 480.02
R4375 N4375 N4376 315.61
R4376 N4376 N4377 788.08
R4377 N4377 N4378 918.96
R4378 N4378 N4379 826.82
R4379 N4379 N4380 716.18
R4380 N4380 N4381 356.21
R4381 N4381 N4382 768.63
R4382 N4382 N4383 827.93
R4383 N4383 N4384 471.61
R4384 N4384 N4385 868.13
R4385 N4385 N4386 264.17
R4386 N4386 N4387 360.64
R4387 N4387 N4388 673.20
R4388 N4388 N4389 655.96
R4389 N4389 N4390 344.92
R4390 N4390 N4391 660.48
R4391 N4391 N4392 269.01
R4392 N4392 N4393 117.46
R4393 N4393 N4394 144.67
R4394 N4394 N4395 581.47
R4395 N4395 N4396 267.34
R4396 N4396 N4397 192.05
R4397 N4397 N4398 342.28
R4398 N4398 N4399 743.68
R4399 N4399 N4400 754.40
R4400 N4400 N4401 309.53
R4401 N4401 N4402 235.62
R4402 N4402 N4403 544.22
R4403 N4403 N4404 407.72
R4404 N4404 N4405 380.42
R4405 N4405 N4406 819.52
R4406 N4406 N4407 998.17
R4407 N4407 N4408 517.32
R4408 N4408 N4409 812.28
R4409 N4409 N4410 397.22
R4410 N4410 N4411 859.19
R4411 N4411 N4412 956.48
R4412 N4412 N4413 150.43
R4413 N4413 N4414 798.09
R4414 N4414 N4415 164.25
R4415 N4415 N4416 523.13
R4416 N4416 N4417 272.97
R4417 N4417 N4418 857.39
R4418 N4418 N4419 835.53
R4419 N4419 N4420 845.43
R4420 N4420 N4421 209.77
R4421 N4421 N4422 791.33
R4422 N4422 N4423 324.07
R4423 N4423 N4424 794.10
R4424 N4424 N4425 498.66
R4425 N4425 N4426 763.86
R4426 N4426 N4427 130.16
R4427 N4427 N4428 514.75
R4428 N4428 N4429 793.90
R4429 N4429 N4430 569.03
R4430 N4430 N4431 983.90
R4431 N4431 N4432 525.54
R4432 N4432 N4433 713.30
R4433 N4433 N4434 380.90
R4434 N4434 N4435 390.76
R4435 N4435 N4436 666.25
R4436 N4436 N4437 137.97
R4437 N4437 N4438 943.68
R4438 N4438 N4439 568.83
R4439 N4439 N4440 327.98
R4440 N4440 N4441 674.67
R4441 N4441 N4442 278.85
R4442 N4442 N4443 898.77
R4443 N4443 N4444 877.29
R4444 N4444 N4445 296.01
R4445 N4445 N4446 201.64
R4446 N4446 N4447 669.62
R4447 N4447 N4448 392.06
R4448 N4448 N4449 250.62
R4449 N4449 N4450 348.49
R4450 N4450 N4451 207.68
R4451 N4451 N4452 810.23
R4452 N4452 N4453 108.04
R4453 N4453 N4454 137.79
R4454 N4454 N4455 805.13
R4455 N4455 N4456 527.74
R4456 N4456 N4457 636.59
R4457 N4457 N4458 434.26
R4458 N4458 N4459 180.53
R4459 N4459 N4460 241.93
R4460 N4460 N4461 182.26
R4461 N4461 N4462 656.78
R4462 N4462 N4463 937.76
R4463 N4463 N4464 997.28
R4464 N4464 N4465 662.62
R4465 N4465 N4466 153.80
R4466 N4466 N4467 680.12
R4467 N4467 N4468 731.20
R4468 N4468 N4469 812.32
R4469 N4469 N4470 213.24
R4470 N4470 N4471 309.41
R4471 N4471 N4472 983.51
R4472 N4472 N4473 809.71
R4473 N4473 N4474 781.03
R4474 N4474 N4475 824.97
R4475 N4475 N4476 494.85
R4476 N4476 N4477 273.67
R4477 N4477 N4478 720.32
R4478 N4478 N4479 422.35
R4479 N4479 N4480 221.26
R4480 N4480 N4481 908.80
R4481 N4481 N4482 536.77
R4482 N4482 N4483 493.75
R4483 N4483 N4484 365.24
R4484 N4484 N4485 727.33
R4485 N4485 N4486 270.80
R4486 N4486 N4487 267.96
R4487 N4487 N4488 412.90
R4488 N4488 N4489 759.16
R4489 N4489 N4490 347.79
R4490 N4490 N4491 848.21
R4491 N4491 N4492 923.03
R4492 N4492 N4493 599.07
R4493 N4493 N4494 161.99
R4494 N4494 N4495 239.52
R4495 N4495 N4496 366.11
R4496 N4496 N4497 337.01
R4497 N4497 N4498 430.40
R4498 N4498 N4499 100.65
R4499 N4499 N4500 674.22
R4500 N4500 N4501 441.14
R4501 N4501 N4502 266.98
R4502 N4502 N4503 116.85
R4503 N4503 N4504 871.15
R4504 N4504 N4505 798.41
R4505 N4505 N4506 314.91
R4506 N4506 N4507 748.90
R4507 N4507 N4508 692.46
R4508 N4508 N4509 585.06
R4509 N4509 N4510 448.74
R4510 N4510 N4511 571.66
R4511 N4511 N4512 547.79
R4512 N4512 N4513 596.32
R4513 N4513 N4514 651.74
R4514 N4514 N4515 390.34
R4515 N4515 N4516 676.81
R4516 N4516 N4517 199.42
R4517 N4517 N4518 570.88
R4518 N4518 N4519 160.01
R4519 N4519 N4520 851.67
R4520 N4520 N4521 216.80
R4521 N4521 N4522 886.14
R4522 N4522 N4523 281.87
R4523 N4523 N4524 536.83
R4524 N4524 N4525 188.88
R4525 N4525 N4526 613.91
R4526 N4526 N4527 852.67
R4527 N4527 N4528 692.13
R4528 N4528 N4529 573.24
R4529 N4529 N4530 731.18
R4530 N4530 N4531 330.34
R4531 N4531 N4532 429.72
R4532 N4532 N4533 645.36
R4533 N4533 N4534 163.79
R4534 N4534 N4535 937.19
R4535 N4535 N4536 287.86
R4536 N4536 N4537 542.26
R4537 N4537 N4538 900.79
R4538 N4538 N4539 171.96
R4539 N4539 N4540 820.92
R4540 N4540 N4541 154.63
R4541 N4541 N4542 602.22
R4542 N4542 N4543 944.42
R4543 N4543 N4544 474.36
R4544 N4544 N4545 432.16
R4545 N4545 N4546 737.59
R4546 N4546 N4547 841.28
R4547 N4547 N4548 339.23
R4548 N4548 N4549 136.59
R4549 N4549 N4550 163.35
R4550 N4550 N4551 373.51
R4551 N4551 N4552 950.14
R4552 N4552 N4553 964.53
R4553 N4553 N4554 187.41
R4554 N4554 N4555 752.65
R4555 N4555 N4556 578.49
R4556 N4556 N4557 270.51
R4557 N4557 N4558 573.57
R4558 N4558 N4559 323.89
R4559 N4559 N4560 662.79
R4560 N4560 N4561 261.01
R4561 N4561 N4562 774.27
R4562 N4562 N4563 473.67
R4563 N4563 N4564 194.96
R4564 N4564 N4565 674.76
R4565 N4565 N4566 422.17
R4566 N4566 N4567 512.85
R4567 N4567 N4568 698.72
R4568 N4568 N4569 894.54
R4569 N4569 N4570 250.13
R4570 N4570 N4571 262.36
R4571 N4571 N4572 461.40
R4572 N4572 N4573 403.76
R4573 N4573 N4574 242.36
R4574 N4574 N4575 998.59
R4575 N4575 N4576 498.71
R4576 N4576 N4577 417.09
R4577 N4577 N4578 383.64
R4578 N4578 N4579 992.32
R4579 N4579 N4580 392.19
R4580 N4580 N4581 434.55
R4581 N4581 N4582 787.77
R4582 N4582 N4583 487.53
R4583 N4583 N4584 753.28
R4584 N4584 N4585 647.57
R4585 N4585 N4586 606.83
R4586 N4586 N4587 292.54
R4587 N4587 N4588 789.14
R4588 N4588 N4589 933.53
R4589 N4589 N4590 328.68
R4590 N4590 N4591 965.49
R4591 N4591 N4592 502.75
R4592 N4592 N4593 457.38
R4593 N4593 N4594 753.68
R4594 N4594 N4595 984.66
R4595 N4595 N4596 636.19
R4596 N4596 N4597 565.85
R4597 N4597 N4598 994.07
R4598 N4598 N4599 371.66
R4599 N4599 N4600 370.30
R4600 N4600 N4601 299.70
R4601 N4601 N4602 870.15
R4602 N4602 N4603 119.53
R4603 N4603 N4604 839.75
R4604 N4604 N4605 720.75
R4605 N4605 N4606 348.36
R4606 N4606 N4607 598.30
R4607 N4607 N4608 600.69
R4608 N4608 N4609 933.33
R4609 N4609 N4610 239.24
R4610 N4610 N4611 133.96
R4611 N4611 N4612 420.09
R4612 N4612 N4613 224.57
R4613 N4613 N4614 430.37
R4614 N4614 N4615 623.94
R4615 N4615 N4616 309.69
R4616 N4616 N4617 829.97
R4617 N4617 N4618 182.71
R4618 N4618 N4619 459.82
R4619 N4619 N4620 926.09
R4620 N4620 N4621 760.84
R4621 N4621 N4622 751.22
R4622 N4622 N4623 813.61
R4623 N4623 N4624 255.61
R4624 N4624 N4625 843.13
R4625 N4625 N4626 720.64
R4626 N4626 N4627 618.61
R4627 N4627 N4628 916.89
R4628 N4628 N4629 635.71
R4629 N4629 N4630 370.35
R4630 N4630 N4631 757.71
R4631 N4631 N4632 618.66
R4632 N4632 N4633 170.63
R4633 N4633 N4634 150.33
R4634 N4634 N4635 793.81
R4635 N4635 N4636 413.14
R4636 N4636 N4637 835.43
R4637 N4637 N4638 474.87
R4638 N4638 N4639 881.05
R4639 N4639 N4640 882.81
R4640 N4640 N4641 304.05
R4641 N4641 N4642 687.50
R4642 N4642 N4643 642.07
R4643 N4643 N4644 110.29
R4644 N4644 N4645 799.68
R4645 N4645 N4646 444.24
R4646 N4646 N4647 374.31
R4647 N4647 N4648 137.06
R4648 N4648 N4649 585.94
R4649 N4649 N4650 234.62
R4650 N4650 N4651 552.16
R4651 N4651 N4652 298.72
R4652 N4652 N4653 145.47
R4653 N4653 N4654 758.42
R4654 N4654 N4655 453.59
R4655 N4655 N4656 501.05
R4656 N4656 N4657 635.62
R4657 N4657 N4658 554.26
R4658 N4658 N4659 299.88
R4659 N4659 N4660 360.80
R4660 N4660 N4661 454.89
R4661 N4661 N4662 218.97
R4662 N4662 N4663 174.29
R4663 N4663 N4664 614.30
R4664 N4664 N4665 144.38
R4665 N4665 N4666 459.27
R4666 N4666 N4667 176.57
R4667 N4667 N4668 551.64
R4668 N4668 N4669 796.44
R4669 N4669 N4670 217.34
R4670 N4670 N4671 221.38
R4671 N4671 N4672 603.37
R4672 N4672 N4673 539.07
R4673 N4673 N4674 687.02
R4674 N4674 N4675 276.49
R4675 N4675 N4676 654.40
R4676 N4676 N4677 762.10
R4677 N4677 N4678 321.62
R4678 N4678 N4679 164.48
R4679 N4679 N4680 799.09
R4680 N4680 N4681 391.07
R4681 N4681 N4682 931.72
R4682 N4682 N4683 180.64
R4683 N4683 N4684 704.57
R4684 N4684 N4685 481.19
R4685 N4685 N4686 413.48
R4686 N4686 N4687 388.66
R4687 N4687 N4688 634.49
R4688 N4688 N4689 121.79
R4689 N4689 N4690 374.34
R4690 N4690 N4691 988.89
R4691 N4691 N4692 654.60
R4692 N4692 N4693 991.14
R4693 N4693 N4694 497.99
R4694 N4694 N4695 231.24
R4695 N4695 N4696 140.39
R4696 N4696 N4697 836.35
R4697 N4697 N4698 279.72
R4698 N4698 N4699 436.44
R4699 N4699 N4700 781.96
R4700 N4700 N4701 867.49
R4701 N4701 N4702 201.13
R4702 N4702 N4703 149.08
R4703 N4703 N4704 954.05
R4704 N4704 N4705 934.06
R4705 N4705 N4706 881.88
R4706 N4706 N4707 838.12
R4707 N4707 N4708 112.36
R4708 N4708 N4709 724.42
R4709 N4709 N4710 200.15
R4710 N4710 N4711 505.06
R4711 N4711 N4712 120.47
R4712 N4712 N4713 288.11
R4713 N4713 N4714 584.20
R4714 N4714 N4715 283.42
R4715 N4715 N4716 570.94
R4716 N4716 N4717 332.79
R4717 N4717 N4718 534.72
R4718 N4718 N4719 756.93
R4719 N4719 N4720 227.21
R4720 N4720 N4721 728.88
R4721 N4721 N4722 116.55
R4722 N4722 N4723 624.70
R4723 N4723 N4724 697.18
R4724 N4724 N4725 139.13
R4725 N4725 N4726 253.29
R4726 N4726 N4727 355.61
R4727 N4727 N4728 810.27
R4728 N4728 N4729 656.17
R4729 N4729 N4730 147.78
R4730 N4730 N4731 689.28
R4731 N4731 N4732 107.50
R4732 N4732 N4733 449.78
R4733 N4733 N4734 344.18
R4734 N4734 N4735 866.87
R4735 N4735 N4736 694.09
R4736 N4736 N4737 877.85
R4737 N4737 N4738 117.17
R4738 N4738 N4739 880.67
R4739 N4739 N4740 684.47
R4740 N4740 N4741 308.05
R4741 N4741 N4742 442.63
R4742 N4742 N4743 978.95
R4743 N4743 N4744 189.64
R4744 N4744 N4745 383.91
R4745 N4745 N4746 880.10
R4746 N4746 N4747 578.40
R4747 N4747 N4748 267.78
R4748 N4748 N4749 550.59
R4749 N4749 N4750 512.19
R4750 N4750 N4751 933.71
R4751 N4751 N4752 119.34
R4752 N4752 N4753 322.65
R4753 N4753 N4754 576.47
R4754 N4754 N4755 400.21
R4755 N4755 N4756 454.06
R4756 N4756 N4757 241.30
R4757 N4757 N4758 412.10
R4758 N4758 N4759 416.72
R4759 N4759 N4760 662.71
R4760 N4760 N4761 312.58
R4761 N4761 N4762 980.42
R4762 N4762 N4763 551.13
R4763 N4763 N4764 830.70
R4764 N4764 N4765 663.21
R4765 N4765 N4766 890.81
R4766 N4766 N4767 901.36
R4767 N4767 N4768 833.37
R4768 N4768 N4769 126.52
R4769 N4769 N4770 599.45
R4770 N4770 N4771 352.17
R4771 N4771 N4772 236.54
R4772 N4772 N4773 907.46
R4773 N4773 N4774 691.24
R4774 N4774 N4775 179.02
R4775 N4775 N4776 443.99
R4776 N4776 N4777 964.55
R4777 N4777 N4778 651.20
R4778 N4778 N4779 662.97
R4779 N4779 N4780 304.69
R4780 N4780 N4781 316.32
R4781 N4781 N4782 237.47
R4782 N4782 N4783 973.48
R4783 N4783 N4784 918.76
R4784 N4784 N4785 396.36
R4785 N4785 N4786 588.01
R4786 N4786 N4787 286.08
R4787 N4787 N4788 224.72
R4788 N4788 N4789 587.22
R4789 N4789 N4790 820.09
R4790 N4790 N4791 876.33
R4791 N4791 N4792 378.10
R4792 N4792 N4793 734.62
R4793 N4793 N4794 571.42
R4794 N4794 N4795 221.73
R4795 N4795 N4796 996.12
R4796 N4796 N4797 978.20
R4797 N4797 N4798 230.64
R4798 N4798 N4799 939.73
R4799 N4799 N4800 925.40
R4800 N4800 N4801 385.75
R4801 N4801 N4802 601.61
R4802 N4802 N4803 953.74
R4803 N4803 N4804 206.55
R4804 N4804 N4805 385.84
R4805 N4805 N4806 891.67
R4806 N4806 N4807 754.37
R4807 N4807 N4808 788.89
R4808 N4808 N4809 892.12
R4809 N4809 N4810 472.64
R4810 N4810 N4811 470.13
R4811 N4811 N4812 498.70
R4812 N4812 N4813 940.39
R4813 N4813 N4814 904.72
R4814 N4814 N4815 939.93
R4815 N4815 N4816 346.42
R4816 N4816 N4817 801.20
R4817 N4817 N4818 196.09
R4818 N4818 N4819 266.27
R4819 N4819 N4820 786.20
R4820 N4820 N4821 650.78
R4821 N4821 N4822 340.18
R4822 N4822 N4823 610.34
R4823 N4823 N4824 307.82
R4824 N4824 N4825 308.96
R4825 N4825 N4826 718.64
R4826 N4826 N4827 423.34
R4827 N4827 N4828 719.33
R4828 N4828 N4829 528.94
R4829 N4829 N4830 552.09
R4830 N4830 N4831 644.24
R4831 N4831 N4832 740.82
R4832 N4832 N4833 436.56
R4833 N4833 N4834 866.92
R4834 N4834 N4835 542.30
R4835 N4835 N4836 223.76
R4836 N4836 N4837 273.93
R4837 N4837 N4838 129.01
R4838 N4838 N4839 788.08
R4839 N4839 N4840 113.51
R4840 N4840 N4841 342.87
R4841 N4841 N4842 471.74
R4842 N4842 N4843 768.13
R4843 N4843 N4844 989.42
R4844 N4844 N4845 782.00
R4845 N4845 N4846 159.52
R4846 N4846 N4847 934.39
R4847 N4847 N4848 987.06
R4848 N4848 N4849 880.42
R4849 N4849 N4850 540.95
R4850 N4850 N4851 392.41
R4851 N4851 N4852 511.79
R4852 N4852 N4853 322.11
R4853 N4853 N4854 464.38
R4854 N4854 N4855 137.64
R4855 N4855 N4856 761.80
R4856 N4856 N4857 442.34
R4857 N4857 N4858 381.61
R4858 N4858 N4859 650.35
R4859 N4859 N4860 768.22
R4860 N4860 N4861 634.43
R4861 N4861 N4862 572.71
R4862 N4862 N4863 888.20
R4863 N4863 N4864 808.23
R4864 N4864 N4865 568.58
R4865 N4865 N4866 506.45
R4866 N4866 N4867 844.31
R4867 N4867 N4868 138.17
R4868 N4868 N4869 996.25
R4869 N4869 N4870 566.83
R4870 N4870 N4871 456.05
R4871 N4871 N4872 761.65
R4872 N4872 N4873 601.93
R4873 N4873 N4874 564.51
R4874 N4874 N4875 667.58
R4875 N4875 N4876 144.37
R4876 N4876 N4877 362.06
R4877 N4877 N4878 458.24
R4878 N4878 N4879 374.10
R4879 N4879 N4880 844.86
R4880 N4880 N4881 515.21
R4881 N4881 N4882 480.22
R4882 N4882 N4883 651.82
R4883 N4883 N4884 149.09
R4884 N4884 N4885 565.27
R4885 N4885 N4886 228.02
R4886 N4886 N4887 846.90
R4887 N4887 N4888 506.53
R4888 N4888 N4889 750.38
R4889 N4889 N4890 201.85
R4890 N4890 N4891 800.86
R4891 N4891 N4892 944.06
R4892 N4892 N4893 726.50
R4893 N4893 N4894 221.78
R4894 N4894 N4895 472.20
R4895 N4895 N4896 505.80
R4896 N4896 N4897 260.99
R4897 N4897 N4898 631.28
R4898 N4898 N4899 741.37
R4899 N4899 N4900 281.74
R4900 N4900 N4901 509.21
R4901 N4901 N4902 325.07
R4902 N4902 N4903 722.55
R4903 N4903 N4904 916.45
R4904 N4904 N4905 816.84
R4905 N4905 N4906 746.54
R4906 N4906 N4907 211.19
R4907 N4907 N4908 202.75
R4908 N4908 N4909 504.46
R4909 N4909 N4910 426.65
R4910 N4910 N4911 571.44
R4911 N4911 N4912 445.68
R4912 N4912 N4913 811.96
R4913 N4913 N4914 560.50
R4914 N4914 N4915 954.78
R4915 N4915 N4916 440.81
R4916 N4916 N4917 442.55
R4917 N4917 N4918 791.43
R4918 N4918 N4919 921.03
R4919 N4919 N4920 608.94
R4920 N4920 N4921 693.58
R4921 N4921 N4922 235.08
R4922 N4922 N4923 881.94
R4923 N4923 N4924 260.98
R4924 N4924 N4925 740.84
R4925 N4925 N4926 477.62
R4926 N4926 N4927 378.57
R4927 N4927 N4928 791.77
R4928 N4928 N4929 501.63
R4929 N4929 N4930 663.81
R4930 N4930 N4931 205.80
R4931 N4931 N4932 218.41
R4932 N4932 N4933 282.57
R4933 N4933 N4934 660.30
R4934 N4934 N4935 327.80
R4935 N4935 N4936 512.78
R4936 N4936 N4937 869.87
R4937 N4937 N4938 589.15
R4938 N4938 N4939 105.18
R4939 N4939 N4940 894.43
R4940 N4940 N4941 314.09
R4941 N4941 N4942 629.98
R4942 N4942 N4943 528.14
R4943 N4943 N4944 469.14
R4944 N4944 N4945 171.46
R4945 N4945 N4946 640.09
R4946 N4946 N4947 320.24
R4947 N4947 N4948 592.61
R4948 N4948 N4949 657.79
R4949 N4949 N4950 601.79
R4950 N4950 N4951 842.73
R4951 N4951 N4952 144.03
R4952 N4952 N4953 233.43
R4953 N4953 N4954 687.95
R4954 N4954 N4955 133.05
R4955 N4955 N4956 868.45
R4956 N4956 N4957 700.30
R4957 N4957 N4958 854.21
R4958 N4958 N4959 368.60
R4959 N4959 N4960 928.35
R4960 N4960 N4961 144.13
R4961 N4961 N4962 475.26
R4962 N4962 N4963 260.42
R4963 N4963 N4964 704.88
R4964 N4964 N4965 649.98
R4965 N4965 N4966 722.36
R4966 N4966 N4967 635.47
R4967 N4967 N4968 808.58
R4968 N4968 N4969 259.68
R4969 N4969 N4970 509.80
R4970 N4970 N4971 621.07
R4971 N4971 N4972 938.33
R4972 N4972 N4973 183.81
R4973 N4973 N4974 369.37
R4974 N4974 N4975 431.71
R4975 N4975 N4976 441.05
R4976 N4976 N4977 160.90
R4977 N4977 N4978 484.59
R4978 N4978 N4979 595.42
R4979 N4979 N4980 363.55
R4980 N4980 N4981 221.09
R4981 N4981 N4982 725.16
R4982 N4982 N4983 346.98
R4983 N4983 N4984 574.35
R4984 N4984 N4985 572.18
R4985 N4985 N4986 726.25
R4986 N4986 N4987 650.85
R4987 N4987 N4988 198.37
R4988 N4988 N4989 756.76
R4989 N4989 N4990 666.08
R4990 N4990 N4991 988.47
R4991 N4991 N4992 535.30
R4992 N4992 N4993 719.79
R4993 N4993 N4994 940.50
R4994 N4994 N4995 987.65
R4995 N4995 N4996 358.47
R4996 N4996 N4997 647.96
R4997 N4997 N4998 384.84
R4998 N4998 N4999 572.85
R4999 N4999 N5000 995.52
RG1 N1 0 1e6
RG2 N2 0 1e6
RG3 N3 0 1e6
RG4 N4 0 1e6
RG5 N5 0 1e6
RG6 N6 0 1e6
RG7 N7 0 1e6
RG8 N8 0 1e6
RG9 N9 0 1e6
RG10 N10 0 1e6
RG11 N11 0 1e6
RG12 N12 0 1e6
RG13 N13 0 1e6
RG14 N14 0 1e6
RG15 N15 0 1e6
RG16 N16 0 1e6
RG17 N17 0 1e6
RG18 N18 0 1e6
RG19 N19 0 1e6
RG20 N20 0 1e6
RG21 N21 0 1e6
RG22 N22 0 1e6
RG23 N23 0 1e6
RG24 N24 0 1e6
RG25 N25 0 1e6
RG26 N26 0 1e6
RG27 N27 0 1e6
RG28 N28 0 1e6
RG29 N29 0 1e6
RG30 N30 0 1e6
RG31 N31 0 1e6
RG32 N32 0 1e6
RG33 N33 0 1e6
RG34 N34 0 1e6
RG35 N35 0 1e6
RG36 N36 0 1e6
RG37 N37 0 1e6
RG38 N38 0 1e6
RG39 N39 0 1e6
RG40 N40 0 1e6
RG41 N41 0 1e6
RG42 N42 0 1e6
RG43 N43 0 1e6
RG44 N44 0 1e6
RG45 N45 0 1e6
RG46 N46 0 1e6
RG47 N47 0 1e6
RG48 N48 0 1e6
RG49 N49 0 1e6
RG50 N50 0 1e6
RG51 N51 0 1e6
RG52 N52 0 1e6
RG53 N53 0 1e6
RG54 N54 0 1e6
RG55 N55 0 1e6
RG56 N56 0 1e6
RG57 N57 0 1e6
RG58 N58 0 1e6
RG59 N59 0 1e6
RG60 N60 0 1e6
RG61 N61 0 1e6
RG62 N62 0 1e6
RG63 N63 0 1e6
RG64 N64 0 1e6
RG65 N65 0 1e6
RG66 N66 0 1e6
RG67 N67 0 1e6
RG68 N68 0 1e6
RG69 N69 0 1e6
RG70 N70 0 1e6
RG71 N71 0 1e6
RG72 N72 0 1e6
RG73 N73 0 1e6
RG74 N74 0 1e6
RG75 N75 0 1e6
RG76 N76 0 1e6
RG77 N77 0 1e6
RG78 N78 0 1e6
RG79 N79 0 1e6
RG80 N80 0 1e6
RG81 N81 0 1e6
RG82 N82 0 1e6
RG83 N83 0 1e6
RG84 N84 0 1e6
RG85 N85 0 1e6
RG86 N86 0 1e6
RG87 N87 0 1e6
RG88 N88 0 1e6
RG89 N89 0 1e6
RG90 N90 0 1e6
RG91 N91 0 1e6
RG92 N92 0 1e6
RG93 N93 0 1e6
RG94 N94 0 1e6
RG95 N95 0 1e6
RG96 N96 0 1e6
RG97 N97 0 1e6
RG98 N98 0 1e6
RG99 N99 0 1e6
RG100 N100 0 1e6
RG101 N101 0 1e6
RG102 N102 0 1e6
RG103 N103 0 1e6
RG104 N104 0 1e6
RG105 N105 0 1e6
RG106 N106 0 1e6
RG107 N107 0 1e6
RG108 N108 0 1e6
RG109 N109 0 1e6
RG110 N110 0 1e6
RG111 N111 0 1e6
RG112 N112 0 1e6
RG113 N113 0 1e6
RG114 N114 0 1e6
RG115 N115 0 1e6
RG116 N116 0 1e6
RG117 N117 0 1e6
RG118 N118 0 1e6
RG119 N119 0 1e6
RG120 N120 0 1e6
RG121 N121 0 1e6
RG122 N122 0 1e6
RG123 N123 0 1e6
RG124 N124 0 1e6
RG125 N125 0 1e6
RG126 N126 0 1e6
RG127 N127 0 1e6
RG128 N128 0 1e6
RG129 N129 0 1e6
RG130 N130 0 1e6
RG131 N131 0 1e6
RG132 N132 0 1e6
RG133 N133 0 1e6
RG134 N134 0 1e6
RG135 N135 0 1e6
RG136 N136 0 1e6
RG137 N137 0 1e6
RG138 N138 0 1e6
RG139 N139 0 1e6
RG140 N140 0 1e6
RG141 N141 0 1e6
RG142 N142 0 1e6
RG143 N143 0 1e6
RG144 N144 0 1e6
RG145 N145 0 1e6
RG146 N146 0 1e6
RG147 N147 0 1e6
RG148 N148 0 1e6
RG149 N149 0 1e6
RG150 N150 0 1e6
RG151 N151 0 1e6
RG152 N152 0 1e6
RG153 N153 0 1e6
RG154 N154 0 1e6
RG155 N155 0 1e6
RG156 N156 0 1e6
RG157 N157 0 1e6
RG158 N158 0 1e6
RG159 N159 0 1e6
RG160 N160 0 1e6
RG161 N161 0 1e6
RG162 N162 0 1e6
RG163 N163 0 1e6
RG164 N164 0 1e6
RG165 N165 0 1e6
RG166 N166 0 1e6
RG167 N167 0 1e6
RG168 N168 0 1e6
RG169 N169 0 1e6
RG170 N170 0 1e6
RG171 N171 0 1e6
RG172 N172 0 1e6
RG173 N173 0 1e6
RG174 N174 0 1e6
RG175 N175 0 1e6
RG176 N176 0 1e6
RG177 N177 0 1e6
RG178 N178 0 1e6
RG179 N179 0 1e6
RG180 N180 0 1e6
RG181 N181 0 1e6
RG182 N182 0 1e6
RG183 N183 0 1e6
RG184 N184 0 1e6
RG185 N185 0 1e6
RG186 N186 0 1e6
RG187 N187 0 1e6
RG188 N188 0 1e6
RG189 N189 0 1e6
RG190 N190 0 1e6
RG191 N191 0 1e6
RG192 N192 0 1e6
RG193 N193 0 1e6
RG194 N194 0 1e6
RG195 N195 0 1e6
RG196 N196 0 1e6
RG197 N197 0 1e6
RG198 N198 0 1e6
RG199 N199 0 1e6
RG200 N200 0 1e6
RG201 N201 0 1e6
RG202 N202 0 1e6
RG203 N203 0 1e6
RG204 N204 0 1e6
RG205 N205 0 1e6
RG206 N206 0 1e6
RG207 N207 0 1e6
RG208 N208 0 1e6
RG209 N209 0 1e6
RG210 N210 0 1e6
RG211 N211 0 1e6
RG212 N212 0 1e6
RG213 N213 0 1e6
RG214 N214 0 1e6
RG215 N215 0 1e6
RG216 N216 0 1e6
RG217 N217 0 1e6
RG218 N218 0 1e6
RG219 N219 0 1e6
RG220 N220 0 1e6
RG221 N221 0 1e6
RG222 N222 0 1e6
RG223 N223 0 1e6
RG224 N224 0 1e6
RG225 N225 0 1e6
RG226 N226 0 1e6
RG227 N227 0 1e6
RG228 N228 0 1e6
RG229 N229 0 1e6
RG230 N230 0 1e6
RG231 N231 0 1e6
RG232 N232 0 1e6
RG233 N233 0 1e6
RG234 N234 0 1e6
RG235 N235 0 1e6
RG236 N236 0 1e6
RG237 N237 0 1e6
RG238 N238 0 1e6
RG239 N239 0 1e6
RG240 N240 0 1e6
RG241 N241 0 1e6
RG242 N242 0 1e6
RG243 N243 0 1e6
RG244 N244 0 1e6
RG245 N245 0 1e6
RG246 N246 0 1e6
RG247 N247 0 1e6
RG248 N248 0 1e6
RG249 N249 0 1e6
RG250 N250 0 1e6
RG251 N251 0 1e6
RG252 N252 0 1e6
RG253 N253 0 1e6
RG254 N254 0 1e6
RG255 N255 0 1e6
RG256 N256 0 1e6
RG257 N257 0 1e6
RG258 N258 0 1e6
RG259 N259 0 1e6
RG260 N260 0 1e6
RG261 N261 0 1e6
RG262 N262 0 1e6
RG263 N263 0 1e6
RG264 N264 0 1e6
RG265 N265 0 1e6
RG266 N266 0 1e6
RG267 N267 0 1e6
RG268 N268 0 1e6
RG269 N269 0 1e6
RG270 N270 0 1e6
RG271 N271 0 1e6
RG272 N272 0 1e6
RG273 N273 0 1e6
RG274 N274 0 1e6
RG275 N275 0 1e6
RG276 N276 0 1e6
RG277 N277 0 1e6
RG278 N278 0 1e6
RG279 N279 0 1e6
RG280 N280 0 1e6
RG281 N281 0 1e6
RG282 N282 0 1e6
RG283 N283 0 1e6
RG284 N284 0 1e6
RG285 N285 0 1e6
RG286 N286 0 1e6
RG287 N287 0 1e6
RG288 N288 0 1e6
RG289 N289 0 1e6
RG290 N290 0 1e6
RG291 N291 0 1e6
RG292 N292 0 1e6
RG293 N293 0 1e6
RG294 N294 0 1e6
RG295 N295 0 1e6
RG296 N296 0 1e6
RG297 N297 0 1e6
RG298 N298 0 1e6
RG299 N299 0 1e6
RG300 N300 0 1e6
RG301 N301 0 1e6
RG302 N302 0 1e6
RG303 N303 0 1e6
RG304 N304 0 1e6
RG305 N305 0 1e6
RG306 N306 0 1e6
RG307 N307 0 1e6
RG308 N308 0 1e6
RG309 N309 0 1e6
RG310 N310 0 1e6
RG311 N311 0 1e6
RG312 N312 0 1e6
RG313 N313 0 1e6
RG314 N314 0 1e6
RG315 N315 0 1e6
RG316 N316 0 1e6
RG317 N317 0 1e6
RG318 N318 0 1e6
RG319 N319 0 1e6
RG320 N320 0 1e6
RG321 N321 0 1e6
RG322 N322 0 1e6
RG323 N323 0 1e6
RG324 N324 0 1e6
RG325 N325 0 1e6
RG326 N326 0 1e6
RG327 N327 0 1e6
RG328 N328 0 1e6
RG329 N329 0 1e6
RG330 N330 0 1e6
RG331 N331 0 1e6
RG332 N332 0 1e6
RG333 N333 0 1e6
RG334 N334 0 1e6
RG335 N335 0 1e6
RG336 N336 0 1e6
RG337 N337 0 1e6
RG338 N338 0 1e6
RG339 N339 0 1e6
RG340 N340 0 1e6
RG341 N341 0 1e6
RG342 N342 0 1e6
RG343 N343 0 1e6
RG344 N344 0 1e6
RG345 N345 0 1e6
RG346 N346 0 1e6
RG347 N347 0 1e6
RG348 N348 0 1e6
RG349 N349 0 1e6
RG350 N350 0 1e6
RG351 N351 0 1e6
RG352 N352 0 1e6
RG353 N353 0 1e6
RG354 N354 0 1e6
RG355 N355 0 1e6
RG356 N356 0 1e6
RG357 N357 0 1e6
RG358 N358 0 1e6
RG359 N359 0 1e6
RG360 N360 0 1e6
RG361 N361 0 1e6
RG362 N362 0 1e6
RG363 N363 0 1e6
RG364 N364 0 1e6
RG365 N365 0 1e6
RG366 N366 0 1e6
RG367 N367 0 1e6
RG368 N368 0 1e6
RG369 N369 0 1e6
RG370 N370 0 1e6
RG371 N371 0 1e6
RG372 N372 0 1e6
RG373 N373 0 1e6
RG374 N374 0 1e6
RG375 N375 0 1e6
RG376 N376 0 1e6
RG377 N377 0 1e6
RG378 N378 0 1e6
RG379 N379 0 1e6
RG380 N380 0 1e6
RG381 N381 0 1e6
RG382 N382 0 1e6
RG383 N383 0 1e6
RG384 N384 0 1e6
RG385 N385 0 1e6
RG386 N386 0 1e6
RG387 N387 0 1e6
RG388 N388 0 1e6
RG389 N389 0 1e6
RG390 N390 0 1e6
RG391 N391 0 1e6
RG392 N392 0 1e6
RG393 N393 0 1e6
RG394 N394 0 1e6
RG395 N395 0 1e6
RG396 N396 0 1e6
RG397 N397 0 1e6
RG398 N398 0 1e6
RG399 N399 0 1e6
RG400 N400 0 1e6
RG401 N401 0 1e6
RG402 N402 0 1e6
RG403 N403 0 1e6
RG404 N404 0 1e6
RG405 N405 0 1e6
RG406 N406 0 1e6
RG407 N407 0 1e6
RG408 N408 0 1e6
RG409 N409 0 1e6
RG410 N410 0 1e6
RG411 N411 0 1e6
RG412 N412 0 1e6
RG413 N413 0 1e6
RG414 N414 0 1e6
RG415 N415 0 1e6
RG416 N416 0 1e6
RG417 N417 0 1e6
RG418 N418 0 1e6
RG419 N419 0 1e6
RG420 N420 0 1e6
RG421 N421 0 1e6
RG422 N422 0 1e6
RG423 N423 0 1e6
RG424 N424 0 1e6
RG425 N425 0 1e6
RG426 N426 0 1e6
RG427 N427 0 1e6
RG428 N428 0 1e6
RG429 N429 0 1e6
RG430 N430 0 1e6
RG431 N431 0 1e6
RG432 N432 0 1e6
RG433 N433 0 1e6
RG434 N434 0 1e6
RG435 N435 0 1e6
RG436 N436 0 1e6
RG437 N437 0 1e6
RG438 N438 0 1e6
RG439 N439 0 1e6
RG440 N440 0 1e6
RG441 N441 0 1e6
RG442 N442 0 1e6
RG443 N443 0 1e6
RG444 N444 0 1e6
RG445 N445 0 1e6
RG446 N446 0 1e6
RG447 N447 0 1e6
RG448 N448 0 1e6
RG449 N449 0 1e6
RG450 N450 0 1e6
RG451 N451 0 1e6
RG452 N452 0 1e6
RG453 N453 0 1e6
RG454 N454 0 1e6
RG455 N455 0 1e6
RG456 N456 0 1e6
RG457 N457 0 1e6
RG458 N458 0 1e6
RG459 N459 0 1e6
RG460 N460 0 1e6
RG461 N461 0 1e6
RG462 N462 0 1e6
RG463 N463 0 1e6
RG464 N464 0 1e6
RG465 N465 0 1e6
RG466 N466 0 1e6
RG467 N467 0 1e6
RG468 N468 0 1e6
RG469 N469 0 1e6
RG470 N470 0 1e6
RG471 N471 0 1e6
RG472 N472 0 1e6
RG473 N473 0 1e6
RG474 N474 0 1e6
RG475 N475 0 1e6
RG476 N476 0 1e6
RG477 N477 0 1e6
RG478 N478 0 1e6
RG479 N479 0 1e6
RG480 N480 0 1e6
RG481 N481 0 1e6
RG482 N482 0 1e6
RG483 N483 0 1e6
RG484 N484 0 1e6
RG485 N485 0 1e6
RG486 N486 0 1e6
RG487 N487 0 1e6
RG488 N488 0 1e6
RG489 N489 0 1e6
RG490 N490 0 1e6
RG491 N491 0 1e6
RG492 N492 0 1e6
RG493 N493 0 1e6
RG494 N494 0 1e6
RG495 N495 0 1e6
RG496 N496 0 1e6
RG497 N497 0 1e6
RG498 N498 0 1e6
RG499 N499 0 1e6
RG500 N500 0 1e6
RG501 N501 0 1e6
RG502 N502 0 1e6
RG503 N503 0 1e6
RG504 N504 0 1e6
RG505 N505 0 1e6
RG506 N506 0 1e6
RG507 N507 0 1e6
RG508 N508 0 1e6
RG509 N509 0 1e6
RG510 N510 0 1e6
RG511 N511 0 1e6
RG512 N512 0 1e6
RG513 N513 0 1e6
RG514 N514 0 1e6
RG515 N515 0 1e6
RG516 N516 0 1e6
RG517 N517 0 1e6
RG518 N518 0 1e6
RG519 N519 0 1e6
RG520 N520 0 1e6
RG521 N521 0 1e6
RG522 N522 0 1e6
RG523 N523 0 1e6
RG524 N524 0 1e6
RG525 N525 0 1e6
RG526 N526 0 1e6
RG527 N527 0 1e6
RG528 N528 0 1e6
RG529 N529 0 1e6
RG530 N530 0 1e6
RG531 N531 0 1e6
RG532 N532 0 1e6
RG533 N533 0 1e6
RG534 N534 0 1e6
RG535 N535 0 1e6
RG536 N536 0 1e6
RG537 N537 0 1e6
RG538 N538 0 1e6
RG539 N539 0 1e6
RG540 N540 0 1e6
RG541 N541 0 1e6
RG542 N542 0 1e6
RG543 N543 0 1e6
RG544 N544 0 1e6
RG545 N545 0 1e6
RG546 N546 0 1e6
RG547 N547 0 1e6
RG548 N548 0 1e6
RG549 N549 0 1e6
RG550 N550 0 1e6
RG551 N551 0 1e6
RG552 N552 0 1e6
RG553 N553 0 1e6
RG554 N554 0 1e6
RG555 N555 0 1e6
RG556 N556 0 1e6
RG557 N557 0 1e6
RG558 N558 0 1e6
RG559 N559 0 1e6
RG560 N560 0 1e6
RG561 N561 0 1e6
RG562 N562 0 1e6
RG563 N563 0 1e6
RG564 N564 0 1e6
RG565 N565 0 1e6
RG566 N566 0 1e6
RG567 N567 0 1e6
RG568 N568 0 1e6
RG569 N569 0 1e6
RG570 N570 0 1e6
RG571 N571 0 1e6
RG572 N572 0 1e6
RG573 N573 0 1e6
RG574 N574 0 1e6
RG575 N575 0 1e6
RG576 N576 0 1e6
RG577 N577 0 1e6
RG578 N578 0 1e6
RG579 N579 0 1e6
RG580 N580 0 1e6
RG581 N581 0 1e6
RG582 N582 0 1e6
RG583 N583 0 1e6
RG584 N584 0 1e6
RG585 N585 0 1e6
RG586 N586 0 1e6
RG587 N587 0 1e6
RG588 N588 0 1e6
RG589 N589 0 1e6
RG590 N590 0 1e6
RG591 N591 0 1e6
RG592 N592 0 1e6
RG593 N593 0 1e6
RG594 N594 0 1e6
RG595 N595 0 1e6
RG596 N596 0 1e6
RG597 N597 0 1e6
RG598 N598 0 1e6
RG599 N599 0 1e6
RG600 N600 0 1e6
RG601 N601 0 1e6
RG602 N602 0 1e6
RG603 N603 0 1e6
RG604 N604 0 1e6
RG605 N605 0 1e6
RG606 N606 0 1e6
RG607 N607 0 1e6
RG608 N608 0 1e6
RG609 N609 0 1e6
RG610 N610 0 1e6
RG611 N611 0 1e6
RG612 N612 0 1e6
RG613 N613 0 1e6
RG614 N614 0 1e6
RG615 N615 0 1e6
RG616 N616 0 1e6
RG617 N617 0 1e6
RG618 N618 0 1e6
RG619 N619 0 1e6
RG620 N620 0 1e6
RG621 N621 0 1e6
RG622 N622 0 1e6
RG623 N623 0 1e6
RG624 N624 0 1e6
RG625 N625 0 1e6
RG626 N626 0 1e6
RG627 N627 0 1e6
RG628 N628 0 1e6
RG629 N629 0 1e6
RG630 N630 0 1e6
RG631 N631 0 1e6
RG632 N632 0 1e6
RG633 N633 0 1e6
RG634 N634 0 1e6
RG635 N635 0 1e6
RG636 N636 0 1e6
RG637 N637 0 1e6
RG638 N638 0 1e6
RG639 N639 0 1e6
RG640 N640 0 1e6
RG641 N641 0 1e6
RG642 N642 0 1e6
RG643 N643 0 1e6
RG644 N644 0 1e6
RG645 N645 0 1e6
RG646 N646 0 1e6
RG647 N647 0 1e6
RG648 N648 0 1e6
RG649 N649 0 1e6
RG650 N650 0 1e6
RG651 N651 0 1e6
RG652 N652 0 1e6
RG653 N653 0 1e6
RG654 N654 0 1e6
RG655 N655 0 1e6
RG656 N656 0 1e6
RG657 N657 0 1e6
RG658 N658 0 1e6
RG659 N659 0 1e6
RG660 N660 0 1e6
RG661 N661 0 1e6
RG662 N662 0 1e6
RG663 N663 0 1e6
RG664 N664 0 1e6
RG665 N665 0 1e6
RG666 N666 0 1e6
RG667 N667 0 1e6
RG668 N668 0 1e6
RG669 N669 0 1e6
RG670 N670 0 1e6
RG671 N671 0 1e6
RG672 N672 0 1e6
RG673 N673 0 1e6
RG674 N674 0 1e6
RG675 N675 0 1e6
RG676 N676 0 1e6
RG677 N677 0 1e6
RG678 N678 0 1e6
RG679 N679 0 1e6
RG680 N680 0 1e6
RG681 N681 0 1e6
RG682 N682 0 1e6
RG683 N683 0 1e6
RG684 N684 0 1e6
RG685 N685 0 1e6
RG686 N686 0 1e6
RG687 N687 0 1e6
RG688 N688 0 1e6
RG689 N689 0 1e6
RG690 N690 0 1e6
RG691 N691 0 1e6
RG692 N692 0 1e6
RG693 N693 0 1e6
RG694 N694 0 1e6
RG695 N695 0 1e6
RG696 N696 0 1e6
RG697 N697 0 1e6
RG698 N698 0 1e6
RG699 N699 0 1e6
RG700 N700 0 1e6
RG701 N701 0 1e6
RG702 N702 0 1e6
RG703 N703 0 1e6
RG704 N704 0 1e6
RG705 N705 0 1e6
RG706 N706 0 1e6
RG707 N707 0 1e6
RG708 N708 0 1e6
RG709 N709 0 1e6
RG710 N710 0 1e6
RG711 N711 0 1e6
RG712 N712 0 1e6
RG713 N713 0 1e6
RG714 N714 0 1e6
RG715 N715 0 1e6
RG716 N716 0 1e6
RG717 N717 0 1e6
RG718 N718 0 1e6
RG719 N719 0 1e6
RG720 N720 0 1e6
RG721 N721 0 1e6
RG722 N722 0 1e6
RG723 N723 0 1e6
RG724 N724 0 1e6
RG725 N725 0 1e6
RG726 N726 0 1e6
RG727 N727 0 1e6
RG728 N728 0 1e6
RG729 N729 0 1e6
RG730 N730 0 1e6
RG731 N731 0 1e6
RG732 N732 0 1e6
RG733 N733 0 1e6
RG734 N734 0 1e6
RG735 N735 0 1e6
RG736 N736 0 1e6
RG737 N737 0 1e6
RG738 N738 0 1e6
RG739 N739 0 1e6
RG740 N740 0 1e6
RG741 N741 0 1e6
RG742 N742 0 1e6
RG743 N743 0 1e6
RG744 N744 0 1e6
RG745 N745 0 1e6
RG746 N746 0 1e6
RG747 N747 0 1e6
RG748 N748 0 1e6
RG749 N749 0 1e6
RG750 N750 0 1e6
RG751 N751 0 1e6
RG752 N752 0 1e6
RG753 N753 0 1e6
RG754 N754 0 1e6
RG755 N755 0 1e6
RG756 N756 0 1e6
RG757 N757 0 1e6
RG758 N758 0 1e6
RG759 N759 0 1e6
RG760 N760 0 1e6
RG761 N761 0 1e6
RG762 N762 0 1e6
RG763 N763 0 1e6
RG764 N764 0 1e6
RG765 N765 0 1e6
RG766 N766 0 1e6
RG767 N767 0 1e6
RG768 N768 0 1e6
RG769 N769 0 1e6
RG770 N770 0 1e6
RG771 N771 0 1e6
RG772 N772 0 1e6
RG773 N773 0 1e6
RG774 N774 0 1e6
RG775 N775 0 1e6
RG776 N776 0 1e6
RG777 N777 0 1e6
RG778 N778 0 1e6
RG779 N779 0 1e6
RG780 N780 0 1e6
RG781 N781 0 1e6
RG782 N782 0 1e6
RG783 N783 0 1e6
RG784 N784 0 1e6
RG785 N785 0 1e6
RG786 N786 0 1e6
RG787 N787 0 1e6
RG788 N788 0 1e6
RG789 N789 0 1e6
RG790 N790 0 1e6
RG791 N791 0 1e6
RG792 N792 0 1e6
RG793 N793 0 1e6
RG794 N794 0 1e6
RG795 N795 0 1e6
RG796 N796 0 1e6
RG797 N797 0 1e6
RG798 N798 0 1e6
RG799 N799 0 1e6
RG800 N800 0 1e6
RG801 N801 0 1e6
RG802 N802 0 1e6
RG803 N803 0 1e6
RG804 N804 0 1e6
RG805 N805 0 1e6
RG806 N806 0 1e6
RG807 N807 0 1e6
RG808 N808 0 1e6
RG809 N809 0 1e6
RG810 N810 0 1e6
RG811 N811 0 1e6
RG812 N812 0 1e6
RG813 N813 0 1e6
RG814 N814 0 1e6
RG815 N815 0 1e6
RG816 N816 0 1e6
RG817 N817 0 1e6
RG818 N818 0 1e6
RG819 N819 0 1e6
RG820 N820 0 1e6
RG821 N821 0 1e6
RG822 N822 0 1e6
RG823 N823 0 1e6
RG824 N824 0 1e6
RG825 N825 0 1e6
RG826 N826 0 1e6
RG827 N827 0 1e6
RG828 N828 0 1e6
RG829 N829 0 1e6
RG830 N830 0 1e6
RG831 N831 0 1e6
RG832 N832 0 1e6
RG833 N833 0 1e6
RG834 N834 0 1e6
RG835 N835 0 1e6
RG836 N836 0 1e6
RG837 N837 0 1e6
RG838 N838 0 1e6
RG839 N839 0 1e6
RG840 N840 0 1e6
RG841 N841 0 1e6
RG842 N842 0 1e6
RG843 N843 0 1e6
RG844 N844 0 1e6
RG845 N845 0 1e6
RG846 N846 0 1e6
RG847 N847 0 1e6
RG848 N848 0 1e6
RG849 N849 0 1e6
RG850 N850 0 1e6
RG851 N851 0 1e6
RG852 N852 0 1e6
RG853 N853 0 1e6
RG854 N854 0 1e6
RG855 N855 0 1e6
RG856 N856 0 1e6
RG857 N857 0 1e6
RG858 N858 0 1e6
RG859 N859 0 1e6
RG860 N860 0 1e6
RG861 N861 0 1e6
RG862 N862 0 1e6
RG863 N863 0 1e6
RG864 N864 0 1e6
RG865 N865 0 1e6
RG866 N866 0 1e6
RG867 N867 0 1e6
RG868 N868 0 1e6
RG869 N869 0 1e6
RG870 N870 0 1e6
RG871 N871 0 1e6
RG872 N872 0 1e6
RG873 N873 0 1e6
RG874 N874 0 1e6
RG875 N875 0 1e6
RG876 N876 0 1e6
RG877 N877 0 1e6
RG878 N878 0 1e6
RG879 N879 0 1e6
RG880 N880 0 1e6
RG881 N881 0 1e6
RG882 N882 0 1e6
RG883 N883 0 1e6
RG884 N884 0 1e6
RG885 N885 0 1e6
RG886 N886 0 1e6
RG887 N887 0 1e6
RG888 N888 0 1e6
RG889 N889 0 1e6
RG890 N890 0 1e6
RG891 N891 0 1e6
RG892 N892 0 1e6
RG893 N893 0 1e6
RG894 N894 0 1e6
RG895 N895 0 1e6
RG896 N896 0 1e6
RG897 N897 0 1e6
RG898 N898 0 1e6
RG899 N899 0 1e6
RG900 N900 0 1e6
RG901 N901 0 1e6
RG902 N902 0 1e6
RG903 N903 0 1e6
RG904 N904 0 1e6
RG905 N905 0 1e6
RG906 N906 0 1e6
RG907 N907 0 1e6
RG908 N908 0 1e6
RG909 N909 0 1e6
RG910 N910 0 1e6
RG911 N911 0 1e6
RG912 N912 0 1e6
RG913 N913 0 1e6
RG914 N914 0 1e6
RG915 N915 0 1e6
RG916 N916 0 1e6
RG917 N917 0 1e6
RG918 N918 0 1e6
RG919 N919 0 1e6
RG920 N920 0 1e6
RG921 N921 0 1e6
RG922 N922 0 1e6
RG923 N923 0 1e6
RG924 N924 0 1e6
RG925 N925 0 1e6
RG926 N926 0 1e6
RG927 N927 0 1e6
RG928 N928 0 1e6
RG929 N929 0 1e6
RG930 N930 0 1e6
RG931 N931 0 1e6
RG932 N932 0 1e6
RG933 N933 0 1e6
RG934 N934 0 1e6
RG935 N935 0 1e6
RG936 N936 0 1e6
RG937 N937 0 1e6
RG938 N938 0 1e6
RG939 N939 0 1e6
RG940 N940 0 1e6
RG941 N941 0 1e6
RG942 N942 0 1e6
RG943 N943 0 1e6
RG944 N944 0 1e6
RG945 N945 0 1e6
RG946 N946 0 1e6
RG947 N947 0 1e6
RG948 N948 0 1e6
RG949 N949 0 1e6
RG950 N950 0 1e6
RG951 N951 0 1e6
RG952 N952 0 1e6
RG953 N953 0 1e6
RG954 N954 0 1e6
RG955 N955 0 1e6
RG956 N956 0 1e6
RG957 N957 0 1e6
RG958 N958 0 1e6
RG959 N959 0 1e6
RG960 N960 0 1e6
RG961 N961 0 1e6
RG962 N962 0 1e6
RG963 N963 0 1e6
RG964 N964 0 1e6
RG965 N965 0 1e6
RG966 N966 0 1e6
RG967 N967 0 1e6
RG968 N968 0 1e6
RG969 N969 0 1e6
RG970 N970 0 1e6
RG971 N971 0 1e6
RG972 N972 0 1e6
RG973 N973 0 1e6
RG974 N974 0 1e6
RG975 N975 0 1e6
RG976 N976 0 1e6
RG977 N977 0 1e6
RG978 N978 0 1e6
RG979 N979 0 1e6
RG980 N980 0 1e6
RG981 N981 0 1e6
RG982 N982 0 1e6
RG983 N983 0 1e6
RG984 N984 0 1e6
RG985 N985 0 1e6
RG986 N986 0 1e6
RG987 N987 0 1e6
RG988 N988 0 1e6
RG989 N989 0 1e6
RG990 N990 0 1e6
RG991 N991 0 1e6
RG992 N992 0 1e6
RG993 N993 0 1e6
RG994 N994 0 1e6
RG995 N995 0 1e6
RG996 N996 0 1e6
RG997 N997 0 1e6
RG998 N998 0 1e6
RG999 N999 0 1e6
RG1000 N1000 0 1e6
RG1001 N1001 0 1e6
RG1002 N1002 0 1e6
RG1003 N1003 0 1e6
RG1004 N1004 0 1e6
RG1005 N1005 0 1e6
RG1006 N1006 0 1e6
RG1007 N1007 0 1e6
RG1008 N1008 0 1e6
RG1009 N1009 0 1e6
RG1010 N1010 0 1e6
RG1011 N1011 0 1e6
RG1012 N1012 0 1e6
RG1013 N1013 0 1e6
RG1014 N1014 0 1e6
RG1015 N1015 0 1e6
RG1016 N1016 0 1e6
RG1017 N1017 0 1e6
RG1018 N1018 0 1e6
RG1019 N1019 0 1e6
RG1020 N1020 0 1e6
RG1021 N1021 0 1e6
RG1022 N1022 0 1e6
RG1023 N1023 0 1e6
RG1024 N1024 0 1e6
RG1025 N1025 0 1e6
RG1026 N1026 0 1e6
RG1027 N1027 0 1e6
RG1028 N1028 0 1e6
RG1029 N1029 0 1e6
RG1030 N1030 0 1e6
RG1031 N1031 0 1e6
RG1032 N1032 0 1e6
RG1033 N1033 0 1e6
RG1034 N1034 0 1e6
RG1035 N1035 0 1e6
RG1036 N1036 0 1e6
RG1037 N1037 0 1e6
RG1038 N1038 0 1e6
RG1039 N1039 0 1e6
RG1040 N1040 0 1e6
RG1041 N1041 0 1e6
RG1042 N1042 0 1e6
RG1043 N1043 0 1e6
RG1044 N1044 0 1e6
RG1045 N1045 0 1e6
RG1046 N1046 0 1e6
RG1047 N1047 0 1e6
RG1048 N1048 0 1e6
RG1049 N1049 0 1e6
RG1050 N1050 0 1e6
RG1051 N1051 0 1e6
RG1052 N1052 0 1e6
RG1053 N1053 0 1e6
RG1054 N1054 0 1e6
RG1055 N1055 0 1e6
RG1056 N1056 0 1e6
RG1057 N1057 0 1e6
RG1058 N1058 0 1e6
RG1059 N1059 0 1e6
RG1060 N1060 0 1e6
RG1061 N1061 0 1e6
RG1062 N1062 0 1e6
RG1063 N1063 0 1e6
RG1064 N1064 0 1e6
RG1065 N1065 0 1e6
RG1066 N1066 0 1e6
RG1067 N1067 0 1e6
RG1068 N1068 0 1e6
RG1069 N1069 0 1e6
RG1070 N1070 0 1e6
RG1071 N1071 0 1e6
RG1072 N1072 0 1e6
RG1073 N1073 0 1e6
RG1074 N1074 0 1e6
RG1075 N1075 0 1e6
RG1076 N1076 0 1e6
RG1077 N1077 0 1e6
RG1078 N1078 0 1e6
RG1079 N1079 0 1e6
RG1080 N1080 0 1e6
RG1081 N1081 0 1e6
RG1082 N1082 0 1e6
RG1083 N1083 0 1e6
RG1084 N1084 0 1e6
RG1085 N1085 0 1e6
RG1086 N1086 0 1e6
RG1087 N1087 0 1e6
RG1088 N1088 0 1e6
RG1089 N1089 0 1e6
RG1090 N1090 0 1e6
RG1091 N1091 0 1e6
RG1092 N1092 0 1e6
RG1093 N1093 0 1e6
RG1094 N1094 0 1e6
RG1095 N1095 0 1e6
RG1096 N1096 0 1e6
RG1097 N1097 0 1e6
RG1098 N1098 0 1e6
RG1099 N1099 0 1e6
RG1100 N1100 0 1e6
RG1101 N1101 0 1e6
RG1102 N1102 0 1e6
RG1103 N1103 0 1e6
RG1104 N1104 0 1e6
RG1105 N1105 0 1e6
RG1106 N1106 0 1e6
RG1107 N1107 0 1e6
RG1108 N1108 0 1e6
RG1109 N1109 0 1e6
RG1110 N1110 0 1e6
RG1111 N1111 0 1e6
RG1112 N1112 0 1e6
RG1113 N1113 0 1e6
RG1114 N1114 0 1e6
RG1115 N1115 0 1e6
RG1116 N1116 0 1e6
RG1117 N1117 0 1e6
RG1118 N1118 0 1e6
RG1119 N1119 0 1e6
RG1120 N1120 0 1e6
RG1121 N1121 0 1e6
RG1122 N1122 0 1e6
RG1123 N1123 0 1e6
RG1124 N1124 0 1e6
RG1125 N1125 0 1e6
RG1126 N1126 0 1e6
RG1127 N1127 0 1e6
RG1128 N1128 0 1e6
RG1129 N1129 0 1e6
RG1130 N1130 0 1e6
RG1131 N1131 0 1e6
RG1132 N1132 0 1e6
RG1133 N1133 0 1e6
RG1134 N1134 0 1e6
RG1135 N1135 0 1e6
RG1136 N1136 0 1e6
RG1137 N1137 0 1e6
RG1138 N1138 0 1e6
RG1139 N1139 0 1e6
RG1140 N1140 0 1e6
RG1141 N1141 0 1e6
RG1142 N1142 0 1e6
RG1143 N1143 0 1e6
RG1144 N1144 0 1e6
RG1145 N1145 0 1e6
RG1146 N1146 0 1e6
RG1147 N1147 0 1e6
RG1148 N1148 0 1e6
RG1149 N1149 0 1e6
RG1150 N1150 0 1e6
RG1151 N1151 0 1e6
RG1152 N1152 0 1e6
RG1153 N1153 0 1e6
RG1154 N1154 0 1e6
RG1155 N1155 0 1e6
RG1156 N1156 0 1e6
RG1157 N1157 0 1e6
RG1158 N1158 0 1e6
RG1159 N1159 0 1e6
RG1160 N1160 0 1e6
RG1161 N1161 0 1e6
RG1162 N1162 0 1e6
RG1163 N1163 0 1e6
RG1164 N1164 0 1e6
RG1165 N1165 0 1e6
RG1166 N1166 0 1e6
RG1167 N1167 0 1e6
RG1168 N1168 0 1e6
RG1169 N1169 0 1e6
RG1170 N1170 0 1e6
RG1171 N1171 0 1e6
RG1172 N1172 0 1e6
RG1173 N1173 0 1e6
RG1174 N1174 0 1e6
RG1175 N1175 0 1e6
RG1176 N1176 0 1e6
RG1177 N1177 0 1e6
RG1178 N1178 0 1e6
RG1179 N1179 0 1e6
RG1180 N1180 0 1e6
RG1181 N1181 0 1e6
RG1182 N1182 0 1e6
RG1183 N1183 0 1e6
RG1184 N1184 0 1e6
RG1185 N1185 0 1e6
RG1186 N1186 0 1e6
RG1187 N1187 0 1e6
RG1188 N1188 0 1e6
RG1189 N1189 0 1e6
RG1190 N1190 0 1e6
RG1191 N1191 0 1e6
RG1192 N1192 0 1e6
RG1193 N1193 0 1e6
RG1194 N1194 0 1e6
RG1195 N1195 0 1e6
RG1196 N1196 0 1e6
RG1197 N1197 0 1e6
RG1198 N1198 0 1e6
RG1199 N1199 0 1e6
RG1200 N1200 0 1e6
RG1201 N1201 0 1e6
RG1202 N1202 0 1e6
RG1203 N1203 0 1e6
RG1204 N1204 0 1e6
RG1205 N1205 0 1e6
RG1206 N1206 0 1e6
RG1207 N1207 0 1e6
RG1208 N1208 0 1e6
RG1209 N1209 0 1e6
RG1210 N1210 0 1e6
RG1211 N1211 0 1e6
RG1212 N1212 0 1e6
RG1213 N1213 0 1e6
RG1214 N1214 0 1e6
RG1215 N1215 0 1e6
RG1216 N1216 0 1e6
RG1217 N1217 0 1e6
RG1218 N1218 0 1e6
RG1219 N1219 0 1e6
RG1220 N1220 0 1e6
RG1221 N1221 0 1e6
RG1222 N1222 0 1e6
RG1223 N1223 0 1e6
RG1224 N1224 0 1e6
RG1225 N1225 0 1e6
RG1226 N1226 0 1e6
RG1227 N1227 0 1e6
RG1228 N1228 0 1e6
RG1229 N1229 0 1e6
RG1230 N1230 0 1e6
RG1231 N1231 0 1e6
RG1232 N1232 0 1e6
RG1233 N1233 0 1e6
RG1234 N1234 0 1e6
RG1235 N1235 0 1e6
RG1236 N1236 0 1e6
RG1237 N1237 0 1e6
RG1238 N1238 0 1e6
RG1239 N1239 0 1e6
RG1240 N1240 0 1e6
RG1241 N1241 0 1e6
RG1242 N1242 0 1e6
RG1243 N1243 0 1e6
RG1244 N1244 0 1e6
RG1245 N1245 0 1e6
RG1246 N1246 0 1e6
RG1247 N1247 0 1e6
RG1248 N1248 0 1e6
RG1249 N1249 0 1e6
RG1250 N1250 0 1e6
RG1251 N1251 0 1e6
RG1252 N1252 0 1e6
RG1253 N1253 0 1e6
RG1254 N1254 0 1e6
RG1255 N1255 0 1e6
RG1256 N1256 0 1e6
RG1257 N1257 0 1e6
RG1258 N1258 0 1e6
RG1259 N1259 0 1e6
RG1260 N1260 0 1e6
RG1261 N1261 0 1e6
RG1262 N1262 0 1e6
RG1263 N1263 0 1e6
RG1264 N1264 0 1e6
RG1265 N1265 0 1e6
RG1266 N1266 0 1e6
RG1267 N1267 0 1e6
RG1268 N1268 0 1e6
RG1269 N1269 0 1e6
RG1270 N1270 0 1e6
RG1271 N1271 0 1e6
RG1272 N1272 0 1e6
RG1273 N1273 0 1e6
RG1274 N1274 0 1e6
RG1275 N1275 0 1e6
RG1276 N1276 0 1e6
RG1277 N1277 0 1e6
RG1278 N1278 0 1e6
RG1279 N1279 0 1e6
RG1280 N1280 0 1e6
RG1281 N1281 0 1e6
RG1282 N1282 0 1e6
RG1283 N1283 0 1e6
RG1284 N1284 0 1e6
RG1285 N1285 0 1e6
RG1286 N1286 0 1e6
RG1287 N1287 0 1e6
RG1288 N1288 0 1e6
RG1289 N1289 0 1e6
RG1290 N1290 0 1e6
RG1291 N1291 0 1e6
RG1292 N1292 0 1e6
RG1293 N1293 0 1e6
RG1294 N1294 0 1e6
RG1295 N1295 0 1e6
RG1296 N1296 0 1e6
RG1297 N1297 0 1e6
RG1298 N1298 0 1e6
RG1299 N1299 0 1e6
RG1300 N1300 0 1e6
RG1301 N1301 0 1e6
RG1302 N1302 0 1e6
RG1303 N1303 0 1e6
RG1304 N1304 0 1e6
RG1305 N1305 0 1e6
RG1306 N1306 0 1e6
RG1307 N1307 0 1e6
RG1308 N1308 0 1e6
RG1309 N1309 0 1e6
RG1310 N1310 0 1e6
RG1311 N1311 0 1e6
RG1312 N1312 0 1e6
RG1313 N1313 0 1e6
RG1314 N1314 0 1e6
RG1315 N1315 0 1e6
RG1316 N1316 0 1e6
RG1317 N1317 0 1e6
RG1318 N1318 0 1e6
RG1319 N1319 0 1e6
RG1320 N1320 0 1e6
RG1321 N1321 0 1e6
RG1322 N1322 0 1e6
RG1323 N1323 0 1e6
RG1324 N1324 0 1e6
RG1325 N1325 0 1e6
RG1326 N1326 0 1e6
RG1327 N1327 0 1e6
RG1328 N1328 0 1e6
RG1329 N1329 0 1e6
RG1330 N1330 0 1e6
RG1331 N1331 0 1e6
RG1332 N1332 0 1e6
RG1333 N1333 0 1e6
RG1334 N1334 0 1e6
RG1335 N1335 0 1e6
RG1336 N1336 0 1e6
RG1337 N1337 0 1e6
RG1338 N1338 0 1e6
RG1339 N1339 0 1e6
RG1340 N1340 0 1e6
RG1341 N1341 0 1e6
RG1342 N1342 0 1e6
RG1343 N1343 0 1e6
RG1344 N1344 0 1e6
RG1345 N1345 0 1e6
RG1346 N1346 0 1e6
RG1347 N1347 0 1e6
RG1348 N1348 0 1e6
RG1349 N1349 0 1e6
RG1350 N1350 0 1e6
RG1351 N1351 0 1e6
RG1352 N1352 0 1e6
RG1353 N1353 0 1e6
RG1354 N1354 0 1e6
RG1355 N1355 0 1e6
RG1356 N1356 0 1e6
RG1357 N1357 0 1e6
RG1358 N1358 0 1e6
RG1359 N1359 0 1e6
RG1360 N1360 0 1e6
RG1361 N1361 0 1e6
RG1362 N1362 0 1e6
RG1363 N1363 0 1e6
RG1364 N1364 0 1e6
RG1365 N1365 0 1e6
RG1366 N1366 0 1e6
RG1367 N1367 0 1e6
RG1368 N1368 0 1e6
RG1369 N1369 0 1e6
RG1370 N1370 0 1e6
RG1371 N1371 0 1e6
RG1372 N1372 0 1e6
RG1373 N1373 0 1e6
RG1374 N1374 0 1e6
RG1375 N1375 0 1e6
RG1376 N1376 0 1e6
RG1377 N1377 0 1e6
RG1378 N1378 0 1e6
RG1379 N1379 0 1e6
RG1380 N1380 0 1e6
RG1381 N1381 0 1e6
RG1382 N1382 0 1e6
RG1383 N1383 0 1e6
RG1384 N1384 0 1e6
RG1385 N1385 0 1e6
RG1386 N1386 0 1e6
RG1387 N1387 0 1e6
RG1388 N1388 0 1e6
RG1389 N1389 0 1e6
RG1390 N1390 0 1e6
RG1391 N1391 0 1e6
RG1392 N1392 0 1e6
RG1393 N1393 0 1e6
RG1394 N1394 0 1e6
RG1395 N1395 0 1e6
RG1396 N1396 0 1e6
RG1397 N1397 0 1e6
RG1398 N1398 0 1e6
RG1399 N1399 0 1e6
RG1400 N1400 0 1e6
RG1401 N1401 0 1e6
RG1402 N1402 0 1e6
RG1403 N1403 0 1e6
RG1404 N1404 0 1e6
RG1405 N1405 0 1e6
RG1406 N1406 0 1e6
RG1407 N1407 0 1e6
RG1408 N1408 0 1e6
RG1409 N1409 0 1e6
RG1410 N1410 0 1e6
RG1411 N1411 0 1e6
RG1412 N1412 0 1e6
RG1413 N1413 0 1e6
RG1414 N1414 0 1e6
RG1415 N1415 0 1e6
RG1416 N1416 0 1e6
RG1417 N1417 0 1e6
RG1418 N1418 0 1e6
RG1419 N1419 0 1e6
RG1420 N1420 0 1e6
RG1421 N1421 0 1e6
RG1422 N1422 0 1e6
RG1423 N1423 0 1e6
RG1424 N1424 0 1e6
RG1425 N1425 0 1e6
RG1426 N1426 0 1e6
RG1427 N1427 0 1e6
RG1428 N1428 0 1e6
RG1429 N1429 0 1e6
RG1430 N1430 0 1e6
RG1431 N1431 0 1e6
RG1432 N1432 0 1e6
RG1433 N1433 0 1e6
RG1434 N1434 0 1e6
RG1435 N1435 0 1e6
RG1436 N1436 0 1e6
RG1437 N1437 0 1e6
RG1438 N1438 0 1e6
RG1439 N1439 0 1e6
RG1440 N1440 0 1e6
RG1441 N1441 0 1e6
RG1442 N1442 0 1e6
RG1443 N1443 0 1e6
RG1444 N1444 0 1e6
RG1445 N1445 0 1e6
RG1446 N1446 0 1e6
RG1447 N1447 0 1e6
RG1448 N1448 0 1e6
RG1449 N1449 0 1e6
RG1450 N1450 0 1e6
RG1451 N1451 0 1e6
RG1452 N1452 0 1e6
RG1453 N1453 0 1e6
RG1454 N1454 0 1e6
RG1455 N1455 0 1e6
RG1456 N1456 0 1e6
RG1457 N1457 0 1e6
RG1458 N1458 0 1e6
RG1459 N1459 0 1e6
RG1460 N1460 0 1e6
RG1461 N1461 0 1e6
RG1462 N1462 0 1e6
RG1463 N1463 0 1e6
RG1464 N1464 0 1e6
RG1465 N1465 0 1e6
RG1466 N1466 0 1e6
RG1467 N1467 0 1e6
RG1468 N1468 0 1e6
RG1469 N1469 0 1e6
RG1470 N1470 0 1e6
RG1471 N1471 0 1e6
RG1472 N1472 0 1e6
RG1473 N1473 0 1e6
RG1474 N1474 0 1e6
RG1475 N1475 0 1e6
RG1476 N1476 0 1e6
RG1477 N1477 0 1e6
RG1478 N1478 0 1e6
RG1479 N1479 0 1e6
RG1480 N1480 0 1e6
RG1481 N1481 0 1e6
RG1482 N1482 0 1e6
RG1483 N1483 0 1e6
RG1484 N1484 0 1e6
RG1485 N1485 0 1e6
RG1486 N1486 0 1e6
RG1487 N1487 0 1e6
RG1488 N1488 0 1e6
RG1489 N1489 0 1e6
RG1490 N1490 0 1e6
RG1491 N1491 0 1e6
RG1492 N1492 0 1e6
RG1493 N1493 0 1e6
RG1494 N1494 0 1e6
RG1495 N1495 0 1e6
RG1496 N1496 0 1e6
RG1497 N1497 0 1e6
RG1498 N1498 0 1e6
RG1499 N1499 0 1e6
RG1500 N1500 0 1e6
RG1501 N1501 0 1e6
RG1502 N1502 0 1e6
RG1503 N1503 0 1e6
RG1504 N1504 0 1e6
RG1505 N1505 0 1e6
RG1506 N1506 0 1e6
RG1507 N1507 0 1e6
RG1508 N1508 0 1e6
RG1509 N1509 0 1e6
RG1510 N1510 0 1e6
RG1511 N1511 0 1e6
RG1512 N1512 0 1e6
RG1513 N1513 0 1e6
RG1514 N1514 0 1e6
RG1515 N1515 0 1e6
RG1516 N1516 0 1e6
RG1517 N1517 0 1e6
RG1518 N1518 0 1e6
RG1519 N1519 0 1e6
RG1520 N1520 0 1e6
RG1521 N1521 0 1e6
RG1522 N1522 0 1e6
RG1523 N1523 0 1e6
RG1524 N1524 0 1e6
RG1525 N1525 0 1e6
RG1526 N1526 0 1e6
RG1527 N1527 0 1e6
RG1528 N1528 0 1e6
RG1529 N1529 0 1e6
RG1530 N1530 0 1e6
RG1531 N1531 0 1e6
RG1532 N1532 0 1e6
RG1533 N1533 0 1e6
RG1534 N1534 0 1e6
RG1535 N1535 0 1e6
RG1536 N1536 0 1e6
RG1537 N1537 0 1e6
RG1538 N1538 0 1e6
RG1539 N1539 0 1e6
RG1540 N1540 0 1e6
RG1541 N1541 0 1e6
RG1542 N1542 0 1e6
RG1543 N1543 0 1e6
RG1544 N1544 0 1e6
RG1545 N1545 0 1e6
RG1546 N1546 0 1e6
RG1547 N1547 0 1e6
RG1548 N1548 0 1e6
RG1549 N1549 0 1e6
RG1550 N1550 0 1e6
RG1551 N1551 0 1e6
RG1552 N1552 0 1e6
RG1553 N1553 0 1e6
RG1554 N1554 0 1e6
RG1555 N1555 0 1e6
RG1556 N1556 0 1e6
RG1557 N1557 0 1e6
RG1558 N1558 0 1e6
RG1559 N1559 0 1e6
RG1560 N1560 0 1e6
RG1561 N1561 0 1e6
RG1562 N1562 0 1e6
RG1563 N1563 0 1e6
RG1564 N1564 0 1e6
RG1565 N1565 0 1e6
RG1566 N1566 0 1e6
RG1567 N1567 0 1e6
RG1568 N1568 0 1e6
RG1569 N1569 0 1e6
RG1570 N1570 0 1e6
RG1571 N1571 0 1e6
RG1572 N1572 0 1e6
RG1573 N1573 0 1e6
RG1574 N1574 0 1e6
RG1575 N1575 0 1e6
RG1576 N1576 0 1e6
RG1577 N1577 0 1e6
RG1578 N1578 0 1e6
RG1579 N1579 0 1e6
RG1580 N1580 0 1e6
RG1581 N1581 0 1e6
RG1582 N1582 0 1e6
RG1583 N1583 0 1e6
RG1584 N1584 0 1e6
RG1585 N1585 0 1e6
RG1586 N1586 0 1e6
RG1587 N1587 0 1e6
RG1588 N1588 0 1e6
RG1589 N1589 0 1e6
RG1590 N1590 0 1e6
RG1591 N1591 0 1e6
RG1592 N1592 0 1e6
RG1593 N1593 0 1e6
RG1594 N1594 0 1e6
RG1595 N1595 0 1e6
RG1596 N1596 0 1e6
RG1597 N1597 0 1e6
RG1598 N1598 0 1e6
RG1599 N1599 0 1e6
RG1600 N1600 0 1e6
RG1601 N1601 0 1e6
RG1602 N1602 0 1e6
RG1603 N1603 0 1e6
RG1604 N1604 0 1e6
RG1605 N1605 0 1e6
RG1606 N1606 0 1e6
RG1607 N1607 0 1e6
RG1608 N1608 0 1e6
RG1609 N1609 0 1e6
RG1610 N1610 0 1e6
RG1611 N1611 0 1e6
RG1612 N1612 0 1e6
RG1613 N1613 0 1e6
RG1614 N1614 0 1e6
RG1615 N1615 0 1e6
RG1616 N1616 0 1e6
RG1617 N1617 0 1e6
RG1618 N1618 0 1e6
RG1619 N1619 0 1e6
RG1620 N1620 0 1e6
RG1621 N1621 0 1e6
RG1622 N1622 0 1e6
RG1623 N1623 0 1e6
RG1624 N1624 0 1e6
RG1625 N1625 0 1e6
RG1626 N1626 0 1e6
RG1627 N1627 0 1e6
RG1628 N1628 0 1e6
RG1629 N1629 0 1e6
RG1630 N1630 0 1e6
RG1631 N1631 0 1e6
RG1632 N1632 0 1e6
RG1633 N1633 0 1e6
RG1634 N1634 0 1e6
RG1635 N1635 0 1e6
RG1636 N1636 0 1e6
RG1637 N1637 0 1e6
RG1638 N1638 0 1e6
RG1639 N1639 0 1e6
RG1640 N1640 0 1e6
RG1641 N1641 0 1e6
RG1642 N1642 0 1e6
RG1643 N1643 0 1e6
RG1644 N1644 0 1e6
RG1645 N1645 0 1e6
RG1646 N1646 0 1e6
RG1647 N1647 0 1e6
RG1648 N1648 0 1e6
RG1649 N1649 0 1e6
RG1650 N1650 0 1e6
RG1651 N1651 0 1e6
RG1652 N1652 0 1e6
RG1653 N1653 0 1e6
RG1654 N1654 0 1e6
RG1655 N1655 0 1e6
RG1656 N1656 0 1e6
RG1657 N1657 0 1e6
RG1658 N1658 0 1e6
RG1659 N1659 0 1e6
RG1660 N1660 0 1e6
RG1661 N1661 0 1e6
RG1662 N1662 0 1e6
RG1663 N1663 0 1e6
RG1664 N1664 0 1e6
RG1665 N1665 0 1e6
RG1666 N1666 0 1e6
RG1667 N1667 0 1e6
RG1668 N1668 0 1e6
RG1669 N1669 0 1e6
RG1670 N1670 0 1e6
RG1671 N1671 0 1e6
RG1672 N1672 0 1e6
RG1673 N1673 0 1e6
RG1674 N1674 0 1e6
RG1675 N1675 0 1e6
RG1676 N1676 0 1e6
RG1677 N1677 0 1e6
RG1678 N1678 0 1e6
RG1679 N1679 0 1e6
RG1680 N1680 0 1e6
RG1681 N1681 0 1e6
RG1682 N1682 0 1e6
RG1683 N1683 0 1e6
RG1684 N1684 0 1e6
RG1685 N1685 0 1e6
RG1686 N1686 0 1e6
RG1687 N1687 0 1e6
RG1688 N1688 0 1e6
RG1689 N1689 0 1e6
RG1690 N1690 0 1e6
RG1691 N1691 0 1e6
RG1692 N1692 0 1e6
RG1693 N1693 0 1e6
RG1694 N1694 0 1e6
RG1695 N1695 0 1e6
RG1696 N1696 0 1e6
RG1697 N1697 0 1e6
RG1698 N1698 0 1e6
RG1699 N1699 0 1e6
RG1700 N1700 0 1e6
RG1701 N1701 0 1e6
RG1702 N1702 0 1e6
RG1703 N1703 0 1e6
RG1704 N1704 0 1e6
RG1705 N1705 0 1e6
RG1706 N1706 0 1e6
RG1707 N1707 0 1e6
RG1708 N1708 0 1e6
RG1709 N1709 0 1e6
RG1710 N1710 0 1e6
RG1711 N1711 0 1e6
RG1712 N1712 0 1e6
RG1713 N1713 0 1e6
RG1714 N1714 0 1e6
RG1715 N1715 0 1e6
RG1716 N1716 0 1e6
RG1717 N1717 0 1e6
RG1718 N1718 0 1e6
RG1719 N1719 0 1e6
RG1720 N1720 0 1e6
RG1721 N1721 0 1e6
RG1722 N1722 0 1e6
RG1723 N1723 0 1e6
RG1724 N1724 0 1e6
RG1725 N1725 0 1e6
RG1726 N1726 0 1e6
RG1727 N1727 0 1e6
RG1728 N1728 0 1e6
RG1729 N1729 0 1e6
RG1730 N1730 0 1e6
RG1731 N1731 0 1e6
RG1732 N1732 0 1e6
RG1733 N1733 0 1e6
RG1734 N1734 0 1e6
RG1735 N1735 0 1e6
RG1736 N1736 0 1e6
RG1737 N1737 0 1e6
RG1738 N1738 0 1e6
RG1739 N1739 0 1e6
RG1740 N1740 0 1e6
RG1741 N1741 0 1e6
RG1742 N1742 0 1e6
RG1743 N1743 0 1e6
RG1744 N1744 0 1e6
RG1745 N1745 0 1e6
RG1746 N1746 0 1e6
RG1747 N1747 0 1e6
RG1748 N1748 0 1e6
RG1749 N1749 0 1e6
RG1750 N1750 0 1e6
RG1751 N1751 0 1e6
RG1752 N1752 0 1e6
RG1753 N1753 0 1e6
RG1754 N1754 0 1e6
RG1755 N1755 0 1e6
RG1756 N1756 0 1e6
RG1757 N1757 0 1e6
RG1758 N1758 0 1e6
RG1759 N1759 0 1e6
RG1760 N1760 0 1e6
RG1761 N1761 0 1e6
RG1762 N1762 0 1e6
RG1763 N1763 0 1e6
RG1764 N1764 0 1e6
RG1765 N1765 0 1e6
RG1766 N1766 0 1e6
RG1767 N1767 0 1e6
RG1768 N1768 0 1e6
RG1769 N1769 0 1e6
RG1770 N1770 0 1e6
RG1771 N1771 0 1e6
RG1772 N1772 0 1e6
RG1773 N1773 0 1e6
RG1774 N1774 0 1e6
RG1775 N1775 0 1e6
RG1776 N1776 0 1e6
RG1777 N1777 0 1e6
RG1778 N1778 0 1e6
RG1779 N1779 0 1e6
RG1780 N1780 0 1e6
RG1781 N1781 0 1e6
RG1782 N1782 0 1e6
RG1783 N1783 0 1e6
RG1784 N1784 0 1e6
RG1785 N1785 0 1e6
RG1786 N1786 0 1e6
RG1787 N1787 0 1e6
RG1788 N1788 0 1e6
RG1789 N1789 0 1e6
RG1790 N1790 0 1e6
RG1791 N1791 0 1e6
RG1792 N1792 0 1e6
RG1793 N1793 0 1e6
RG1794 N1794 0 1e6
RG1795 N1795 0 1e6
RG1796 N1796 0 1e6
RG1797 N1797 0 1e6
RG1798 N1798 0 1e6
RG1799 N1799 0 1e6
RG1800 N1800 0 1e6
RG1801 N1801 0 1e6
RG1802 N1802 0 1e6
RG1803 N1803 0 1e6
RG1804 N1804 0 1e6
RG1805 N1805 0 1e6
RG1806 N1806 0 1e6
RG1807 N1807 0 1e6
RG1808 N1808 0 1e6
RG1809 N1809 0 1e6
RG1810 N1810 0 1e6
RG1811 N1811 0 1e6
RG1812 N1812 0 1e6
RG1813 N1813 0 1e6
RG1814 N1814 0 1e6
RG1815 N1815 0 1e6
RG1816 N1816 0 1e6
RG1817 N1817 0 1e6
RG1818 N1818 0 1e6
RG1819 N1819 0 1e6
RG1820 N1820 0 1e6
RG1821 N1821 0 1e6
RG1822 N1822 0 1e6
RG1823 N1823 0 1e6
RG1824 N1824 0 1e6
RG1825 N1825 0 1e6
RG1826 N1826 0 1e6
RG1827 N1827 0 1e6
RG1828 N1828 0 1e6
RG1829 N1829 0 1e6
RG1830 N1830 0 1e6
RG1831 N1831 0 1e6
RG1832 N1832 0 1e6
RG1833 N1833 0 1e6
RG1834 N1834 0 1e6
RG1835 N1835 0 1e6
RG1836 N1836 0 1e6
RG1837 N1837 0 1e6
RG1838 N1838 0 1e6
RG1839 N1839 0 1e6
RG1840 N1840 0 1e6
RG1841 N1841 0 1e6
RG1842 N1842 0 1e6
RG1843 N1843 0 1e6
RG1844 N1844 0 1e6
RG1845 N1845 0 1e6
RG1846 N1846 0 1e6
RG1847 N1847 0 1e6
RG1848 N1848 0 1e6
RG1849 N1849 0 1e6
RG1850 N1850 0 1e6
RG1851 N1851 0 1e6
RG1852 N1852 0 1e6
RG1853 N1853 0 1e6
RG1854 N1854 0 1e6
RG1855 N1855 0 1e6
RG1856 N1856 0 1e6
RG1857 N1857 0 1e6
RG1858 N1858 0 1e6
RG1859 N1859 0 1e6
RG1860 N1860 0 1e6
RG1861 N1861 0 1e6
RG1862 N1862 0 1e6
RG1863 N1863 0 1e6
RG1864 N1864 0 1e6
RG1865 N1865 0 1e6
RG1866 N1866 0 1e6
RG1867 N1867 0 1e6
RG1868 N1868 0 1e6
RG1869 N1869 0 1e6
RG1870 N1870 0 1e6
RG1871 N1871 0 1e6
RG1872 N1872 0 1e6
RG1873 N1873 0 1e6
RG1874 N1874 0 1e6
RG1875 N1875 0 1e6
RG1876 N1876 0 1e6
RG1877 N1877 0 1e6
RG1878 N1878 0 1e6
RG1879 N1879 0 1e6
RG1880 N1880 0 1e6
RG1881 N1881 0 1e6
RG1882 N1882 0 1e6
RG1883 N1883 0 1e6
RG1884 N1884 0 1e6
RG1885 N1885 0 1e6
RG1886 N1886 0 1e6
RG1887 N1887 0 1e6
RG1888 N1888 0 1e6
RG1889 N1889 0 1e6
RG1890 N1890 0 1e6
RG1891 N1891 0 1e6
RG1892 N1892 0 1e6
RG1893 N1893 0 1e6
RG1894 N1894 0 1e6
RG1895 N1895 0 1e6
RG1896 N1896 0 1e6
RG1897 N1897 0 1e6
RG1898 N1898 0 1e6
RG1899 N1899 0 1e6
RG1900 N1900 0 1e6
RG1901 N1901 0 1e6
RG1902 N1902 0 1e6
RG1903 N1903 0 1e6
RG1904 N1904 0 1e6
RG1905 N1905 0 1e6
RG1906 N1906 0 1e6
RG1907 N1907 0 1e6
RG1908 N1908 0 1e6
RG1909 N1909 0 1e6
RG1910 N1910 0 1e6
RG1911 N1911 0 1e6
RG1912 N1912 0 1e6
RG1913 N1913 0 1e6
RG1914 N1914 0 1e6
RG1915 N1915 0 1e6
RG1916 N1916 0 1e6
RG1917 N1917 0 1e6
RG1918 N1918 0 1e6
RG1919 N1919 0 1e6
RG1920 N1920 0 1e6
RG1921 N1921 0 1e6
RG1922 N1922 0 1e6
RG1923 N1923 0 1e6
RG1924 N1924 0 1e6
RG1925 N1925 0 1e6
RG1926 N1926 0 1e6
RG1927 N1927 0 1e6
RG1928 N1928 0 1e6
RG1929 N1929 0 1e6
RG1930 N1930 0 1e6
RG1931 N1931 0 1e6
RG1932 N1932 0 1e6
RG1933 N1933 0 1e6
RG1934 N1934 0 1e6
RG1935 N1935 0 1e6
RG1936 N1936 0 1e6
RG1937 N1937 0 1e6
RG1938 N1938 0 1e6
RG1939 N1939 0 1e6
RG1940 N1940 0 1e6
RG1941 N1941 0 1e6
RG1942 N1942 0 1e6
RG1943 N1943 0 1e6
RG1944 N1944 0 1e6
RG1945 N1945 0 1e6
RG1946 N1946 0 1e6
RG1947 N1947 0 1e6
RG1948 N1948 0 1e6
RG1949 N1949 0 1e6
RG1950 N1950 0 1e6
RG1951 N1951 0 1e6
RG1952 N1952 0 1e6
RG1953 N1953 0 1e6
RG1954 N1954 0 1e6
RG1955 N1955 0 1e6
RG1956 N1956 0 1e6
RG1957 N1957 0 1e6
RG1958 N1958 0 1e6
RG1959 N1959 0 1e6
RG1960 N1960 0 1e6
RG1961 N1961 0 1e6
RG1962 N1962 0 1e6
RG1963 N1963 0 1e6
RG1964 N1964 0 1e6
RG1965 N1965 0 1e6
RG1966 N1966 0 1e6
RG1967 N1967 0 1e6
RG1968 N1968 0 1e6
RG1969 N1969 0 1e6
RG1970 N1970 0 1e6
RG1971 N1971 0 1e6
RG1972 N1972 0 1e6
RG1973 N1973 0 1e6
RG1974 N1974 0 1e6
RG1975 N1975 0 1e6
RG1976 N1976 0 1e6
RG1977 N1977 0 1e6
RG1978 N1978 0 1e6
RG1979 N1979 0 1e6
RG1980 N1980 0 1e6
RG1981 N1981 0 1e6
RG1982 N1982 0 1e6
RG1983 N1983 0 1e6
RG1984 N1984 0 1e6
RG1985 N1985 0 1e6
RG1986 N1986 0 1e6
RG1987 N1987 0 1e6
RG1988 N1988 0 1e6
RG1989 N1989 0 1e6
RG1990 N1990 0 1e6
RG1991 N1991 0 1e6
RG1992 N1992 0 1e6
RG1993 N1993 0 1e6
RG1994 N1994 0 1e6
RG1995 N1995 0 1e6
RG1996 N1996 0 1e6
RG1997 N1997 0 1e6
RG1998 N1998 0 1e6
RG1999 N1999 0 1e6
RG2000 N2000 0 1e6
RG2001 N2001 0 1e6
RG2002 N2002 0 1e6
RG2003 N2003 0 1e6
RG2004 N2004 0 1e6
RG2005 N2005 0 1e6
RG2006 N2006 0 1e6
RG2007 N2007 0 1e6
RG2008 N2008 0 1e6
RG2009 N2009 0 1e6
RG2010 N2010 0 1e6
RG2011 N2011 0 1e6
RG2012 N2012 0 1e6
RG2013 N2013 0 1e6
RG2014 N2014 0 1e6
RG2015 N2015 0 1e6
RG2016 N2016 0 1e6
RG2017 N2017 0 1e6
RG2018 N2018 0 1e6
RG2019 N2019 0 1e6
RG2020 N2020 0 1e6
RG2021 N2021 0 1e6
RG2022 N2022 0 1e6
RG2023 N2023 0 1e6
RG2024 N2024 0 1e6
RG2025 N2025 0 1e6
RG2026 N2026 0 1e6
RG2027 N2027 0 1e6
RG2028 N2028 0 1e6
RG2029 N2029 0 1e6
RG2030 N2030 0 1e6
RG2031 N2031 0 1e6
RG2032 N2032 0 1e6
RG2033 N2033 0 1e6
RG2034 N2034 0 1e6
RG2035 N2035 0 1e6
RG2036 N2036 0 1e6
RG2037 N2037 0 1e6
RG2038 N2038 0 1e6
RG2039 N2039 0 1e6
RG2040 N2040 0 1e6
RG2041 N2041 0 1e6
RG2042 N2042 0 1e6
RG2043 N2043 0 1e6
RG2044 N2044 0 1e6
RG2045 N2045 0 1e6
RG2046 N2046 0 1e6
RG2047 N2047 0 1e6
RG2048 N2048 0 1e6
RG2049 N2049 0 1e6
RG2050 N2050 0 1e6
RG2051 N2051 0 1e6
RG2052 N2052 0 1e6
RG2053 N2053 0 1e6
RG2054 N2054 0 1e6
RG2055 N2055 0 1e6
RG2056 N2056 0 1e6
RG2057 N2057 0 1e6
RG2058 N2058 0 1e6
RG2059 N2059 0 1e6
RG2060 N2060 0 1e6
RG2061 N2061 0 1e6
RG2062 N2062 0 1e6
RG2063 N2063 0 1e6
RG2064 N2064 0 1e6
RG2065 N2065 0 1e6
RG2066 N2066 0 1e6
RG2067 N2067 0 1e6
RG2068 N2068 0 1e6
RG2069 N2069 0 1e6
RG2070 N2070 0 1e6
RG2071 N2071 0 1e6
RG2072 N2072 0 1e6
RG2073 N2073 0 1e6
RG2074 N2074 0 1e6
RG2075 N2075 0 1e6
RG2076 N2076 0 1e6
RG2077 N2077 0 1e6
RG2078 N2078 0 1e6
RG2079 N2079 0 1e6
RG2080 N2080 0 1e6
RG2081 N2081 0 1e6
RG2082 N2082 0 1e6
RG2083 N2083 0 1e6
RG2084 N2084 0 1e6
RG2085 N2085 0 1e6
RG2086 N2086 0 1e6
RG2087 N2087 0 1e6
RG2088 N2088 0 1e6
RG2089 N2089 0 1e6
RG2090 N2090 0 1e6
RG2091 N2091 0 1e6
RG2092 N2092 0 1e6
RG2093 N2093 0 1e6
RG2094 N2094 0 1e6
RG2095 N2095 0 1e6
RG2096 N2096 0 1e6
RG2097 N2097 0 1e6
RG2098 N2098 0 1e6
RG2099 N2099 0 1e6
RG2100 N2100 0 1e6
RG2101 N2101 0 1e6
RG2102 N2102 0 1e6
RG2103 N2103 0 1e6
RG2104 N2104 0 1e6
RG2105 N2105 0 1e6
RG2106 N2106 0 1e6
RG2107 N2107 0 1e6
RG2108 N2108 0 1e6
RG2109 N2109 0 1e6
RG2110 N2110 0 1e6
RG2111 N2111 0 1e6
RG2112 N2112 0 1e6
RG2113 N2113 0 1e6
RG2114 N2114 0 1e6
RG2115 N2115 0 1e6
RG2116 N2116 0 1e6
RG2117 N2117 0 1e6
RG2118 N2118 0 1e6
RG2119 N2119 0 1e6
RG2120 N2120 0 1e6
RG2121 N2121 0 1e6
RG2122 N2122 0 1e6
RG2123 N2123 0 1e6
RG2124 N2124 0 1e6
RG2125 N2125 0 1e6
RG2126 N2126 0 1e6
RG2127 N2127 0 1e6
RG2128 N2128 0 1e6
RG2129 N2129 0 1e6
RG2130 N2130 0 1e6
RG2131 N2131 0 1e6
RG2132 N2132 0 1e6
RG2133 N2133 0 1e6
RG2134 N2134 0 1e6
RG2135 N2135 0 1e6
RG2136 N2136 0 1e6
RG2137 N2137 0 1e6
RG2138 N2138 0 1e6
RG2139 N2139 0 1e6
RG2140 N2140 0 1e6
RG2141 N2141 0 1e6
RG2142 N2142 0 1e6
RG2143 N2143 0 1e6
RG2144 N2144 0 1e6
RG2145 N2145 0 1e6
RG2146 N2146 0 1e6
RG2147 N2147 0 1e6
RG2148 N2148 0 1e6
RG2149 N2149 0 1e6
RG2150 N2150 0 1e6
RG2151 N2151 0 1e6
RG2152 N2152 0 1e6
RG2153 N2153 0 1e6
RG2154 N2154 0 1e6
RG2155 N2155 0 1e6
RG2156 N2156 0 1e6
RG2157 N2157 0 1e6
RG2158 N2158 0 1e6
RG2159 N2159 0 1e6
RG2160 N2160 0 1e6
RG2161 N2161 0 1e6
RG2162 N2162 0 1e6
RG2163 N2163 0 1e6
RG2164 N2164 0 1e6
RG2165 N2165 0 1e6
RG2166 N2166 0 1e6
RG2167 N2167 0 1e6
RG2168 N2168 0 1e6
RG2169 N2169 0 1e6
RG2170 N2170 0 1e6
RG2171 N2171 0 1e6
RG2172 N2172 0 1e6
RG2173 N2173 0 1e6
RG2174 N2174 0 1e6
RG2175 N2175 0 1e6
RG2176 N2176 0 1e6
RG2177 N2177 0 1e6
RG2178 N2178 0 1e6
RG2179 N2179 0 1e6
RG2180 N2180 0 1e6
RG2181 N2181 0 1e6
RG2182 N2182 0 1e6
RG2183 N2183 0 1e6
RG2184 N2184 0 1e6
RG2185 N2185 0 1e6
RG2186 N2186 0 1e6
RG2187 N2187 0 1e6
RG2188 N2188 0 1e6
RG2189 N2189 0 1e6
RG2190 N2190 0 1e6
RG2191 N2191 0 1e6
RG2192 N2192 0 1e6
RG2193 N2193 0 1e6
RG2194 N2194 0 1e6
RG2195 N2195 0 1e6
RG2196 N2196 0 1e6
RG2197 N2197 0 1e6
RG2198 N2198 0 1e6
RG2199 N2199 0 1e6
RG2200 N2200 0 1e6
RG2201 N2201 0 1e6
RG2202 N2202 0 1e6
RG2203 N2203 0 1e6
RG2204 N2204 0 1e6
RG2205 N2205 0 1e6
RG2206 N2206 0 1e6
RG2207 N2207 0 1e6
RG2208 N2208 0 1e6
RG2209 N2209 0 1e6
RG2210 N2210 0 1e6
RG2211 N2211 0 1e6
RG2212 N2212 0 1e6
RG2213 N2213 0 1e6
RG2214 N2214 0 1e6
RG2215 N2215 0 1e6
RG2216 N2216 0 1e6
RG2217 N2217 0 1e6
RG2218 N2218 0 1e6
RG2219 N2219 0 1e6
RG2220 N2220 0 1e6
RG2221 N2221 0 1e6
RG2222 N2222 0 1e6
RG2223 N2223 0 1e6
RG2224 N2224 0 1e6
RG2225 N2225 0 1e6
RG2226 N2226 0 1e6
RG2227 N2227 0 1e6
RG2228 N2228 0 1e6
RG2229 N2229 0 1e6
RG2230 N2230 0 1e6
RG2231 N2231 0 1e6
RG2232 N2232 0 1e6
RG2233 N2233 0 1e6
RG2234 N2234 0 1e6
RG2235 N2235 0 1e6
RG2236 N2236 0 1e6
RG2237 N2237 0 1e6
RG2238 N2238 0 1e6
RG2239 N2239 0 1e6
RG2240 N2240 0 1e6
RG2241 N2241 0 1e6
RG2242 N2242 0 1e6
RG2243 N2243 0 1e6
RG2244 N2244 0 1e6
RG2245 N2245 0 1e6
RG2246 N2246 0 1e6
RG2247 N2247 0 1e6
RG2248 N2248 0 1e6
RG2249 N2249 0 1e6
RG2250 N2250 0 1e6
RG2251 N2251 0 1e6
RG2252 N2252 0 1e6
RG2253 N2253 0 1e6
RG2254 N2254 0 1e6
RG2255 N2255 0 1e6
RG2256 N2256 0 1e6
RG2257 N2257 0 1e6
RG2258 N2258 0 1e6
RG2259 N2259 0 1e6
RG2260 N2260 0 1e6
RG2261 N2261 0 1e6
RG2262 N2262 0 1e6
RG2263 N2263 0 1e6
RG2264 N2264 0 1e6
RG2265 N2265 0 1e6
RG2266 N2266 0 1e6
RG2267 N2267 0 1e6
RG2268 N2268 0 1e6
RG2269 N2269 0 1e6
RG2270 N2270 0 1e6
RG2271 N2271 0 1e6
RG2272 N2272 0 1e6
RG2273 N2273 0 1e6
RG2274 N2274 0 1e6
RG2275 N2275 0 1e6
RG2276 N2276 0 1e6
RG2277 N2277 0 1e6
RG2278 N2278 0 1e6
RG2279 N2279 0 1e6
RG2280 N2280 0 1e6
RG2281 N2281 0 1e6
RG2282 N2282 0 1e6
RG2283 N2283 0 1e6
RG2284 N2284 0 1e6
RG2285 N2285 0 1e6
RG2286 N2286 0 1e6
RG2287 N2287 0 1e6
RG2288 N2288 0 1e6
RG2289 N2289 0 1e6
RG2290 N2290 0 1e6
RG2291 N2291 0 1e6
RG2292 N2292 0 1e6
RG2293 N2293 0 1e6
RG2294 N2294 0 1e6
RG2295 N2295 0 1e6
RG2296 N2296 0 1e6
RG2297 N2297 0 1e6
RG2298 N2298 0 1e6
RG2299 N2299 0 1e6
RG2300 N2300 0 1e6
RG2301 N2301 0 1e6
RG2302 N2302 0 1e6
RG2303 N2303 0 1e6
RG2304 N2304 0 1e6
RG2305 N2305 0 1e6
RG2306 N2306 0 1e6
RG2307 N2307 0 1e6
RG2308 N2308 0 1e6
RG2309 N2309 0 1e6
RG2310 N2310 0 1e6
RG2311 N2311 0 1e6
RG2312 N2312 0 1e6
RG2313 N2313 0 1e6
RG2314 N2314 0 1e6
RG2315 N2315 0 1e6
RG2316 N2316 0 1e6
RG2317 N2317 0 1e6
RG2318 N2318 0 1e6
RG2319 N2319 0 1e6
RG2320 N2320 0 1e6
RG2321 N2321 0 1e6
RG2322 N2322 0 1e6
RG2323 N2323 0 1e6
RG2324 N2324 0 1e6
RG2325 N2325 0 1e6
RG2326 N2326 0 1e6
RG2327 N2327 0 1e6
RG2328 N2328 0 1e6
RG2329 N2329 0 1e6
RG2330 N2330 0 1e6
RG2331 N2331 0 1e6
RG2332 N2332 0 1e6
RG2333 N2333 0 1e6
RG2334 N2334 0 1e6
RG2335 N2335 0 1e6
RG2336 N2336 0 1e6
RG2337 N2337 0 1e6
RG2338 N2338 0 1e6
RG2339 N2339 0 1e6
RG2340 N2340 0 1e6
RG2341 N2341 0 1e6
RG2342 N2342 0 1e6
RG2343 N2343 0 1e6
RG2344 N2344 0 1e6
RG2345 N2345 0 1e6
RG2346 N2346 0 1e6
RG2347 N2347 0 1e6
RG2348 N2348 0 1e6
RG2349 N2349 0 1e6
RG2350 N2350 0 1e6
RG2351 N2351 0 1e6
RG2352 N2352 0 1e6
RG2353 N2353 0 1e6
RG2354 N2354 0 1e6
RG2355 N2355 0 1e6
RG2356 N2356 0 1e6
RG2357 N2357 0 1e6
RG2358 N2358 0 1e6
RG2359 N2359 0 1e6
RG2360 N2360 0 1e6
RG2361 N2361 0 1e6
RG2362 N2362 0 1e6
RG2363 N2363 0 1e6
RG2364 N2364 0 1e6
RG2365 N2365 0 1e6
RG2366 N2366 0 1e6
RG2367 N2367 0 1e6
RG2368 N2368 0 1e6
RG2369 N2369 0 1e6
RG2370 N2370 0 1e6
RG2371 N2371 0 1e6
RG2372 N2372 0 1e6
RG2373 N2373 0 1e6
RG2374 N2374 0 1e6
RG2375 N2375 0 1e6
RG2376 N2376 0 1e6
RG2377 N2377 0 1e6
RG2378 N2378 0 1e6
RG2379 N2379 0 1e6
RG2380 N2380 0 1e6
RG2381 N2381 0 1e6
RG2382 N2382 0 1e6
RG2383 N2383 0 1e6
RG2384 N2384 0 1e6
RG2385 N2385 0 1e6
RG2386 N2386 0 1e6
RG2387 N2387 0 1e6
RG2388 N2388 0 1e6
RG2389 N2389 0 1e6
RG2390 N2390 0 1e6
RG2391 N2391 0 1e6
RG2392 N2392 0 1e6
RG2393 N2393 0 1e6
RG2394 N2394 0 1e6
RG2395 N2395 0 1e6
RG2396 N2396 0 1e6
RG2397 N2397 0 1e6
RG2398 N2398 0 1e6
RG2399 N2399 0 1e6
RG2400 N2400 0 1e6
RG2401 N2401 0 1e6
RG2402 N2402 0 1e6
RG2403 N2403 0 1e6
RG2404 N2404 0 1e6
RG2405 N2405 0 1e6
RG2406 N2406 0 1e6
RG2407 N2407 0 1e6
RG2408 N2408 0 1e6
RG2409 N2409 0 1e6
RG2410 N2410 0 1e6
RG2411 N2411 0 1e6
RG2412 N2412 0 1e6
RG2413 N2413 0 1e6
RG2414 N2414 0 1e6
RG2415 N2415 0 1e6
RG2416 N2416 0 1e6
RG2417 N2417 0 1e6
RG2418 N2418 0 1e6
RG2419 N2419 0 1e6
RG2420 N2420 0 1e6
RG2421 N2421 0 1e6
RG2422 N2422 0 1e6
RG2423 N2423 0 1e6
RG2424 N2424 0 1e6
RG2425 N2425 0 1e6
RG2426 N2426 0 1e6
RG2427 N2427 0 1e6
RG2428 N2428 0 1e6
RG2429 N2429 0 1e6
RG2430 N2430 0 1e6
RG2431 N2431 0 1e6
RG2432 N2432 0 1e6
RG2433 N2433 0 1e6
RG2434 N2434 0 1e6
RG2435 N2435 0 1e6
RG2436 N2436 0 1e6
RG2437 N2437 0 1e6
RG2438 N2438 0 1e6
RG2439 N2439 0 1e6
RG2440 N2440 0 1e6
RG2441 N2441 0 1e6
RG2442 N2442 0 1e6
RG2443 N2443 0 1e6
RG2444 N2444 0 1e6
RG2445 N2445 0 1e6
RG2446 N2446 0 1e6
RG2447 N2447 0 1e6
RG2448 N2448 0 1e6
RG2449 N2449 0 1e6
RG2450 N2450 0 1e6
RG2451 N2451 0 1e6
RG2452 N2452 0 1e6
RG2453 N2453 0 1e6
RG2454 N2454 0 1e6
RG2455 N2455 0 1e6
RG2456 N2456 0 1e6
RG2457 N2457 0 1e6
RG2458 N2458 0 1e6
RG2459 N2459 0 1e6
RG2460 N2460 0 1e6
RG2461 N2461 0 1e6
RG2462 N2462 0 1e6
RG2463 N2463 0 1e6
RG2464 N2464 0 1e6
RG2465 N2465 0 1e6
RG2466 N2466 0 1e6
RG2467 N2467 0 1e6
RG2468 N2468 0 1e6
RG2469 N2469 0 1e6
RG2470 N2470 0 1e6
RG2471 N2471 0 1e6
RG2472 N2472 0 1e6
RG2473 N2473 0 1e6
RG2474 N2474 0 1e6
RG2475 N2475 0 1e6
RG2476 N2476 0 1e6
RG2477 N2477 0 1e6
RG2478 N2478 0 1e6
RG2479 N2479 0 1e6
RG2480 N2480 0 1e6
RG2481 N2481 0 1e6
RG2482 N2482 0 1e6
RG2483 N2483 0 1e6
RG2484 N2484 0 1e6
RG2485 N2485 0 1e6
RG2486 N2486 0 1e6
RG2487 N2487 0 1e6
RG2488 N2488 0 1e6
RG2489 N2489 0 1e6
RG2490 N2490 0 1e6
RG2491 N2491 0 1e6
RG2492 N2492 0 1e6
RG2493 N2493 0 1e6
RG2494 N2494 0 1e6
RG2495 N2495 0 1e6
RG2496 N2496 0 1e6
RG2497 N2497 0 1e6
RG2498 N2498 0 1e6
RG2499 N2499 0 1e6
RG2500 N2500 0 1e6
RG2501 N2501 0 1e6
RG2502 N2502 0 1e6
RG2503 N2503 0 1e6
RG2504 N2504 0 1e6
RG2505 N2505 0 1e6
RG2506 N2506 0 1e6
RG2507 N2507 0 1e6
RG2508 N2508 0 1e6
RG2509 N2509 0 1e6
RG2510 N2510 0 1e6
RG2511 N2511 0 1e6
RG2512 N2512 0 1e6
RG2513 N2513 0 1e6
RG2514 N2514 0 1e6
RG2515 N2515 0 1e6
RG2516 N2516 0 1e6
RG2517 N2517 0 1e6
RG2518 N2518 0 1e6
RG2519 N2519 0 1e6
RG2520 N2520 0 1e6
RG2521 N2521 0 1e6
RG2522 N2522 0 1e6
RG2523 N2523 0 1e6
RG2524 N2524 0 1e6
RG2525 N2525 0 1e6
RG2526 N2526 0 1e6
RG2527 N2527 0 1e6
RG2528 N2528 0 1e6
RG2529 N2529 0 1e6
RG2530 N2530 0 1e6
RG2531 N2531 0 1e6
RG2532 N2532 0 1e6
RG2533 N2533 0 1e6
RG2534 N2534 0 1e6
RG2535 N2535 0 1e6
RG2536 N2536 0 1e6
RG2537 N2537 0 1e6
RG2538 N2538 0 1e6
RG2539 N2539 0 1e6
RG2540 N2540 0 1e6
RG2541 N2541 0 1e6
RG2542 N2542 0 1e6
RG2543 N2543 0 1e6
RG2544 N2544 0 1e6
RG2545 N2545 0 1e6
RG2546 N2546 0 1e6
RG2547 N2547 0 1e6
RG2548 N2548 0 1e6
RG2549 N2549 0 1e6
RG2550 N2550 0 1e6
RG2551 N2551 0 1e6
RG2552 N2552 0 1e6
RG2553 N2553 0 1e6
RG2554 N2554 0 1e6
RG2555 N2555 0 1e6
RG2556 N2556 0 1e6
RG2557 N2557 0 1e6
RG2558 N2558 0 1e6
RG2559 N2559 0 1e6
RG2560 N2560 0 1e6
RG2561 N2561 0 1e6
RG2562 N2562 0 1e6
RG2563 N2563 0 1e6
RG2564 N2564 0 1e6
RG2565 N2565 0 1e6
RG2566 N2566 0 1e6
RG2567 N2567 0 1e6
RG2568 N2568 0 1e6
RG2569 N2569 0 1e6
RG2570 N2570 0 1e6
RG2571 N2571 0 1e6
RG2572 N2572 0 1e6
RG2573 N2573 0 1e6
RG2574 N2574 0 1e6
RG2575 N2575 0 1e6
RG2576 N2576 0 1e6
RG2577 N2577 0 1e6
RG2578 N2578 0 1e6
RG2579 N2579 0 1e6
RG2580 N2580 0 1e6
RG2581 N2581 0 1e6
RG2582 N2582 0 1e6
RG2583 N2583 0 1e6
RG2584 N2584 0 1e6
RG2585 N2585 0 1e6
RG2586 N2586 0 1e6
RG2587 N2587 0 1e6
RG2588 N2588 0 1e6
RG2589 N2589 0 1e6
RG2590 N2590 0 1e6
RG2591 N2591 0 1e6
RG2592 N2592 0 1e6
RG2593 N2593 0 1e6
RG2594 N2594 0 1e6
RG2595 N2595 0 1e6
RG2596 N2596 0 1e6
RG2597 N2597 0 1e6
RG2598 N2598 0 1e6
RG2599 N2599 0 1e6
RG2600 N2600 0 1e6
RG2601 N2601 0 1e6
RG2602 N2602 0 1e6
RG2603 N2603 0 1e6
RG2604 N2604 0 1e6
RG2605 N2605 0 1e6
RG2606 N2606 0 1e6
RG2607 N2607 0 1e6
RG2608 N2608 0 1e6
RG2609 N2609 0 1e6
RG2610 N2610 0 1e6
RG2611 N2611 0 1e6
RG2612 N2612 0 1e6
RG2613 N2613 0 1e6
RG2614 N2614 0 1e6
RG2615 N2615 0 1e6
RG2616 N2616 0 1e6
RG2617 N2617 0 1e6
RG2618 N2618 0 1e6
RG2619 N2619 0 1e6
RG2620 N2620 0 1e6
RG2621 N2621 0 1e6
RG2622 N2622 0 1e6
RG2623 N2623 0 1e6
RG2624 N2624 0 1e6
RG2625 N2625 0 1e6
RG2626 N2626 0 1e6
RG2627 N2627 0 1e6
RG2628 N2628 0 1e6
RG2629 N2629 0 1e6
RG2630 N2630 0 1e6
RG2631 N2631 0 1e6
RG2632 N2632 0 1e6
RG2633 N2633 0 1e6
RG2634 N2634 0 1e6
RG2635 N2635 0 1e6
RG2636 N2636 0 1e6
RG2637 N2637 0 1e6
RG2638 N2638 0 1e6
RG2639 N2639 0 1e6
RG2640 N2640 0 1e6
RG2641 N2641 0 1e6
RG2642 N2642 0 1e6
RG2643 N2643 0 1e6
RG2644 N2644 0 1e6
RG2645 N2645 0 1e6
RG2646 N2646 0 1e6
RG2647 N2647 0 1e6
RG2648 N2648 0 1e6
RG2649 N2649 0 1e6
RG2650 N2650 0 1e6
RG2651 N2651 0 1e6
RG2652 N2652 0 1e6
RG2653 N2653 0 1e6
RG2654 N2654 0 1e6
RG2655 N2655 0 1e6
RG2656 N2656 0 1e6
RG2657 N2657 0 1e6
RG2658 N2658 0 1e6
RG2659 N2659 0 1e6
RG2660 N2660 0 1e6
RG2661 N2661 0 1e6
RG2662 N2662 0 1e6
RG2663 N2663 0 1e6
RG2664 N2664 0 1e6
RG2665 N2665 0 1e6
RG2666 N2666 0 1e6
RG2667 N2667 0 1e6
RG2668 N2668 0 1e6
RG2669 N2669 0 1e6
RG2670 N2670 0 1e6
RG2671 N2671 0 1e6
RG2672 N2672 0 1e6
RG2673 N2673 0 1e6
RG2674 N2674 0 1e6
RG2675 N2675 0 1e6
RG2676 N2676 0 1e6
RG2677 N2677 0 1e6
RG2678 N2678 0 1e6
RG2679 N2679 0 1e6
RG2680 N2680 0 1e6
RG2681 N2681 0 1e6
RG2682 N2682 0 1e6
RG2683 N2683 0 1e6
RG2684 N2684 0 1e6
RG2685 N2685 0 1e6
RG2686 N2686 0 1e6
RG2687 N2687 0 1e6
RG2688 N2688 0 1e6
RG2689 N2689 0 1e6
RG2690 N2690 0 1e6
RG2691 N2691 0 1e6
RG2692 N2692 0 1e6
RG2693 N2693 0 1e6
RG2694 N2694 0 1e6
RG2695 N2695 0 1e6
RG2696 N2696 0 1e6
RG2697 N2697 0 1e6
RG2698 N2698 0 1e6
RG2699 N2699 0 1e6
RG2700 N2700 0 1e6
RG2701 N2701 0 1e6
RG2702 N2702 0 1e6
RG2703 N2703 0 1e6
RG2704 N2704 0 1e6
RG2705 N2705 0 1e6
RG2706 N2706 0 1e6
RG2707 N2707 0 1e6
RG2708 N2708 0 1e6
RG2709 N2709 0 1e6
RG2710 N2710 0 1e6
RG2711 N2711 0 1e6
RG2712 N2712 0 1e6
RG2713 N2713 0 1e6
RG2714 N2714 0 1e6
RG2715 N2715 0 1e6
RG2716 N2716 0 1e6
RG2717 N2717 0 1e6
RG2718 N2718 0 1e6
RG2719 N2719 0 1e6
RG2720 N2720 0 1e6
RG2721 N2721 0 1e6
RG2722 N2722 0 1e6
RG2723 N2723 0 1e6
RG2724 N2724 0 1e6
RG2725 N2725 0 1e6
RG2726 N2726 0 1e6
RG2727 N2727 0 1e6
RG2728 N2728 0 1e6
RG2729 N2729 0 1e6
RG2730 N2730 0 1e6
RG2731 N2731 0 1e6
RG2732 N2732 0 1e6
RG2733 N2733 0 1e6
RG2734 N2734 0 1e6
RG2735 N2735 0 1e6
RG2736 N2736 0 1e6
RG2737 N2737 0 1e6
RG2738 N2738 0 1e6
RG2739 N2739 0 1e6
RG2740 N2740 0 1e6
RG2741 N2741 0 1e6
RG2742 N2742 0 1e6
RG2743 N2743 0 1e6
RG2744 N2744 0 1e6
RG2745 N2745 0 1e6
RG2746 N2746 0 1e6
RG2747 N2747 0 1e6
RG2748 N2748 0 1e6
RG2749 N2749 0 1e6
RG2750 N2750 0 1e6
RG2751 N2751 0 1e6
RG2752 N2752 0 1e6
RG2753 N2753 0 1e6
RG2754 N2754 0 1e6
RG2755 N2755 0 1e6
RG2756 N2756 0 1e6
RG2757 N2757 0 1e6
RG2758 N2758 0 1e6
RG2759 N2759 0 1e6
RG2760 N2760 0 1e6
RG2761 N2761 0 1e6
RG2762 N2762 0 1e6
RG2763 N2763 0 1e6
RG2764 N2764 0 1e6
RG2765 N2765 0 1e6
RG2766 N2766 0 1e6
RG2767 N2767 0 1e6
RG2768 N2768 0 1e6
RG2769 N2769 0 1e6
RG2770 N2770 0 1e6
RG2771 N2771 0 1e6
RG2772 N2772 0 1e6
RG2773 N2773 0 1e6
RG2774 N2774 0 1e6
RG2775 N2775 0 1e6
RG2776 N2776 0 1e6
RG2777 N2777 0 1e6
RG2778 N2778 0 1e6
RG2779 N2779 0 1e6
RG2780 N2780 0 1e6
RG2781 N2781 0 1e6
RG2782 N2782 0 1e6
RG2783 N2783 0 1e6
RG2784 N2784 0 1e6
RG2785 N2785 0 1e6
RG2786 N2786 0 1e6
RG2787 N2787 0 1e6
RG2788 N2788 0 1e6
RG2789 N2789 0 1e6
RG2790 N2790 0 1e6
RG2791 N2791 0 1e6
RG2792 N2792 0 1e6
RG2793 N2793 0 1e6
RG2794 N2794 0 1e6
RG2795 N2795 0 1e6
RG2796 N2796 0 1e6
RG2797 N2797 0 1e6
RG2798 N2798 0 1e6
RG2799 N2799 0 1e6
RG2800 N2800 0 1e6
RG2801 N2801 0 1e6
RG2802 N2802 0 1e6
RG2803 N2803 0 1e6
RG2804 N2804 0 1e6
RG2805 N2805 0 1e6
RG2806 N2806 0 1e6
RG2807 N2807 0 1e6
RG2808 N2808 0 1e6
RG2809 N2809 0 1e6
RG2810 N2810 0 1e6
RG2811 N2811 0 1e6
RG2812 N2812 0 1e6
RG2813 N2813 0 1e6
RG2814 N2814 0 1e6
RG2815 N2815 0 1e6
RG2816 N2816 0 1e6
RG2817 N2817 0 1e6
RG2818 N2818 0 1e6
RG2819 N2819 0 1e6
RG2820 N2820 0 1e6
RG2821 N2821 0 1e6
RG2822 N2822 0 1e6
RG2823 N2823 0 1e6
RG2824 N2824 0 1e6
RG2825 N2825 0 1e6
RG2826 N2826 0 1e6
RG2827 N2827 0 1e6
RG2828 N2828 0 1e6
RG2829 N2829 0 1e6
RG2830 N2830 0 1e6
RG2831 N2831 0 1e6
RG2832 N2832 0 1e6
RG2833 N2833 0 1e6
RG2834 N2834 0 1e6
RG2835 N2835 0 1e6
RG2836 N2836 0 1e6
RG2837 N2837 0 1e6
RG2838 N2838 0 1e6
RG2839 N2839 0 1e6
RG2840 N2840 0 1e6
RG2841 N2841 0 1e6
RG2842 N2842 0 1e6
RG2843 N2843 0 1e6
RG2844 N2844 0 1e6
RG2845 N2845 0 1e6
RG2846 N2846 0 1e6
RG2847 N2847 0 1e6
RG2848 N2848 0 1e6
RG2849 N2849 0 1e6
RG2850 N2850 0 1e6
RG2851 N2851 0 1e6
RG2852 N2852 0 1e6
RG2853 N2853 0 1e6
RG2854 N2854 0 1e6
RG2855 N2855 0 1e6
RG2856 N2856 0 1e6
RG2857 N2857 0 1e6
RG2858 N2858 0 1e6
RG2859 N2859 0 1e6
RG2860 N2860 0 1e6
RG2861 N2861 0 1e6
RG2862 N2862 0 1e6
RG2863 N2863 0 1e6
RG2864 N2864 0 1e6
RG2865 N2865 0 1e6
RG2866 N2866 0 1e6
RG2867 N2867 0 1e6
RG2868 N2868 0 1e6
RG2869 N2869 0 1e6
RG2870 N2870 0 1e6
RG2871 N2871 0 1e6
RG2872 N2872 0 1e6
RG2873 N2873 0 1e6
RG2874 N2874 0 1e6
RG2875 N2875 0 1e6
RG2876 N2876 0 1e6
RG2877 N2877 0 1e6
RG2878 N2878 0 1e6
RG2879 N2879 0 1e6
RG2880 N2880 0 1e6
RG2881 N2881 0 1e6
RG2882 N2882 0 1e6
RG2883 N2883 0 1e6
RG2884 N2884 0 1e6
RG2885 N2885 0 1e6
RG2886 N2886 0 1e6
RG2887 N2887 0 1e6
RG2888 N2888 0 1e6
RG2889 N2889 0 1e6
RG2890 N2890 0 1e6
RG2891 N2891 0 1e6
RG2892 N2892 0 1e6
RG2893 N2893 0 1e6
RG2894 N2894 0 1e6
RG2895 N2895 0 1e6
RG2896 N2896 0 1e6
RG2897 N2897 0 1e6
RG2898 N2898 0 1e6
RG2899 N2899 0 1e6
RG2900 N2900 0 1e6
RG2901 N2901 0 1e6
RG2902 N2902 0 1e6
RG2903 N2903 0 1e6
RG2904 N2904 0 1e6
RG2905 N2905 0 1e6
RG2906 N2906 0 1e6
RG2907 N2907 0 1e6
RG2908 N2908 0 1e6
RG2909 N2909 0 1e6
RG2910 N2910 0 1e6
RG2911 N2911 0 1e6
RG2912 N2912 0 1e6
RG2913 N2913 0 1e6
RG2914 N2914 0 1e6
RG2915 N2915 0 1e6
RG2916 N2916 0 1e6
RG2917 N2917 0 1e6
RG2918 N2918 0 1e6
RG2919 N2919 0 1e6
RG2920 N2920 0 1e6
RG2921 N2921 0 1e6
RG2922 N2922 0 1e6
RG2923 N2923 0 1e6
RG2924 N2924 0 1e6
RG2925 N2925 0 1e6
RG2926 N2926 0 1e6
RG2927 N2927 0 1e6
RG2928 N2928 0 1e6
RG2929 N2929 0 1e6
RG2930 N2930 0 1e6
RG2931 N2931 0 1e6
RG2932 N2932 0 1e6
RG2933 N2933 0 1e6
RG2934 N2934 0 1e6
RG2935 N2935 0 1e6
RG2936 N2936 0 1e6
RG2937 N2937 0 1e6
RG2938 N2938 0 1e6
RG2939 N2939 0 1e6
RG2940 N2940 0 1e6
RG2941 N2941 0 1e6
RG2942 N2942 0 1e6
RG2943 N2943 0 1e6
RG2944 N2944 0 1e6
RG2945 N2945 0 1e6
RG2946 N2946 0 1e6
RG2947 N2947 0 1e6
RG2948 N2948 0 1e6
RG2949 N2949 0 1e6
RG2950 N2950 0 1e6
RG2951 N2951 0 1e6
RG2952 N2952 0 1e6
RG2953 N2953 0 1e6
RG2954 N2954 0 1e6
RG2955 N2955 0 1e6
RG2956 N2956 0 1e6
RG2957 N2957 0 1e6
RG2958 N2958 0 1e6
RG2959 N2959 0 1e6
RG2960 N2960 0 1e6
RG2961 N2961 0 1e6
RG2962 N2962 0 1e6
RG2963 N2963 0 1e6
RG2964 N2964 0 1e6
RG2965 N2965 0 1e6
RG2966 N2966 0 1e6
RG2967 N2967 0 1e6
RG2968 N2968 0 1e6
RG2969 N2969 0 1e6
RG2970 N2970 0 1e6
RG2971 N2971 0 1e6
RG2972 N2972 0 1e6
RG2973 N2973 0 1e6
RG2974 N2974 0 1e6
RG2975 N2975 0 1e6
RG2976 N2976 0 1e6
RG2977 N2977 0 1e6
RG2978 N2978 0 1e6
RG2979 N2979 0 1e6
RG2980 N2980 0 1e6
RG2981 N2981 0 1e6
RG2982 N2982 0 1e6
RG2983 N2983 0 1e6
RG2984 N2984 0 1e6
RG2985 N2985 0 1e6
RG2986 N2986 0 1e6
RG2987 N2987 0 1e6
RG2988 N2988 0 1e6
RG2989 N2989 0 1e6
RG2990 N2990 0 1e6
RG2991 N2991 0 1e6
RG2992 N2992 0 1e6
RG2993 N2993 0 1e6
RG2994 N2994 0 1e6
RG2995 N2995 0 1e6
RG2996 N2996 0 1e6
RG2997 N2997 0 1e6
RG2998 N2998 0 1e6
RG2999 N2999 0 1e6
RG3000 N3000 0 1e6
RG3001 N3001 0 1e6
RG3002 N3002 0 1e6
RG3003 N3003 0 1e6
RG3004 N3004 0 1e6
RG3005 N3005 0 1e6
RG3006 N3006 0 1e6
RG3007 N3007 0 1e6
RG3008 N3008 0 1e6
RG3009 N3009 0 1e6
RG3010 N3010 0 1e6
RG3011 N3011 0 1e6
RG3012 N3012 0 1e6
RG3013 N3013 0 1e6
RG3014 N3014 0 1e6
RG3015 N3015 0 1e6
RG3016 N3016 0 1e6
RG3017 N3017 0 1e6
RG3018 N3018 0 1e6
RG3019 N3019 0 1e6
RG3020 N3020 0 1e6
RG3021 N3021 0 1e6
RG3022 N3022 0 1e6
RG3023 N3023 0 1e6
RG3024 N3024 0 1e6
RG3025 N3025 0 1e6
RG3026 N3026 0 1e6
RG3027 N3027 0 1e6
RG3028 N3028 0 1e6
RG3029 N3029 0 1e6
RG3030 N3030 0 1e6
RG3031 N3031 0 1e6
RG3032 N3032 0 1e6
RG3033 N3033 0 1e6
RG3034 N3034 0 1e6
RG3035 N3035 0 1e6
RG3036 N3036 0 1e6
RG3037 N3037 0 1e6
RG3038 N3038 0 1e6
RG3039 N3039 0 1e6
RG3040 N3040 0 1e6
RG3041 N3041 0 1e6
RG3042 N3042 0 1e6
RG3043 N3043 0 1e6
RG3044 N3044 0 1e6
RG3045 N3045 0 1e6
RG3046 N3046 0 1e6
RG3047 N3047 0 1e6
RG3048 N3048 0 1e6
RG3049 N3049 0 1e6
RG3050 N3050 0 1e6
RG3051 N3051 0 1e6
RG3052 N3052 0 1e6
RG3053 N3053 0 1e6
RG3054 N3054 0 1e6
RG3055 N3055 0 1e6
RG3056 N3056 0 1e6
RG3057 N3057 0 1e6
RG3058 N3058 0 1e6
RG3059 N3059 0 1e6
RG3060 N3060 0 1e6
RG3061 N3061 0 1e6
RG3062 N3062 0 1e6
RG3063 N3063 0 1e6
RG3064 N3064 0 1e6
RG3065 N3065 0 1e6
RG3066 N3066 0 1e6
RG3067 N3067 0 1e6
RG3068 N3068 0 1e6
RG3069 N3069 0 1e6
RG3070 N3070 0 1e6
RG3071 N3071 0 1e6
RG3072 N3072 0 1e6
RG3073 N3073 0 1e6
RG3074 N3074 0 1e6
RG3075 N3075 0 1e6
RG3076 N3076 0 1e6
RG3077 N3077 0 1e6
RG3078 N3078 0 1e6
RG3079 N3079 0 1e6
RG3080 N3080 0 1e6
RG3081 N3081 0 1e6
RG3082 N3082 0 1e6
RG3083 N3083 0 1e6
RG3084 N3084 0 1e6
RG3085 N3085 0 1e6
RG3086 N3086 0 1e6
RG3087 N3087 0 1e6
RG3088 N3088 0 1e6
RG3089 N3089 0 1e6
RG3090 N3090 0 1e6
RG3091 N3091 0 1e6
RG3092 N3092 0 1e6
RG3093 N3093 0 1e6
RG3094 N3094 0 1e6
RG3095 N3095 0 1e6
RG3096 N3096 0 1e6
RG3097 N3097 0 1e6
RG3098 N3098 0 1e6
RG3099 N3099 0 1e6
RG3100 N3100 0 1e6
RG3101 N3101 0 1e6
RG3102 N3102 0 1e6
RG3103 N3103 0 1e6
RG3104 N3104 0 1e6
RG3105 N3105 0 1e6
RG3106 N3106 0 1e6
RG3107 N3107 0 1e6
RG3108 N3108 0 1e6
RG3109 N3109 0 1e6
RG3110 N3110 0 1e6
RG3111 N3111 0 1e6
RG3112 N3112 0 1e6
RG3113 N3113 0 1e6
RG3114 N3114 0 1e6
RG3115 N3115 0 1e6
RG3116 N3116 0 1e6
RG3117 N3117 0 1e6
RG3118 N3118 0 1e6
RG3119 N3119 0 1e6
RG3120 N3120 0 1e6
RG3121 N3121 0 1e6
RG3122 N3122 0 1e6
RG3123 N3123 0 1e6
RG3124 N3124 0 1e6
RG3125 N3125 0 1e6
RG3126 N3126 0 1e6
RG3127 N3127 0 1e6
RG3128 N3128 0 1e6
RG3129 N3129 0 1e6
RG3130 N3130 0 1e6
RG3131 N3131 0 1e6
RG3132 N3132 0 1e6
RG3133 N3133 0 1e6
RG3134 N3134 0 1e6
RG3135 N3135 0 1e6
RG3136 N3136 0 1e6
RG3137 N3137 0 1e6
RG3138 N3138 0 1e6
RG3139 N3139 0 1e6
RG3140 N3140 0 1e6
RG3141 N3141 0 1e6
RG3142 N3142 0 1e6
RG3143 N3143 0 1e6
RG3144 N3144 0 1e6
RG3145 N3145 0 1e6
RG3146 N3146 0 1e6
RG3147 N3147 0 1e6
RG3148 N3148 0 1e6
RG3149 N3149 0 1e6
RG3150 N3150 0 1e6
RG3151 N3151 0 1e6
RG3152 N3152 0 1e6
RG3153 N3153 0 1e6
RG3154 N3154 0 1e6
RG3155 N3155 0 1e6
RG3156 N3156 0 1e6
RG3157 N3157 0 1e6
RG3158 N3158 0 1e6
RG3159 N3159 0 1e6
RG3160 N3160 0 1e6
RG3161 N3161 0 1e6
RG3162 N3162 0 1e6
RG3163 N3163 0 1e6
RG3164 N3164 0 1e6
RG3165 N3165 0 1e6
RG3166 N3166 0 1e6
RG3167 N3167 0 1e6
RG3168 N3168 0 1e6
RG3169 N3169 0 1e6
RG3170 N3170 0 1e6
RG3171 N3171 0 1e6
RG3172 N3172 0 1e6
RG3173 N3173 0 1e6
RG3174 N3174 0 1e6
RG3175 N3175 0 1e6
RG3176 N3176 0 1e6
RG3177 N3177 0 1e6
RG3178 N3178 0 1e6
RG3179 N3179 0 1e6
RG3180 N3180 0 1e6
RG3181 N3181 0 1e6
RG3182 N3182 0 1e6
RG3183 N3183 0 1e6
RG3184 N3184 0 1e6
RG3185 N3185 0 1e6
RG3186 N3186 0 1e6
RG3187 N3187 0 1e6
RG3188 N3188 0 1e6
RG3189 N3189 0 1e6
RG3190 N3190 0 1e6
RG3191 N3191 0 1e6
RG3192 N3192 0 1e6
RG3193 N3193 0 1e6
RG3194 N3194 0 1e6
RG3195 N3195 0 1e6
RG3196 N3196 0 1e6
RG3197 N3197 0 1e6
RG3198 N3198 0 1e6
RG3199 N3199 0 1e6
RG3200 N3200 0 1e6
RG3201 N3201 0 1e6
RG3202 N3202 0 1e6
RG3203 N3203 0 1e6
RG3204 N3204 0 1e6
RG3205 N3205 0 1e6
RG3206 N3206 0 1e6
RG3207 N3207 0 1e6
RG3208 N3208 0 1e6
RG3209 N3209 0 1e6
RG3210 N3210 0 1e6
RG3211 N3211 0 1e6
RG3212 N3212 0 1e6
RG3213 N3213 0 1e6
RG3214 N3214 0 1e6
RG3215 N3215 0 1e6
RG3216 N3216 0 1e6
RG3217 N3217 0 1e6
RG3218 N3218 0 1e6
RG3219 N3219 0 1e6
RG3220 N3220 0 1e6
RG3221 N3221 0 1e6
RG3222 N3222 0 1e6
RG3223 N3223 0 1e6
RG3224 N3224 0 1e6
RG3225 N3225 0 1e6
RG3226 N3226 0 1e6
RG3227 N3227 0 1e6
RG3228 N3228 0 1e6
RG3229 N3229 0 1e6
RG3230 N3230 0 1e6
RG3231 N3231 0 1e6
RG3232 N3232 0 1e6
RG3233 N3233 0 1e6
RG3234 N3234 0 1e6
RG3235 N3235 0 1e6
RG3236 N3236 0 1e6
RG3237 N3237 0 1e6
RG3238 N3238 0 1e6
RG3239 N3239 0 1e6
RG3240 N3240 0 1e6
RG3241 N3241 0 1e6
RG3242 N3242 0 1e6
RG3243 N3243 0 1e6
RG3244 N3244 0 1e6
RG3245 N3245 0 1e6
RG3246 N3246 0 1e6
RG3247 N3247 0 1e6
RG3248 N3248 0 1e6
RG3249 N3249 0 1e6
RG3250 N3250 0 1e6
RG3251 N3251 0 1e6
RG3252 N3252 0 1e6
RG3253 N3253 0 1e6
RG3254 N3254 0 1e6
RG3255 N3255 0 1e6
RG3256 N3256 0 1e6
RG3257 N3257 0 1e6
RG3258 N3258 0 1e6
RG3259 N3259 0 1e6
RG3260 N3260 0 1e6
RG3261 N3261 0 1e6
RG3262 N3262 0 1e6
RG3263 N3263 0 1e6
RG3264 N3264 0 1e6
RG3265 N3265 0 1e6
RG3266 N3266 0 1e6
RG3267 N3267 0 1e6
RG3268 N3268 0 1e6
RG3269 N3269 0 1e6
RG3270 N3270 0 1e6
RG3271 N3271 0 1e6
RG3272 N3272 0 1e6
RG3273 N3273 0 1e6
RG3274 N3274 0 1e6
RG3275 N3275 0 1e6
RG3276 N3276 0 1e6
RG3277 N3277 0 1e6
RG3278 N3278 0 1e6
RG3279 N3279 0 1e6
RG3280 N3280 0 1e6
RG3281 N3281 0 1e6
RG3282 N3282 0 1e6
RG3283 N3283 0 1e6
RG3284 N3284 0 1e6
RG3285 N3285 0 1e6
RG3286 N3286 0 1e6
RG3287 N3287 0 1e6
RG3288 N3288 0 1e6
RG3289 N3289 0 1e6
RG3290 N3290 0 1e6
RG3291 N3291 0 1e6
RG3292 N3292 0 1e6
RG3293 N3293 0 1e6
RG3294 N3294 0 1e6
RG3295 N3295 0 1e6
RG3296 N3296 0 1e6
RG3297 N3297 0 1e6
RG3298 N3298 0 1e6
RG3299 N3299 0 1e6
RG3300 N3300 0 1e6
RG3301 N3301 0 1e6
RG3302 N3302 0 1e6
RG3303 N3303 0 1e6
RG3304 N3304 0 1e6
RG3305 N3305 0 1e6
RG3306 N3306 0 1e6
RG3307 N3307 0 1e6
RG3308 N3308 0 1e6
RG3309 N3309 0 1e6
RG3310 N3310 0 1e6
RG3311 N3311 0 1e6
RG3312 N3312 0 1e6
RG3313 N3313 0 1e6
RG3314 N3314 0 1e6
RG3315 N3315 0 1e6
RG3316 N3316 0 1e6
RG3317 N3317 0 1e6
RG3318 N3318 0 1e6
RG3319 N3319 0 1e6
RG3320 N3320 0 1e6
RG3321 N3321 0 1e6
RG3322 N3322 0 1e6
RG3323 N3323 0 1e6
RG3324 N3324 0 1e6
RG3325 N3325 0 1e6
RG3326 N3326 0 1e6
RG3327 N3327 0 1e6
RG3328 N3328 0 1e6
RG3329 N3329 0 1e6
RG3330 N3330 0 1e6
RG3331 N3331 0 1e6
RG3332 N3332 0 1e6
RG3333 N3333 0 1e6
RG3334 N3334 0 1e6
RG3335 N3335 0 1e6
RG3336 N3336 0 1e6
RG3337 N3337 0 1e6
RG3338 N3338 0 1e6
RG3339 N3339 0 1e6
RG3340 N3340 0 1e6
RG3341 N3341 0 1e6
RG3342 N3342 0 1e6
RG3343 N3343 0 1e6
RG3344 N3344 0 1e6
RG3345 N3345 0 1e6
RG3346 N3346 0 1e6
RG3347 N3347 0 1e6
RG3348 N3348 0 1e6
RG3349 N3349 0 1e6
RG3350 N3350 0 1e6
RG3351 N3351 0 1e6
RG3352 N3352 0 1e6
RG3353 N3353 0 1e6
RG3354 N3354 0 1e6
RG3355 N3355 0 1e6
RG3356 N3356 0 1e6
RG3357 N3357 0 1e6
RG3358 N3358 0 1e6
RG3359 N3359 0 1e6
RG3360 N3360 0 1e6
RG3361 N3361 0 1e6
RG3362 N3362 0 1e6
RG3363 N3363 0 1e6
RG3364 N3364 0 1e6
RG3365 N3365 0 1e6
RG3366 N3366 0 1e6
RG3367 N3367 0 1e6
RG3368 N3368 0 1e6
RG3369 N3369 0 1e6
RG3370 N3370 0 1e6
RG3371 N3371 0 1e6
RG3372 N3372 0 1e6
RG3373 N3373 0 1e6
RG3374 N3374 0 1e6
RG3375 N3375 0 1e6
RG3376 N3376 0 1e6
RG3377 N3377 0 1e6
RG3378 N3378 0 1e6
RG3379 N3379 0 1e6
RG3380 N3380 0 1e6
RG3381 N3381 0 1e6
RG3382 N3382 0 1e6
RG3383 N3383 0 1e6
RG3384 N3384 0 1e6
RG3385 N3385 0 1e6
RG3386 N3386 0 1e6
RG3387 N3387 0 1e6
RG3388 N3388 0 1e6
RG3389 N3389 0 1e6
RG3390 N3390 0 1e6
RG3391 N3391 0 1e6
RG3392 N3392 0 1e6
RG3393 N3393 0 1e6
RG3394 N3394 0 1e6
RG3395 N3395 0 1e6
RG3396 N3396 0 1e6
RG3397 N3397 0 1e6
RG3398 N3398 0 1e6
RG3399 N3399 0 1e6
RG3400 N3400 0 1e6
RG3401 N3401 0 1e6
RG3402 N3402 0 1e6
RG3403 N3403 0 1e6
RG3404 N3404 0 1e6
RG3405 N3405 0 1e6
RG3406 N3406 0 1e6
RG3407 N3407 0 1e6
RG3408 N3408 0 1e6
RG3409 N3409 0 1e6
RG3410 N3410 0 1e6
RG3411 N3411 0 1e6
RG3412 N3412 0 1e6
RG3413 N3413 0 1e6
RG3414 N3414 0 1e6
RG3415 N3415 0 1e6
RG3416 N3416 0 1e6
RG3417 N3417 0 1e6
RG3418 N3418 0 1e6
RG3419 N3419 0 1e6
RG3420 N3420 0 1e6
RG3421 N3421 0 1e6
RG3422 N3422 0 1e6
RG3423 N3423 0 1e6
RG3424 N3424 0 1e6
RG3425 N3425 0 1e6
RG3426 N3426 0 1e6
RG3427 N3427 0 1e6
RG3428 N3428 0 1e6
RG3429 N3429 0 1e6
RG3430 N3430 0 1e6
RG3431 N3431 0 1e6
RG3432 N3432 0 1e6
RG3433 N3433 0 1e6
RG3434 N3434 0 1e6
RG3435 N3435 0 1e6
RG3436 N3436 0 1e6
RG3437 N3437 0 1e6
RG3438 N3438 0 1e6
RG3439 N3439 0 1e6
RG3440 N3440 0 1e6
RG3441 N3441 0 1e6
RG3442 N3442 0 1e6
RG3443 N3443 0 1e6
RG3444 N3444 0 1e6
RG3445 N3445 0 1e6
RG3446 N3446 0 1e6
RG3447 N3447 0 1e6
RG3448 N3448 0 1e6
RG3449 N3449 0 1e6
RG3450 N3450 0 1e6
RG3451 N3451 0 1e6
RG3452 N3452 0 1e6
RG3453 N3453 0 1e6
RG3454 N3454 0 1e6
RG3455 N3455 0 1e6
RG3456 N3456 0 1e6
RG3457 N3457 0 1e6
RG3458 N3458 0 1e6
RG3459 N3459 0 1e6
RG3460 N3460 0 1e6
RG3461 N3461 0 1e6
RG3462 N3462 0 1e6
RG3463 N3463 0 1e6
RG3464 N3464 0 1e6
RG3465 N3465 0 1e6
RG3466 N3466 0 1e6
RG3467 N3467 0 1e6
RG3468 N3468 0 1e6
RG3469 N3469 0 1e6
RG3470 N3470 0 1e6
RG3471 N3471 0 1e6
RG3472 N3472 0 1e6
RG3473 N3473 0 1e6
RG3474 N3474 0 1e6
RG3475 N3475 0 1e6
RG3476 N3476 0 1e6
RG3477 N3477 0 1e6
RG3478 N3478 0 1e6
RG3479 N3479 0 1e6
RG3480 N3480 0 1e6
RG3481 N3481 0 1e6
RG3482 N3482 0 1e6
RG3483 N3483 0 1e6
RG3484 N3484 0 1e6
RG3485 N3485 0 1e6
RG3486 N3486 0 1e6
RG3487 N3487 0 1e6
RG3488 N3488 0 1e6
RG3489 N3489 0 1e6
RG3490 N3490 0 1e6
RG3491 N3491 0 1e6
RG3492 N3492 0 1e6
RG3493 N3493 0 1e6
RG3494 N3494 0 1e6
RG3495 N3495 0 1e6
RG3496 N3496 0 1e6
RG3497 N3497 0 1e6
RG3498 N3498 0 1e6
RG3499 N3499 0 1e6
RG3500 N3500 0 1e6
RG3501 N3501 0 1e6
RG3502 N3502 0 1e6
RG3503 N3503 0 1e6
RG3504 N3504 0 1e6
RG3505 N3505 0 1e6
RG3506 N3506 0 1e6
RG3507 N3507 0 1e6
RG3508 N3508 0 1e6
RG3509 N3509 0 1e6
RG3510 N3510 0 1e6
RG3511 N3511 0 1e6
RG3512 N3512 0 1e6
RG3513 N3513 0 1e6
RG3514 N3514 0 1e6
RG3515 N3515 0 1e6
RG3516 N3516 0 1e6
RG3517 N3517 0 1e6
RG3518 N3518 0 1e6
RG3519 N3519 0 1e6
RG3520 N3520 0 1e6
RG3521 N3521 0 1e6
RG3522 N3522 0 1e6
RG3523 N3523 0 1e6
RG3524 N3524 0 1e6
RG3525 N3525 0 1e6
RG3526 N3526 0 1e6
RG3527 N3527 0 1e6
RG3528 N3528 0 1e6
RG3529 N3529 0 1e6
RG3530 N3530 0 1e6
RG3531 N3531 0 1e6
RG3532 N3532 0 1e6
RG3533 N3533 0 1e6
RG3534 N3534 0 1e6
RG3535 N3535 0 1e6
RG3536 N3536 0 1e6
RG3537 N3537 0 1e6
RG3538 N3538 0 1e6
RG3539 N3539 0 1e6
RG3540 N3540 0 1e6
RG3541 N3541 0 1e6
RG3542 N3542 0 1e6
RG3543 N3543 0 1e6
RG3544 N3544 0 1e6
RG3545 N3545 0 1e6
RG3546 N3546 0 1e6
RG3547 N3547 0 1e6
RG3548 N3548 0 1e6
RG3549 N3549 0 1e6
RG3550 N3550 0 1e6
RG3551 N3551 0 1e6
RG3552 N3552 0 1e6
RG3553 N3553 0 1e6
RG3554 N3554 0 1e6
RG3555 N3555 0 1e6
RG3556 N3556 0 1e6
RG3557 N3557 0 1e6
RG3558 N3558 0 1e6
RG3559 N3559 0 1e6
RG3560 N3560 0 1e6
RG3561 N3561 0 1e6
RG3562 N3562 0 1e6
RG3563 N3563 0 1e6
RG3564 N3564 0 1e6
RG3565 N3565 0 1e6
RG3566 N3566 0 1e6
RG3567 N3567 0 1e6
RG3568 N3568 0 1e6
RG3569 N3569 0 1e6
RG3570 N3570 0 1e6
RG3571 N3571 0 1e6
RG3572 N3572 0 1e6
RG3573 N3573 0 1e6
RG3574 N3574 0 1e6
RG3575 N3575 0 1e6
RG3576 N3576 0 1e6
RG3577 N3577 0 1e6
RG3578 N3578 0 1e6
RG3579 N3579 0 1e6
RG3580 N3580 0 1e6
RG3581 N3581 0 1e6
RG3582 N3582 0 1e6
RG3583 N3583 0 1e6
RG3584 N3584 0 1e6
RG3585 N3585 0 1e6
RG3586 N3586 0 1e6
RG3587 N3587 0 1e6
RG3588 N3588 0 1e6
RG3589 N3589 0 1e6
RG3590 N3590 0 1e6
RG3591 N3591 0 1e6
RG3592 N3592 0 1e6
RG3593 N3593 0 1e6
RG3594 N3594 0 1e6
RG3595 N3595 0 1e6
RG3596 N3596 0 1e6
RG3597 N3597 0 1e6
RG3598 N3598 0 1e6
RG3599 N3599 0 1e6
RG3600 N3600 0 1e6
RG3601 N3601 0 1e6
RG3602 N3602 0 1e6
RG3603 N3603 0 1e6
RG3604 N3604 0 1e6
RG3605 N3605 0 1e6
RG3606 N3606 0 1e6
RG3607 N3607 0 1e6
RG3608 N3608 0 1e6
RG3609 N3609 0 1e6
RG3610 N3610 0 1e6
RG3611 N3611 0 1e6
RG3612 N3612 0 1e6
RG3613 N3613 0 1e6
RG3614 N3614 0 1e6
RG3615 N3615 0 1e6
RG3616 N3616 0 1e6
RG3617 N3617 0 1e6
RG3618 N3618 0 1e6
RG3619 N3619 0 1e6
RG3620 N3620 0 1e6
RG3621 N3621 0 1e6
RG3622 N3622 0 1e6
RG3623 N3623 0 1e6
RG3624 N3624 0 1e6
RG3625 N3625 0 1e6
RG3626 N3626 0 1e6
RG3627 N3627 0 1e6
RG3628 N3628 0 1e6
RG3629 N3629 0 1e6
RG3630 N3630 0 1e6
RG3631 N3631 0 1e6
RG3632 N3632 0 1e6
RG3633 N3633 0 1e6
RG3634 N3634 0 1e6
RG3635 N3635 0 1e6
RG3636 N3636 0 1e6
RG3637 N3637 0 1e6
RG3638 N3638 0 1e6
RG3639 N3639 0 1e6
RG3640 N3640 0 1e6
RG3641 N3641 0 1e6
RG3642 N3642 0 1e6
RG3643 N3643 0 1e6
RG3644 N3644 0 1e6
RG3645 N3645 0 1e6
RG3646 N3646 0 1e6
RG3647 N3647 0 1e6
RG3648 N3648 0 1e6
RG3649 N3649 0 1e6
RG3650 N3650 0 1e6
RG3651 N3651 0 1e6
RG3652 N3652 0 1e6
RG3653 N3653 0 1e6
RG3654 N3654 0 1e6
RG3655 N3655 0 1e6
RG3656 N3656 0 1e6
RG3657 N3657 0 1e6
RG3658 N3658 0 1e6
RG3659 N3659 0 1e6
RG3660 N3660 0 1e6
RG3661 N3661 0 1e6
RG3662 N3662 0 1e6
RG3663 N3663 0 1e6
RG3664 N3664 0 1e6
RG3665 N3665 0 1e6
RG3666 N3666 0 1e6
RG3667 N3667 0 1e6
RG3668 N3668 0 1e6
RG3669 N3669 0 1e6
RG3670 N3670 0 1e6
RG3671 N3671 0 1e6
RG3672 N3672 0 1e6
RG3673 N3673 0 1e6
RG3674 N3674 0 1e6
RG3675 N3675 0 1e6
RG3676 N3676 0 1e6
RG3677 N3677 0 1e6
RG3678 N3678 0 1e6
RG3679 N3679 0 1e6
RG3680 N3680 0 1e6
RG3681 N3681 0 1e6
RG3682 N3682 0 1e6
RG3683 N3683 0 1e6
RG3684 N3684 0 1e6
RG3685 N3685 0 1e6
RG3686 N3686 0 1e6
RG3687 N3687 0 1e6
RG3688 N3688 0 1e6
RG3689 N3689 0 1e6
RG3690 N3690 0 1e6
RG3691 N3691 0 1e6
RG3692 N3692 0 1e6
RG3693 N3693 0 1e6
RG3694 N3694 0 1e6
RG3695 N3695 0 1e6
RG3696 N3696 0 1e6
RG3697 N3697 0 1e6
RG3698 N3698 0 1e6
RG3699 N3699 0 1e6
RG3700 N3700 0 1e6
RG3701 N3701 0 1e6
RG3702 N3702 0 1e6
RG3703 N3703 0 1e6
RG3704 N3704 0 1e6
RG3705 N3705 0 1e6
RG3706 N3706 0 1e6
RG3707 N3707 0 1e6
RG3708 N3708 0 1e6
RG3709 N3709 0 1e6
RG3710 N3710 0 1e6
RG3711 N3711 0 1e6
RG3712 N3712 0 1e6
RG3713 N3713 0 1e6
RG3714 N3714 0 1e6
RG3715 N3715 0 1e6
RG3716 N3716 0 1e6
RG3717 N3717 0 1e6
RG3718 N3718 0 1e6
RG3719 N3719 0 1e6
RG3720 N3720 0 1e6
RG3721 N3721 0 1e6
RG3722 N3722 0 1e6
RG3723 N3723 0 1e6
RG3724 N3724 0 1e6
RG3725 N3725 0 1e6
RG3726 N3726 0 1e6
RG3727 N3727 0 1e6
RG3728 N3728 0 1e6
RG3729 N3729 0 1e6
RG3730 N3730 0 1e6
RG3731 N3731 0 1e6
RG3732 N3732 0 1e6
RG3733 N3733 0 1e6
RG3734 N3734 0 1e6
RG3735 N3735 0 1e6
RG3736 N3736 0 1e6
RG3737 N3737 0 1e6
RG3738 N3738 0 1e6
RG3739 N3739 0 1e6
RG3740 N3740 0 1e6
RG3741 N3741 0 1e6
RG3742 N3742 0 1e6
RG3743 N3743 0 1e6
RG3744 N3744 0 1e6
RG3745 N3745 0 1e6
RG3746 N3746 0 1e6
RG3747 N3747 0 1e6
RG3748 N3748 0 1e6
RG3749 N3749 0 1e6
RG3750 N3750 0 1e6
RG3751 N3751 0 1e6
RG3752 N3752 0 1e6
RG3753 N3753 0 1e6
RG3754 N3754 0 1e6
RG3755 N3755 0 1e6
RG3756 N3756 0 1e6
RG3757 N3757 0 1e6
RG3758 N3758 0 1e6
RG3759 N3759 0 1e6
RG3760 N3760 0 1e6
RG3761 N3761 0 1e6
RG3762 N3762 0 1e6
RG3763 N3763 0 1e6
RG3764 N3764 0 1e6
RG3765 N3765 0 1e6
RG3766 N3766 0 1e6
RG3767 N3767 0 1e6
RG3768 N3768 0 1e6
RG3769 N3769 0 1e6
RG3770 N3770 0 1e6
RG3771 N3771 0 1e6
RG3772 N3772 0 1e6
RG3773 N3773 0 1e6
RG3774 N3774 0 1e6
RG3775 N3775 0 1e6
RG3776 N3776 0 1e6
RG3777 N3777 0 1e6
RG3778 N3778 0 1e6
RG3779 N3779 0 1e6
RG3780 N3780 0 1e6
RG3781 N3781 0 1e6
RG3782 N3782 0 1e6
RG3783 N3783 0 1e6
RG3784 N3784 0 1e6
RG3785 N3785 0 1e6
RG3786 N3786 0 1e6
RG3787 N3787 0 1e6
RG3788 N3788 0 1e6
RG3789 N3789 0 1e6
RG3790 N3790 0 1e6
RG3791 N3791 0 1e6
RG3792 N3792 0 1e6
RG3793 N3793 0 1e6
RG3794 N3794 0 1e6
RG3795 N3795 0 1e6
RG3796 N3796 0 1e6
RG3797 N3797 0 1e6
RG3798 N3798 0 1e6
RG3799 N3799 0 1e6
RG3800 N3800 0 1e6
RG3801 N3801 0 1e6
RG3802 N3802 0 1e6
RG3803 N3803 0 1e6
RG3804 N3804 0 1e6
RG3805 N3805 0 1e6
RG3806 N3806 0 1e6
RG3807 N3807 0 1e6
RG3808 N3808 0 1e6
RG3809 N3809 0 1e6
RG3810 N3810 0 1e6
RG3811 N3811 0 1e6
RG3812 N3812 0 1e6
RG3813 N3813 0 1e6
RG3814 N3814 0 1e6
RG3815 N3815 0 1e6
RG3816 N3816 0 1e6
RG3817 N3817 0 1e6
RG3818 N3818 0 1e6
RG3819 N3819 0 1e6
RG3820 N3820 0 1e6
RG3821 N3821 0 1e6
RG3822 N3822 0 1e6
RG3823 N3823 0 1e6
RG3824 N3824 0 1e6
RG3825 N3825 0 1e6
RG3826 N3826 0 1e6
RG3827 N3827 0 1e6
RG3828 N3828 0 1e6
RG3829 N3829 0 1e6
RG3830 N3830 0 1e6
RG3831 N3831 0 1e6
RG3832 N3832 0 1e6
RG3833 N3833 0 1e6
RG3834 N3834 0 1e6
RG3835 N3835 0 1e6
RG3836 N3836 0 1e6
RG3837 N3837 0 1e6
RG3838 N3838 0 1e6
RG3839 N3839 0 1e6
RG3840 N3840 0 1e6
RG3841 N3841 0 1e6
RG3842 N3842 0 1e6
RG3843 N3843 0 1e6
RG3844 N3844 0 1e6
RG3845 N3845 0 1e6
RG3846 N3846 0 1e6
RG3847 N3847 0 1e6
RG3848 N3848 0 1e6
RG3849 N3849 0 1e6
RG3850 N3850 0 1e6
RG3851 N3851 0 1e6
RG3852 N3852 0 1e6
RG3853 N3853 0 1e6
RG3854 N3854 0 1e6
RG3855 N3855 0 1e6
RG3856 N3856 0 1e6
RG3857 N3857 0 1e6
RG3858 N3858 0 1e6
RG3859 N3859 0 1e6
RG3860 N3860 0 1e6
RG3861 N3861 0 1e6
RG3862 N3862 0 1e6
RG3863 N3863 0 1e6
RG3864 N3864 0 1e6
RG3865 N3865 0 1e6
RG3866 N3866 0 1e6
RG3867 N3867 0 1e6
RG3868 N3868 0 1e6
RG3869 N3869 0 1e6
RG3870 N3870 0 1e6
RG3871 N3871 0 1e6
RG3872 N3872 0 1e6
RG3873 N3873 0 1e6
RG3874 N3874 0 1e6
RG3875 N3875 0 1e6
RG3876 N3876 0 1e6
RG3877 N3877 0 1e6
RG3878 N3878 0 1e6
RG3879 N3879 0 1e6
RG3880 N3880 0 1e6
RG3881 N3881 0 1e6
RG3882 N3882 0 1e6
RG3883 N3883 0 1e6
RG3884 N3884 0 1e6
RG3885 N3885 0 1e6
RG3886 N3886 0 1e6
RG3887 N3887 0 1e6
RG3888 N3888 0 1e6
RG3889 N3889 0 1e6
RG3890 N3890 0 1e6
RG3891 N3891 0 1e6
RG3892 N3892 0 1e6
RG3893 N3893 0 1e6
RG3894 N3894 0 1e6
RG3895 N3895 0 1e6
RG3896 N3896 0 1e6
RG3897 N3897 0 1e6
RG3898 N3898 0 1e6
RG3899 N3899 0 1e6
RG3900 N3900 0 1e6
RG3901 N3901 0 1e6
RG3902 N3902 0 1e6
RG3903 N3903 0 1e6
RG3904 N3904 0 1e6
RG3905 N3905 0 1e6
RG3906 N3906 0 1e6
RG3907 N3907 0 1e6
RG3908 N3908 0 1e6
RG3909 N3909 0 1e6
RG3910 N3910 0 1e6
RG3911 N3911 0 1e6
RG3912 N3912 0 1e6
RG3913 N3913 0 1e6
RG3914 N3914 0 1e6
RG3915 N3915 0 1e6
RG3916 N3916 0 1e6
RG3917 N3917 0 1e6
RG3918 N3918 0 1e6
RG3919 N3919 0 1e6
RG3920 N3920 0 1e6
RG3921 N3921 0 1e6
RG3922 N3922 0 1e6
RG3923 N3923 0 1e6
RG3924 N3924 0 1e6
RG3925 N3925 0 1e6
RG3926 N3926 0 1e6
RG3927 N3927 0 1e6
RG3928 N3928 0 1e6
RG3929 N3929 0 1e6
RG3930 N3930 0 1e6
RG3931 N3931 0 1e6
RG3932 N3932 0 1e6
RG3933 N3933 0 1e6
RG3934 N3934 0 1e6
RG3935 N3935 0 1e6
RG3936 N3936 0 1e6
RG3937 N3937 0 1e6
RG3938 N3938 0 1e6
RG3939 N3939 0 1e6
RG3940 N3940 0 1e6
RG3941 N3941 0 1e6
RG3942 N3942 0 1e6
RG3943 N3943 0 1e6
RG3944 N3944 0 1e6
RG3945 N3945 0 1e6
RG3946 N3946 0 1e6
RG3947 N3947 0 1e6
RG3948 N3948 0 1e6
RG3949 N3949 0 1e6
RG3950 N3950 0 1e6
RG3951 N3951 0 1e6
RG3952 N3952 0 1e6
RG3953 N3953 0 1e6
RG3954 N3954 0 1e6
RG3955 N3955 0 1e6
RG3956 N3956 0 1e6
RG3957 N3957 0 1e6
RG3958 N3958 0 1e6
RG3959 N3959 0 1e6
RG3960 N3960 0 1e6
RG3961 N3961 0 1e6
RG3962 N3962 0 1e6
RG3963 N3963 0 1e6
RG3964 N3964 0 1e6
RG3965 N3965 0 1e6
RG3966 N3966 0 1e6
RG3967 N3967 0 1e6
RG3968 N3968 0 1e6
RG3969 N3969 0 1e6
RG3970 N3970 0 1e6
RG3971 N3971 0 1e6
RG3972 N3972 0 1e6
RG3973 N3973 0 1e6
RG3974 N3974 0 1e6
RG3975 N3975 0 1e6
RG3976 N3976 0 1e6
RG3977 N3977 0 1e6
RG3978 N3978 0 1e6
RG3979 N3979 0 1e6
RG3980 N3980 0 1e6
RG3981 N3981 0 1e6
RG3982 N3982 0 1e6
RG3983 N3983 0 1e6
RG3984 N3984 0 1e6
RG3985 N3985 0 1e6
RG3986 N3986 0 1e6
RG3987 N3987 0 1e6
RG3988 N3988 0 1e6
RG3989 N3989 0 1e6
RG3990 N3990 0 1e6
RG3991 N3991 0 1e6
RG3992 N3992 0 1e6
RG3993 N3993 0 1e6
RG3994 N3994 0 1e6
RG3995 N3995 0 1e6
RG3996 N3996 0 1e6
RG3997 N3997 0 1e6
RG3998 N3998 0 1e6
RG3999 N3999 0 1e6
RG4000 N4000 0 1e6
RG4001 N4001 0 1e6
RG4002 N4002 0 1e6
RG4003 N4003 0 1e6
RG4004 N4004 0 1e6
RG4005 N4005 0 1e6
RG4006 N4006 0 1e6
RG4007 N4007 0 1e6
RG4008 N4008 0 1e6
RG4009 N4009 0 1e6
RG4010 N4010 0 1e6
RG4011 N4011 0 1e6
RG4012 N4012 0 1e6
RG4013 N4013 0 1e6
RG4014 N4014 0 1e6
RG4015 N4015 0 1e6
RG4016 N4016 0 1e6
RG4017 N4017 0 1e6
RG4018 N4018 0 1e6
RG4019 N4019 0 1e6
RG4020 N4020 0 1e6
RG4021 N4021 0 1e6
RG4022 N4022 0 1e6
RG4023 N4023 0 1e6
RG4024 N4024 0 1e6
RG4025 N4025 0 1e6
RG4026 N4026 0 1e6
RG4027 N4027 0 1e6
RG4028 N4028 0 1e6
RG4029 N4029 0 1e6
RG4030 N4030 0 1e6
RG4031 N4031 0 1e6
RG4032 N4032 0 1e6
RG4033 N4033 0 1e6
RG4034 N4034 0 1e6
RG4035 N4035 0 1e6
RG4036 N4036 0 1e6
RG4037 N4037 0 1e6
RG4038 N4038 0 1e6
RG4039 N4039 0 1e6
RG4040 N4040 0 1e6
RG4041 N4041 0 1e6
RG4042 N4042 0 1e6
RG4043 N4043 0 1e6
RG4044 N4044 0 1e6
RG4045 N4045 0 1e6
RG4046 N4046 0 1e6
RG4047 N4047 0 1e6
RG4048 N4048 0 1e6
RG4049 N4049 0 1e6
RG4050 N4050 0 1e6
RG4051 N4051 0 1e6
RG4052 N4052 0 1e6
RG4053 N4053 0 1e6
RG4054 N4054 0 1e6
RG4055 N4055 0 1e6
RG4056 N4056 0 1e6
RG4057 N4057 0 1e6
RG4058 N4058 0 1e6
RG4059 N4059 0 1e6
RG4060 N4060 0 1e6
RG4061 N4061 0 1e6
RG4062 N4062 0 1e6
RG4063 N4063 0 1e6
RG4064 N4064 0 1e6
RG4065 N4065 0 1e6
RG4066 N4066 0 1e6
RG4067 N4067 0 1e6
RG4068 N4068 0 1e6
RG4069 N4069 0 1e6
RG4070 N4070 0 1e6
RG4071 N4071 0 1e6
RG4072 N4072 0 1e6
RG4073 N4073 0 1e6
RG4074 N4074 0 1e6
RG4075 N4075 0 1e6
RG4076 N4076 0 1e6
RG4077 N4077 0 1e6
RG4078 N4078 0 1e6
RG4079 N4079 0 1e6
RG4080 N4080 0 1e6
RG4081 N4081 0 1e6
RG4082 N4082 0 1e6
RG4083 N4083 0 1e6
RG4084 N4084 0 1e6
RG4085 N4085 0 1e6
RG4086 N4086 0 1e6
RG4087 N4087 0 1e6
RG4088 N4088 0 1e6
RG4089 N4089 0 1e6
RG4090 N4090 0 1e6
RG4091 N4091 0 1e6
RG4092 N4092 0 1e6
RG4093 N4093 0 1e6
RG4094 N4094 0 1e6
RG4095 N4095 0 1e6
RG4096 N4096 0 1e6
RG4097 N4097 0 1e6
RG4098 N4098 0 1e6
RG4099 N4099 0 1e6
RG4100 N4100 0 1e6
RG4101 N4101 0 1e6
RG4102 N4102 0 1e6
RG4103 N4103 0 1e6
RG4104 N4104 0 1e6
RG4105 N4105 0 1e6
RG4106 N4106 0 1e6
RG4107 N4107 0 1e6
RG4108 N4108 0 1e6
RG4109 N4109 0 1e6
RG4110 N4110 0 1e6
RG4111 N4111 0 1e6
RG4112 N4112 0 1e6
RG4113 N4113 0 1e6
RG4114 N4114 0 1e6
RG4115 N4115 0 1e6
RG4116 N4116 0 1e6
RG4117 N4117 0 1e6
RG4118 N4118 0 1e6
RG4119 N4119 0 1e6
RG4120 N4120 0 1e6
RG4121 N4121 0 1e6
RG4122 N4122 0 1e6
RG4123 N4123 0 1e6
RG4124 N4124 0 1e6
RG4125 N4125 0 1e6
RG4126 N4126 0 1e6
RG4127 N4127 0 1e6
RG4128 N4128 0 1e6
RG4129 N4129 0 1e6
RG4130 N4130 0 1e6
RG4131 N4131 0 1e6
RG4132 N4132 0 1e6
RG4133 N4133 0 1e6
RG4134 N4134 0 1e6
RG4135 N4135 0 1e6
RG4136 N4136 0 1e6
RG4137 N4137 0 1e6
RG4138 N4138 0 1e6
RG4139 N4139 0 1e6
RG4140 N4140 0 1e6
RG4141 N4141 0 1e6
RG4142 N4142 0 1e6
RG4143 N4143 0 1e6
RG4144 N4144 0 1e6
RG4145 N4145 0 1e6
RG4146 N4146 0 1e6
RG4147 N4147 0 1e6
RG4148 N4148 0 1e6
RG4149 N4149 0 1e6
RG4150 N4150 0 1e6
RG4151 N4151 0 1e6
RG4152 N4152 0 1e6
RG4153 N4153 0 1e6
RG4154 N4154 0 1e6
RG4155 N4155 0 1e6
RG4156 N4156 0 1e6
RG4157 N4157 0 1e6
RG4158 N4158 0 1e6
RG4159 N4159 0 1e6
RG4160 N4160 0 1e6
RG4161 N4161 0 1e6
RG4162 N4162 0 1e6
RG4163 N4163 0 1e6
RG4164 N4164 0 1e6
RG4165 N4165 0 1e6
RG4166 N4166 0 1e6
RG4167 N4167 0 1e6
RG4168 N4168 0 1e6
RG4169 N4169 0 1e6
RG4170 N4170 0 1e6
RG4171 N4171 0 1e6
RG4172 N4172 0 1e6
RG4173 N4173 0 1e6
RG4174 N4174 0 1e6
RG4175 N4175 0 1e6
RG4176 N4176 0 1e6
RG4177 N4177 0 1e6
RG4178 N4178 0 1e6
RG4179 N4179 0 1e6
RG4180 N4180 0 1e6
RG4181 N4181 0 1e6
RG4182 N4182 0 1e6
RG4183 N4183 0 1e6
RG4184 N4184 0 1e6
RG4185 N4185 0 1e6
RG4186 N4186 0 1e6
RG4187 N4187 0 1e6
RG4188 N4188 0 1e6
RG4189 N4189 0 1e6
RG4190 N4190 0 1e6
RG4191 N4191 0 1e6
RG4192 N4192 0 1e6
RG4193 N4193 0 1e6
RG4194 N4194 0 1e6
RG4195 N4195 0 1e6
RG4196 N4196 0 1e6
RG4197 N4197 0 1e6
RG4198 N4198 0 1e6
RG4199 N4199 0 1e6
RG4200 N4200 0 1e6
RG4201 N4201 0 1e6
RG4202 N4202 0 1e6
RG4203 N4203 0 1e6
RG4204 N4204 0 1e6
RG4205 N4205 0 1e6
RG4206 N4206 0 1e6
RG4207 N4207 0 1e6
RG4208 N4208 0 1e6
RG4209 N4209 0 1e6
RG4210 N4210 0 1e6
RG4211 N4211 0 1e6
RG4212 N4212 0 1e6
RG4213 N4213 0 1e6
RG4214 N4214 0 1e6
RG4215 N4215 0 1e6
RG4216 N4216 0 1e6
RG4217 N4217 0 1e6
RG4218 N4218 0 1e6
RG4219 N4219 0 1e6
RG4220 N4220 0 1e6
RG4221 N4221 0 1e6
RG4222 N4222 0 1e6
RG4223 N4223 0 1e6
RG4224 N4224 0 1e6
RG4225 N4225 0 1e6
RG4226 N4226 0 1e6
RG4227 N4227 0 1e6
RG4228 N4228 0 1e6
RG4229 N4229 0 1e6
RG4230 N4230 0 1e6
RG4231 N4231 0 1e6
RG4232 N4232 0 1e6
RG4233 N4233 0 1e6
RG4234 N4234 0 1e6
RG4235 N4235 0 1e6
RG4236 N4236 0 1e6
RG4237 N4237 0 1e6
RG4238 N4238 0 1e6
RG4239 N4239 0 1e6
RG4240 N4240 0 1e6
RG4241 N4241 0 1e6
RG4242 N4242 0 1e6
RG4243 N4243 0 1e6
RG4244 N4244 0 1e6
RG4245 N4245 0 1e6
RG4246 N4246 0 1e6
RG4247 N4247 0 1e6
RG4248 N4248 0 1e6
RG4249 N4249 0 1e6
RG4250 N4250 0 1e6
RG4251 N4251 0 1e6
RG4252 N4252 0 1e6
RG4253 N4253 0 1e6
RG4254 N4254 0 1e6
RG4255 N4255 0 1e6
RG4256 N4256 0 1e6
RG4257 N4257 0 1e6
RG4258 N4258 0 1e6
RG4259 N4259 0 1e6
RG4260 N4260 0 1e6
RG4261 N4261 0 1e6
RG4262 N4262 0 1e6
RG4263 N4263 0 1e6
RG4264 N4264 0 1e6
RG4265 N4265 0 1e6
RG4266 N4266 0 1e6
RG4267 N4267 0 1e6
RG4268 N4268 0 1e6
RG4269 N4269 0 1e6
RG4270 N4270 0 1e6
RG4271 N4271 0 1e6
RG4272 N4272 0 1e6
RG4273 N4273 0 1e6
RG4274 N4274 0 1e6
RG4275 N4275 0 1e6
RG4276 N4276 0 1e6
RG4277 N4277 0 1e6
RG4278 N4278 0 1e6
RG4279 N4279 0 1e6
RG4280 N4280 0 1e6
RG4281 N4281 0 1e6
RG4282 N4282 0 1e6
RG4283 N4283 0 1e6
RG4284 N4284 0 1e6
RG4285 N4285 0 1e6
RG4286 N4286 0 1e6
RG4287 N4287 0 1e6
RG4288 N4288 0 1e6
RG4289 N4289 0 1e6
RG4290 N4290 0 1e6
RG4291 N4291 0 1e6
RG4292 N4292 0 1e6
RG4293 N4293 0 1e6
RG4294 N4294 0 1e6
RG4295 N4295 0 1e6
RG4296 N4296 0 1e6
RG4297 N4297 0 1e6
RG4298 N4298 0 1e6
RG4299 N4299 0 1e6
RG4300 N4300 0 1e6
RG4301 N4301 0 1e6
RG4302 N4302 0 1e6
RG4303 N4303 0 1e6
RG4304 N4304 0 1e6
RG4305 N4305 0 1e6
RG4306 N4306 0 1e6
RG4307 N4307 0 1e6
RG4308 N4308 0 1e6
RG4309 N4309 0 1e6
RG4310 N4310 0 1e6
RG4311 N4311 0 1e6
RG4312 N4312 0 1e6
RG4313 N4313 0 1e6
RG4314 N4314 0 1e6
RG4315 N4315 0 1e6
RG4316 N4316 0 1e6
RG4317 N4317 0 1e6
RG4318 N4318 0 1e6
RG4319 N4319 0 1e6
RG4320 N4320 0 1e6
RG4321 N4321 0 1e6
RG4322 N4322 0 1e6
RG4323 N4323 0 1e6
RG4324 N4324 0 1e6
RG4325 N4325 0 1e6
RG4326 N4326 0 1e6
RG4327 N4327 0 1e6
RG4328 N4328 0 1e6
RG4329 N4329 0 1e6
RG4330 N4330 0 1e6
RG4331 N4331 0 1e6
RG4332 N4332 0 1e6
RG4333 N4333 0 1e6
RG4334 N4334 0 1e6
RG4335 N4335 0 1e6
RG4336 N4336 0 1e6
RG4337 N4337 0 1e6
RG4338 N4338 0 1e6
RG4339 N4339 0 1e6
RG4340 N4340 0 1e6
RG4341 N4341 0 1e6
RG4342 N4342 0 1e6
RG4343 N4343 0 1e6
RG4344 N4344 0 1e6
RG4345 N4345 0 1e6
RG4346 N4346 0 1e6
RG4347 N4347 0 1e6
RG4348 N4348 0 1e6
RG4349 N4349 0 1e6
RG4350 N4350 0 1e6
RG4351 N4351 0 1e6
RG4352 N4352 0 1e6
RG4353 N4353 0 1e6
RG4354 N4354 0 1e6
RG4355 N4355 0 1e6
RG4356 N4356 0 1e6
RG4357 N4357 0 1e6
RG4358 N4358 0 1e6
RG4359 N4359 0 1e6
RG4360 N4360 0 1e6
RG4361 N4361 0 1e6
RG4362 N4362 0 1e6
RG4363 N4363 0 1e6
RG4364 N4364 0 1e6
RG4365 N4365 0 1e6
RG4366 N4366 0 1e6
RG4367 N4367 0 1e6
RG4368 N4368 0 1e6
RG4369 N4369 0 1e6
RG4370 N4370 0 1e6
RG4371 N4371 0 1e6
RG4372 N4372 0 1e6
RG4373 N4373 0 1e6
RG4374 N4374 0 1e6
RG4375 N4375 0 1e6
RG4376 N4376 0 1e6
RG4377 N4377 0 1e6
RG4378 N4378 0 1e6
RG4379 N4379 0 1e6
RG4380 N4380 0 1e6
RG4381 N4381 0 1e6
RG4382 N4382 0 1e6
RG4383 N4383 0 1e6
RG4384 N4384 0 1e6
RG4385 N4385 0 1e6
RG4386 N4386 0 1e6
RG4387 N4387 0 1e6
RG4388 N4388 0 1e6
RG4389 N4389 0 1e6
RG4390 N4390 0 1e6
RG4391 N4391 0 1e6
RG4392 N4392 0 1e6
RG4393 N4393 0 1e6
RG4394 N4394 0 1e6
RG4395 N4395 0 1e6
RG4396 N4396 0 1e6
RG4397 N4397 0 1e6
RG4398 N4398 0 1e6
RG4399 N4399 0 1e6
RG4400 N4400 0 1e6
RG4401 N4401 0 1e6
RG4402 N4402 0 1e6
RG4403 N4403 0 1e6
RG4404 N4404 0 1e6
RG4405 N4405 0 1e6
RG4406 N4406 0 1e6
RG4407 N4407 0 1e6
RG4408 N4408 0 1e6
RG4409 N4409 0 1e6
RG4410 N4410 0 1e6
RG4411 N4411 0 1e6
RG4412 N4412 0 1e6
RG4413 N4413 0 1e6
RG4414 N4414 0 1e6
RG4415 N4415 0 1e6
RG4416 N4416 0 1e6
RG4417 N4417 0 1e6
RG4418 N4418 0 1e6
RG4419 N4419 0 1e6
RG4420 N4420 0 1e6
RG4421 N4421 0 1e6
RG4422 N4422 0 1e6
RG4423 N4423 0 1e6
RG4424 N4424 0 1e6
RG4425 N4425 0 1e6
RG4426 N4426 0 1e6
RG4427 N4427 0 1e6
RG4428 N4428 0 1e6
RG4429 N4429 0 1e6
RG4430 N4430 0 1e6
RG4431 N4431 0 1e6
RG4432 N4432 0 1e6
RG4433 N4433 0 1e6
RG4434 N4434 0 1e6
RG4435 N4435 0 1e6
RG4436 N4436 0 1e6
RG4437 N4437 0 1e6
RG4438 N4438 0 1e6
RG4439 N4439 0 1e6
RG4440 N4440 0 1e6
RG4441 N4441 0 1e6
RG4442 N4442 0 1e6
RG4443 N4443 0 1e6
RG4444 N4444 0 1e6
RG4445 N4445 0 1e6
RG4446 N4446 0 1e6
RG4447 N4447 0 1e6
RG4448 N4448 0 1e6
RG4449 N4449 0 1e6
RG4450 N4450 0 1e6
RG4451 N4451 0 1e6
RG4452 N4452 0 1e6
RG4453 N4453 0 1e6
RG4454 N4454 0 1e6
RG4455 N4455 0 1e6
RG4456 N4456 0 1e6
RG4457 N4457 0 1e6
RG4458 N4458 0 1e6
RG4459 N4459 0 1e6
RG4460 N4460 0 1e6
RG4461 N4461 0 1e6
RG4462 N4462 0 1e6
RG4463 N4463 0 1e6
RG4464 N4464 0 1e6
RG4465 N4465 0 1e6
RG4466 N4466 0 1e6
RG4467 N4467 0 1e6
RG4468 N4468 0 1e6
RG4469 N4469 0 1e6
RG4470 N4470 0 1e6
RG4471 N4471 0 1e6
RG4472 N4472 0 1e6
RG4473 N4473 0 1e6
RG4474 N4474 0 1e6
RG4475 N4475 0 1e6
RG4476 N4476 0 1e6
RG4477 N4477 0 1e6
RG4478 N4478 0 1e6
RG4479 N4479 0 1e6
RG4480 N4480 0 1e6
RG4481 N4481 0 1e6
RG4482 N4482 0 1e6
RG4483 N4483 0 1e6
RG4484 N4484 0 1e6
RG4485 N4485 0 1e6
RG4486 N4486 0 1e6
RG4487 N4487 0 1e6
RG4488 N4488 0 1e6
RG4489 N4489 0 1e6
RG4490 N4490 0 1e6
RG4491 N4491 0 1e6
RG4492 N4492 0 1e6
RG4493 N4493 0 1e6
RG4494 N4494 0 1e6
RG4495 N4495 0 1e6
RG4496 N4496 0 1e6
RG4497 N4497 0 1e6
RG4498 N4498 0 1e6
RG4499 N4499 0 1e6
RG4500 N4500 0 1e6
RG4501 N4501 0 1e6
RG4502 N4502 0 1e6
RG4503 N4503 0 1e6
RG4504 N4504 0 1e6
RG4505 N4505 0 1e6
RG4506 N4506 0 1e6
RG4507 N4507 0 1e6
RG4508 N4508 0 1e6
RG4509 N4509 0 1e6
RG4510 N4510 0 1e6
RG4511 N4511 0 1e6
RG4512 N4512 0 1e6
RG4513 N4513 0 1e6
RG4514 N4514 0 1e6
RG4515 N4515 0 1e6
RG4516 N4516 0 1e6
RG4517 N4517 0 1e6
RG4518 N4518 0 1e6
RG4519 N4519 0 1e6
RG4520 N4520 0 1e6
RG4521 N4521 0 1e6
RG4522 N4522 0 1e6
RG4523 N4523 0 1e6
RG4524 N4524 0 1e6
RG4525 N4525 0 1e6
RG4526 N4526 0 1e6
RG4527 N4527 0 1e6
RG4528 N4528 0 1e6
RG4529 N4529 0 1e6
RG4530 N4530 0 1e6
RG4531 N4531 0 1e6
RG4532 N4532 0 1e6
RG4533 N4533 0 1e6
RG4534 N4534 0 1e6
RG4535 N4535 0 1e6
RG4536 N4536 0 1e6
RG4537 N4537 0 1e6
RG4538 N4538 0 1e6
RG4539 N4539 0 1e6
RG4540 N4540 0 1e6
RG4541 N4541 0 1e6
RG4542 N4542 0 1e6
RG4543 N4543 0 1e6
RG4544 N4544 0 1e6
RG4545 N4545 0 1e6
RG4546 N4546 0 1e6
RG4547 N4547 0 1e6
RG4548 N4548 0 1e6
RG4549 N4549 0 1e6
RG4550 N4550 0 1e6
RG4551 N4551 0 1e6
RG4552 N4552 0 1e6
RG4553 N4553 0 1e6
RG4554 N4554 0 1e6
RG4555 N4555 0 1e6
RG4556 N4556 0 1e6
RG4557 N4557 0 1e6
RG4558 N4558 0 1e6
RG4559 N4559 0 1e6
RG4560 N4560 0 1e6
RG4561 N4561 0 1e6
RG4562 N4562 0 1e6
RG4563 N4563 0 1e6
RG4564 N4564 0 1e6
RG4565 N4565 0 1e6
RG4566 N4566 0 1e6
RG4567 N4567 0 1e6
RG4568 N4568 0 1e6
RG4569 N4569 0 1e6
RG4570 N4570 0 1e6
RG4571 N4571 0 1e6
RG4572 N4572 0 1e6
RG4573 N4573 0 1e6
RG4574 N4574 0 1e6
RG4575 N4575 0 1e6
RG4576 N4576 0 1e6
RG4577 N4577 0 1e6
RG4578 N4578 0 1e6
RG4579 N4579 0 1e6
RG4580 N4580 0 1e6
RG4581 N4581 0 1e6
RG4582 N4582 0 1e6
RG4583 N4583 0 1e6
RG4584 N4584 0 1e6
RG4585 N4585 0 1e6
RG4586 N4586 0 1e6
RG4587 N4587 0 1e6
RG4588 N4588 0 1e6
RG4589 N4589 0 1e6
RG4590 N4590 0 1e6
RG4591 N4591 0 1e6
RG4592 N4592 0 1e6
RG4593 N4593 0 1e6
RG4594 N4594 0 1e6
RG4595 N4595 0 1e6
RG4596 N4596 0 1e6
RG4597 N4597 0 1e6
RG4598 N4598 0 1e6
RG4599 N4599 0 1e6
RG4600 N4600 0 1e6
RG4601 N4601 0 1e6
RG4602 N4602 0 1e6
RG4603 N4603 0 1e6
RG4604 N4604 0 1e6
RG4605 N4605 0 1e6
RG4606 N4606 0 1e6
RG4607 N4607 0 1e6
RG4608 N4608 0 1e6
RG4609 N4609 0 1e6
RG4610 N4610 0 1e6
RG4611 N4611 0 1e6
RG4612 N4612 0 1e6
RG4613 N4613 0 1e6
RG4614 N4614 0 1e6
RG4615 N4615 0 1e6
RG4616 N4616 0 1e6
RG4617 N4617 0 1e6
RG4618 N4618 0 1e6
RG4619 N4619 0 1e6
RG4620 N4620 0 1e6
RG4621 N4621 0 1e6
RG4622 N4622 0 1e6
RG4623 N4623 0 1e6
RG4624 N4624 0 1e6
RG4625 N4625 0 1e6
RG4626 N4626 0 1e6
RG4627 N4627 0 1e6
RG4628 N4628 0 1e6
RG4629 N4629 0 1e6
RG4630 N4630 0 1e6
RG4631 N4631 0 1e6
RG4632 N4632 0 1e6
RG4633 N4633 0 1e6
RG4634 N4634 0 1e6
RG4635 N4635 0 1e6
RG4636 N4636 0 1e6
RG4637 N4637 0 1e6
RG4638 N4638 0 1e6
RG4639 N4639 0 1e6
RG4640 N4640 0 1e6
RG4641 N4641 0 1e6
RG4642 N4642 0 1e6
RG4643 N4643 0 1e6
RG4644 N4644 0 1e6
RG4645 N4645 0 1e6
RG4646 N4646 0 1e6
RG4647 N4647 0 1e6
RG4648 N4648 0 1e6
RG4649 N4649 0 1e6
RG4650 N4650 0 1e6
RG4651 N4651 0 1e6
RG4652 N4652 0 1e6
RG4653 N4653 0 1e6
RG4654 N4654 0 1e6
RG4655 N4655 0 1e6
RG4656 N4656 0 1e6
RG4657 N4657 0 1e6
RG4658 N4658 0 1e6
RG4659 N4659 0 1e6
RG4660 N4660 0 1e6
RG4661 N4661 0 1e6
RG4662 N4662 0 1e6
RG4663 N4663 0 1e6
RG4664 N4664 0 1e6
RG4665 N4665 0 1e6
RG4666 N4666 0 1e6
RG4667 N4667 0 1e6
RG4668 N4668 0 1e6
RG4669 N4669 0 1e6
RG4670 N4670 0 1e6
RG4671 N4671 0 1e6
RG4672 N4672 0 1e6
RG4673 N4673 0 1e6
RG4674 N4674 0 1e6
RG4675 N4675 0 1e6
RG4676 N4676 0 1e6
RG4677 N4677 0 1e6
RG4678 N4678 0 1e6
RG4679 N4679 0 1e6
RG4680 N4680 0 1e6
RG4681 N4681 0 1e6
RG4682 N4682 0 1e6
RG4683 N4683 0 1e6
RG4684 N4684 0 1e6
RG4685 N4685 0 1e6
RG4686 N4686 0 1e6
RG4687 N4687 0 1e6
RG4688 N4688 0 1e6
RG4689 N4689 0 1e6
RG4690 N4690 0 1e6
RG4691 N4691 0 1e6
RG4692 N4692 0 1e6
RG4693 N4693 0 1e6
RG4694 N4694 0 1e6
RG4695 N4695 0 1e6
RG4696 N4696 0 1e6
RG4697 N4697 0 1e6
RG4698 N4698 0 1e6
RG4699 N4699 0 1e6
RG4700 N4700 0 1e6
RG4701 N4701 0 1e6
RG4702 N4702 0 1e6
RG4703 N4703 0 1e6
RG4704 N4704 0 1e6
RG4705 N4705 0 1e6
RG4706 N4706 0 1e6
RG4707 N4707 0 1e6
RG4708 N4708 0 1e6
RG4709 N4709 0 1e6
RG4710 N4710 0 1e6
RG4711 N4711 0 1e6
RG4712 N4712 0 1e6
RG4713 N4713 0 1e6
RG4714 N4714 0 1e6
RG4715 N4715 0 1e6
RG4716 N4716 0 1e6
RG4717 N4717 0 1e6
RG4718 N4718 0 1e6
RG4719 N4719 0 1e6
RG4720 N4720 0 1e6
RG4721 N4721 0 1e6
RG4722 N4722 0 1e6
RG4723 N4723 0 1e6
RG4724 N4724 0 1e6
RG4725 N4725 0 1e6
RG4726 N4726 0 1e6
RG4727 N4727 0 1e6
RG4728 N4728 0 1e6
RG4729 N4729 0 1e6
RG4730 N4730 0 1e6
RG4731 N4731 0 1e6
RG4732 N4732 0 1e6
RG4733 N4733 0 1e6
RG4734 N4734 0 1e6
RG4735 N4735 0 1e6
RG4736 N4736 0 1e6
RG4737 N4737 0 1e6
RG4738 N4738 0 1e6
RG4739 N4739 0 1e6
RG4740 N4740 0 1e6
RG4741 N4741 0 1e6
RG4742 N4742 0 1e6
RG4743 N4743 0 1e6
RG4744 N4744 0 1e6
RG4745 N4745 0 1e6
RG4746 N4746 0 1e6
RG4747 N4747 0 1e6
RG4748 N4748 0 1e6
RG4749 N4749 0 1e6
RG4750 N4750 0 1e6
RG4751 N4751 0 1e6
RG4752 N4752 0 1e6
RG4753 N4753 0 1e6
RG4754 N4754 0 1e6
RG4755 N4755 0 1e6
RG4756 N4756 0 1e6
RG4757 N4757 0 1e6
RG4758 N4758 0 1e6
RG4759 N4759 0 1e6
RG4760 N4760 0 1e6
RG4761 N4761 0 1e6
RG4762 N4762 0 1e6
RG4763 N4763 0 1e6
RG4764 N4764 0 1e6
RG4765 N4765 0 1e6
RG4766 N4766 0 1e6
RG4767 N4767 0 1e6
RG4768 N4768 0 1e6
RG4769 N4769 0 1e6
RG4770 N4770 0 1e6
RG4771 N4771 0 1e6
RG4772 N4772 0 1e6
RG4773 N4773 0 1e6
RG4774 N4774 0 1e6
RG4775 N4775 0 1e6
RG4776 N4776 0 1e6
RG4777 N4777 0 1e6
RG4778 N4778 0 1e6
RG4779 N4779 0 1e6
RG4780 N4780 0 1e6
RG4781 N4781 0 1e6
RG4782 N4782 0 1e6
RG4783 N4783 0 1e6
RG4784 N4784 0 1e6
RG4785 N4785 0 1e6
RG4786 N4786 0 1e6
RG4787 N4787 0 1e6
RG4788 N4788 0 1e6
RG4789 N4789 0 1e6
RG4790 N4790 0 1e6
RG4791 N4791 0 1e6
RG4792 N4792 0 1e6
RG4793 N4793 0 1e6
RG4794 N4794 0 1e6
RG4795 N4795 0 1e6
RG4796 N4796 0 1e6
RG4797 N4797 0 1e6
RG4798 N4798 0 1e6
RG4799 N4799 0 1e6
RG4800 N4800 0 1e6
RG4801 N4801 0 1e6
RG4802 N4802 0 1e6
RG4803 N4803 0 1e6
RG4804 N4804 0 1e6
RG4805 N4805 0 1e6
RG4806 N4806 0 1e6
RG4807 N4807 0 1e6
RG4808 N4808 0 1e6
RG4809 N4809 0 1e6
RG4810 N4810 0 1e6
RG4811 N4811 0 1e6
RG4812 N4812 0 1e6
RG4813 N4813 0 1e6
RG4814 N4814 0 1e6
RG4815 N4815 0 1e6
RG4816 N4816 0 1e6
RG4817 N4817 0 1e6
RG4818 N4818 0 1e6
RG4819 N4819 0 1e6
RG4820 N4820 0 1e6
RG4821 N4821 0 1e6
RG4822 N4822 0 1e6
RG4823 N4823 0 1e6
RG4824 N4824 0 1e6
RG4825 N4825 0 1e6
RG4826 N4826 0 1e6
RG4827 N4827 0 1e6
RG4828 N4828 0 1e6
RG4829 N4829 0 1e6
RG4830 N4830 0 1e6
RG4831 N4831 0 1e6
RG4832 N4832 0 1e6
RG4833 N4833 0 1e6
RG4834 N4834 0 1e6
RG4835 N4835 0 1e6
RG4836 N4836 0 1e6
RG4837 N4837 0 1e6
RG4838 N4838 0 1e6
RG4839 N4839 0 1e6
RG4840 N4840 0 1e6
RG4841 N4841 0 1e6
RG4842 N4842 0 1e6
RG4843 N4843 0 1e6
RG4844 N4844 0 1e6
RG4845 N4845 0 1e6
RG4846 N4846 0 1e6
RG4847 N4847 0 1e6
RG4848 N4848 0 1e6
RG4849 N4849 0 1e6
RG4850 N4850 0 1e6
RG4851 N4851 0 1e6
RG4852 N4852 0 1e6
RG4853 N4853 0 1e6
RG4854 N4854 0 1e6
RG4855 N4855 0 1e6
RG4856 N4856 0 1e6
RG4857 N4857 0 1e6
RG4858 N4858 0 1e6
RG4859 N4859 0 1e6
RG4860 N4860 0 1e6
RG4861 N4861 0 1e6
RG4862 N4862 0 1e6
RG4863 N4863 0 1e6
RG4864 N4864 0 1e6
RG4865 N4865 0 1e6
RG4866 N4866 0 1e6
RG4867 N4867 0 1e6
RG4868 N4868 0 1e6
RG4869 N4869 0 1e6
RG4870 N4870 0 1e6
RG4871 N4871 0 1e6
RG4872 N4872 0 1e6
RG4873 N4873 0 1e6
RG4874 N4874 0 1e6
RG4875 N4875 0 1e6
RG4876 N4876 0 1e6
RG4877 N4877 0 1e6
RG4878 N4878 0 1e6
RG4879 N4879 0 1e6
RG4880 N4880 0 1e6
RG4881 N4881 0 1e6
RG4882 N4882 0 1e6
RG4883 N4883 0 1e6
RG4884 N4884 0 1e6
RG4885 N4885 0 1e6
RG4886 N4886 0 1e6
RG4887 N4887 0 1e6
RG4888 N4888 0 1e6
RG4889 N4889 0 1e6
RG4890 N4890 0 1e6
RG4891 N4891 0 1e6
RG4892 N4892 0 1e6
RG4893 N4893 0 1e6
RG4894 N4894 0 1e6
RG4895 N4895 0 1e6
RG4896 N4896 0 1e6
RG4897 N4897 0 1e6
RG4898 N4898 0 1e6
RG4899 N4899 0 1e6
RG4900 N4900 0 1e6
RG4901 N4901 0 1e6
RG4902 N4902 0 1e6
RG4903 N4903 0 1e6
RG4904 N4904 0 1e6
RG4905 N4905 0 1e6
RG4906 N4906 0 1e6
RG4907 N4907 0 1e6
RG4908 N4908 0 1e6
RG4909 N4909 0 1e6
RG4910 N4910 0 1e6
RG4911 N4911 0 1e6
RG4912 N4912 0 1e6
RG4913 N4913 0 1e6
RG4914 N4914 0 1e6
RG4915 N4915 0 1e6
RG4916 N4916 0 1e6
RG4917 N4917 0 1e6
RG4918 N4918 0 1e6
RG4919 N4919 0 1e6
RG4920 N4920 0 1e6
RG4921 N4921 0 1e6
RG4922 N4922 0 1e6
RG4923 N4923 0 1e6
RG4924 N4924 0 1e6
RG4925 N4925 0 1e6
RG4926 N4926 0 1e6
RG4927 N4927 0 1e6
RG4928 N4928 0 1e6
RG4929 N4929 0 1e6
RG4930 N4930 0 1e6
RG4931 N4931 0 1e6
RG4932 N4932 0 1e6
RG4933 N4933 0 1e6
RG4934 N4934 0 1e6
RG4935 N4935 0 1e6
RG4936 N4936 0 1e6
RG4937 N4937 0 1e6
RG4938 N4938 0 1e6
RG4939 N4939 0 1e6
RG4940 N4940 0 1e6
RG4941 N4941 0 1e6
RG4942 N4942 0 1e6
RG4943 N4943 0 1e6
RG4944 N4944 0 1e6
RG4945 N4945 0 1e6
RG4946 N4946 0 1e6
RG4947 N4947 0 1e6
RG4948 N4948 0 1e6
RG4949 N4949 0 1e6
RG4950 N4950 0 1e6
RG4951 N4951 0 1e6
RG4952 N4952 0 1e6
RG4953 N4953 0 1e6
RG4954 N4954 0 1e6
RG4955 N4955 0 1e6
RG4956 N4956 0 1e6
RG4957 N4957 0 1e6
RG4958 N4958 0 1e6
RG4959 N4959 0 1e6
RG4960 N4960 0 1e6
RG4961 N4961 0 1e6
RG4962 N4962 0 1e6
RG4963 N4963 0 1e6
RG4964 N4964 0 1e6
RG4965 N4965 0 1e6
RG4966 N4966 0 1e6
RG4967 N4967 0 1e6
RG4968 N4968 0 1e6
RG4969 N4969 0 1e6
RG4970 N4970 0 1e6
RG4971 N4971 0 1e6
RG4972 N4972 0 1e6
RG4973 N4973 0 1e6
RG4974 N4974 0 1e6
RG4975 N4975 0 1e6
RG4976 N4976 0 1e6
RG4977 N4977 0 1e6
RG4978 N4978 0 1e6
RG4979 N4979 0 1e6
RG4980 N4980 0 1e6
RG4981 N4981 0 1e6
RG4982 N4982 0 1e6
RG4983 N4983 0 1e6
RG4984 N4984 0 1e6
RG4985 N4985 0 1e6
RG4986 N4986 0 1e6
RG4987 N4987 0 1e6
RG4988 N4988 0 1e6
RG4989 N4989 0 1e6
RG4990 N4990 0 1e6
RG4991 N4991 0 1e6
RG4992 N4992 0 1e6
RG4993 N4993 0 1e6
RG4994 N4994 0 1e6
RG4995 N4995 0 1e6
RG4996 N4996 0 1e6
RG4997 N4997 0 1e6
RG4998 N4998 0 1e6
RG4999 N4999 0 1e6
RG5000 N5000 0 1e6
V1 N1 0 7
V2 N21 0 9
V3 N41 0 5
V4 N61 0 7
V5 N81 0 9
V6 N101 0 5
V7 N121 0 7
V8 N141 0 9
V9 N161 0 5
V10 N181 0 7
V11 N201 0 9
V12 N221 0 5
V13 N241 0 7
V14 N261 0 9
V15 N281 0 5
V16 N301 0 7
V17 N321 0 9
V18 N341 0 5
V19 N361 0 7
V20 N381 0 9
V21 N401 0 5
V22 N421 0 7
V23 N441 0 9
V24 N461 0 5
V25 N481 0 7
V26 N501 0 9
V27 N521 0 5
V28 N541 0 7
V29 N561 0 9
V30 N581 0 5
V31 N601 0 7
V32 N621 0 9
V33 N641 0 5
V34 N661 0 7
V35 N681 0 9
V36 N701 0 5
V37 N721 0 7
V38 N741 0 9
V39 N761 0 5
V40 N781 0 7
V41 N801 0 9
V42 N821 0 5
V43 N841 0 7
V44 N861 0 9
V45 N881 0 5
V46 N901 0 7
V47 N921 0 9
V48 N941 0 5
V49 N961 0 7
V50 N981 0 9
V51 N1001 0 5
V52 N1021 0 7
V53 N1041 0 9
V54 N1061 0 5
V55 N1081 0 7
V56 N1101 0 9
V57 N1121 0 5
V58 N1141 0 7
V59 N1161 0 9
V60 N1181 0 5
V61 N1201 0 7
V62 N1221 0 9
V63 N1241 0 5
V64 N1261 0 7
V65 N1281 0 9
V66 N1301 0 5
V67 N1321 0 7
V68 N1341 0 9
V69 N1361 0 5
V70 N1381 0 7
V71 N1401 0 9
V72 N1421 0 5
V73 N1441 0 7
V74 N1461 0 9
V75 N1481 0 5
V76 N1501 0 7
V77 N1521 0 9
V78 N1541 0 5
V79 N1561 0 7
V80 N1581 0 9
V81 N1601 0 5
V82 N1621 0 7
V83 N1641 0 9
V84 N1661 0 5
V85 N1681 0 7
V86 N1701 0 9
V87 N1721 0 5
V88 N1741 0 7
V89 N1761 0 9
V90 N1781 0 5
V91 N1801 0 7
V92 N1821 0 9
V93 N1841 0 5
V94 N1861 0 7
V95 N1881 0 9
V96 N1901 0 5
V97 N1921 0 7
V98 N1941 0 9
V99 N1961 0 5
V100 N1981 0 7
V101 N2001 0 9
V102 N2021 0 5
V103 N2041 0 7
V104 N2061 0 9
V105 N2081 0 5
V106 N2101 0 7
V107 N2121 0 9
V108 N2141 0 5
V109 N2161 0 7
V110 N2181 0 9
V111 N2201 0 5
V112 N2221 0 7
V113 N2241 0 9
V114 N2261 0 5
V115 N2281 0 7
V116 N2301 0 9
V117 N2321 0 5
V118 N2341 0 7
V119 N2361 0 9
V120 N2381 0 5
V121 N2401 0 7
V122 N2421 0 9
V123 N2441 0 5
V124 N2461 0 7
V125 N2481 0 9
V126 N2501 0 5
V127 N2521 0 7
V128 N2541 0 9
V129 N2561 0 5
V130 N2581 0 7
V131 N2601 0 9
V132 N2621 0 5
V133 N2641 0 7
V134 N2661 0 9
V135 N2681 0 5
V136 N2701 0 7
V137 N2721 0 9
V138 N2741 0 5
V139 N2761 0 7
V140 N2781 0 9
V141 N2801 0 5
V142 N2821 0 7
V143 N2841 0 9
V144 N2861 0 5
V145 N2881 0 7
V146 N2901 0 9
V147 N2921 0 5
V148 N2941 0 7
V149 N2961 0 9
V150 N2981 0 5
V151 N3001 0 7
V152 N3021 0 9
V153 N3041 0 5
V154 N3061 0 7
V155 N3081 0 9
V156 N3101 0 5
V157 N3121 0 7
V158 N3141 0 9
V159 N3161 0 5
V160 N3181 0 7
V161 N3201 0 9
V162 N3221 0 5
V163 N3241 0 7
V164 N3261 0 9
V165 N3281 0 5
V166 N3301 0 7
V167 N3321 0 9
V168 N3341 0 5
V169 N3361 0 7
V170 N3381 0 9
V171 N3401 0 5
V172 N3421 0 7
V173 N3441 0 9
V174 N3461 0 5
V175 N3481 0 7
V176 N3501 0 9
V177 N3521 0 5
V178 N3541 0 7
V179 N3561 0 9
V180 N3581 0 5
V181 N3601 0 7
V182 N3621 0 9
V183 N3641 0 5
V184 N3661 0 7
V185 N3681 0 9
V186 N3701 0 5
V187 N3721 0 7
V188 N3741 0 9
V189 N3761 0 5
V190 N3781 0 7
V191 N3801 0 9
V192 N3821 0 5
V193 N3841 0 7
V194 N3861 0 9
V195 N3881 0 5
V196 N3901 0 7
V197 N3921 0 9
V198 N3941 0 5
V199 N3961 0 7
V200 N3981 0 9
V201 N4001 0 5
V202 N4021 0 7
V203 N4041 0 9
V204 N4061 0 5
V205 N4081 0 7
V206 N4101 0 9
V207 N4121 0 5
V208 N4141 0 7
V209 N4161 0 9
V210 N4181 0 5
V211 N4201 0 7
V212 N4221 0 9
V213 N4241 0 5
V214 N4261 0 7
V215 N4281 0 9
V216 N4301 0 5
V217 N4321 0 7
V218 N4341 0 9
V219 N4361 0 5
V220 N4381 0 7
V221 N4401 0 9
V222 N4421 0 5
V223 N4441 0 7
V224 N4461 0 9
V225 N4481 0 5
V226 N4501 0 7
V227 N4521 0 9
V228 N4541 0 5
V229 N4561 0 7
V230 N4581 0 9
V231 N4601 0 5
V232 N4621 0 7
V233 N4641 0 9
V234 N4661 0 5
V235 N4681 0 7
V236 N4701 0 9
V237 N4721 0 5
V238 N4741 0 7
V239 N4761 0 9
V240 N4781 0 5
V241 N4801 0 7
V242 N4821 0 9
V243 N4841 0 5
V244 N4861 0 7
V245 N4881 0 9
V246 N4901 0 5
V247 N4921 0 7
V248 N4941 0 9
V249 N4961 0 5
V250 N4981 0 7
I1 N1 0 0.0004
I2 N31 0 0.0002
I3 N61 0 0.0006
I4 N91 0 0.0006
I5 N121 0 0.0007
I6 N151 0 0.0005
I7 N181 0 0.0003
I8 N211 0 0.0006
I9 N241 0 0.0007
I10 N271 0 0.0010
I11 N301 0 0.0001
I12 N331 0 0.0001
I13 N361 0 0.0007
I14 N391 0 0.0002
I15 N421 0 0.0009
I16 N451 0 0.0008
I17 N481 0 0.0010
I18 N511 0 0.0005
I19 N541 0 0.0004
I20 N571 0 0.0006
I21 N601 0 0.0007
I22 N631 0 0.0001
I23 N661 0 0.0003
I24 N691 0 0.0004
I25 N721 0 0.0008
I26 N751 0 0.0004
I27 N781 0 0.0006
I28 N811 0 0.0004
I29 N841 0 0.0001
I30 N871 0 0.0007
I31 N901 0 0.0004
I32 N931 0 0.0008
I33 N961 0 0.0007
I34 N991 0 0.0001
I35 N1021 0 0.0003
I36 N1051 0 0.0004
I37 N1081 0 0.0004
I38 N1111 0 0.0007
I39 N1141 0 0.0009
I40 N1171 0 0.0008
I41 N1201 0 0.0007
I42 N1231 0 0.0005
I43 N1261 0 0.0007
I44 N1291 0 0.0009
I45 N1321 0 0.0006
I46 N1351 0 0.0004
I47 N1381 0 0.0008
I48 N1411 0 0.0005
I49 N1441 0 0.0008
I50 N1471 0 0.0009
I51 N1501 0 0.0004
I52 N1531 0 0.0008
I53 N1561 0 0.0004
I54 N1591 0 0.0006
I55 N1621 0 0.0003
I56 N1651 0 0.0007
I57 N1681 0 0.0008
I58 N1711 0 0.0009
I59 N1741 0 0.0004
I60 N1771 0 0.0010
I61 N1801 0 0.0004
I62 N1831 0 0.0001
I63 N1861 0 0.0010
I64 N1891 0 0.0007
I65 N1921 0 0.0009
I66 N1951 0 0.0006
I67 N1981 0 0.0005
I68 N2011 0 0.0006
I69 N2041 0 0.0009
I70 N2071 0 0.0008
I71 N2101 0 0.0007
I72 N2131 0 0.0004
I73 N2161 0 0.0001
I74 N2191 0 0.0005
I75 N2221 0 0.0005
I76 N2251 0 0.0003
I77 N2281 0 0.0005
I78 N2311 0 0.0010
I79 N2341 0 0.0003
I80 N2371 0 0.0004
I81 N2401 0 0.0002
I82 N2431 0 0.0008
I83 N2461 0 0.0008
I84 N2491 0 0.0009
I85 N2521 0 0.0005
I86 N2551 0 0.0001
I87 N2581 0 0.0005
I88 N2611 0 0.0006
I89 N2641 0 0.0003
I90 N2671 0 0.0009
I91 N2701 0 0.0008
I92 N2731 0 0.0006
I93 N2761 0 0.0008
I94 N2791 0 0.0002
I95 N2821 0 0.0009
I96 N2851 0 0.0008
I97 N2881 0 0.0009
I98 N2911 0 0.0007
I99 N2941 0 0.0002
I100 N2971 0 0.0008
I101 N3001 0 0.0005
I102 N3031 0 0.0007
I103 N3061 0 0.0006
I104 N3091 0 0.0001
I105 N3121 0 0.0009
I106 N3151 0 0.0007
I107 N3181 0 0.0006
I108 N3211 0 0.0002
I109 N3241 0 0.0005
I110 N3271 0 0.0001
I111 N3301 0 0.0006
I112 N3331 0 0.0007
I113 N3361 0 0.0004
I114 N3391 0 0.0006
I115 N3421 0 0.0004
I116 N3451 0 0.0009
I117 N3481 0 0.0004
I118 N3511 0 0.0003
I119 N3541 0 0.0003
I120 N3571 0 0.0004
I121 N3601 0 0.0005
I122 N3631 0 0.0002
I123 N3661 0 0.0002
I124 N3691 0 0.0003
I125 N3721 0 0.0001
I126 N3751 0 0.0007
I127 N3781 0 0.0006
I128 N3811 0 0.0003
I129 N3841 0 0.0004
I130 N3871 0 0.0004
I131 N3901 0 0.0002
I132 N3931 0 0.0007
I133 N3961 0 0.0004
I134 N3991 0 0.0003
I135 N4021 0 0.0002
I136 N4051 0 0.0007
I137 N4081 0 0.0004
I138 N4111 0 0.0005
I139 N4141 0 0.0002
I140 N4171 0 0.0005
I141 N4201 0 0.0007
I142 N4231 0 0.0002
I143 N4261 0 0.0001
I144 N4291 0 0.0005
I145 N4321 0 0.0003
I146 N4351 0 0.0006
I147 N4381 0 0.0006
I148 N4411 0 0.0009
I149 N4441 0 0.0007
I150 N4471 0 0.0007
.DC V1 -5 5 0.1
.PLOT V(N11)
.DC V2 0 10 0.5
.PLOT V(N11)
