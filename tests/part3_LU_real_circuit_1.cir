*** Copyright (C) 2000-2021 Helic, Inc.
*** Detailed model extracted by VeloceRaptor(TM) v5.6.0_b210705_r0_g6c6352c9-2021.R2.2
*** @ Wed May 11 13:49:42 2022

*** Extraction Time: 10 sec
***
*** Extraction temperature (if applicable)(Celsius): 27
***
***

V1 sbPin_1 0 5
V2 sbPin_2 0 10
R0_0 n0_2 n0_3 0.0159297116069809
R0_1 n0_19 n0_4 0.01128043890583305
R0_4 n0_21 n0_2 0.01128043890583305
R0_2 n0_22 n0_2 0.01128043890583305
R0_3 n0_20 n0_4 0.01128043890583305
R0_5 n0_20 n0_21 0.005017540027479075
R0_6 n0_19 n0_22 0.005017540027479075
R0_7 n0_4 n0_2 0.002508770013739537
R0_8 n0_23 n0_3 0.007515772264534882
R0_9 n0_25 n0_29 0.007515772264534885
R0_10 n0_24 n0_3 0.007515772264534879
R0_11 n0_27 n0_28 0.003757886132267443
R0_12 n0_26 n0_29 0.007515772264534888
R0_13 n0_5 n0_28 0.003757886132267441
R0_14 n0_24 n0_5 0.007515772264534901
R0_15 n0_26 n0_27 0.007515772264534886
R0_16 n0_25 n0_5 0.007515772264534886
R0_17 n0_23 n0_27 0.007515772264534901
R0_18 n0_3 n0_28 0.003757886132267451
R0_19 n0_28 n0_29 0.003757886132267443
R0_20 n0_6 sbPin_2 0.003797809752579285
R0_21 sbPin_2 n0_4 0.009960162357860002
R0_22 n0_7 n0_8 0.1233271845535714
R0_23 n0_9 n0_10 0.09343028508928571
R0_24 n0_8 n0_16 0.1233271845535714
R0_25 n0_17 n0_7 0.1382754903285715
R0_26 n0_10 n0_14 0.09343028508928571
R0_27 n0_15 n0_9 0.1083787828071429
R0_28 n0_11 sbPin_1 0.01772899970114286
R0_29 sbPin_1 n0_12 0.005823134956969992
R0_30 n0_13 n0_5 0.03363533450357143
R0_31 n0_18 n0_11 0.06913929870178573
R0_32 n0_13 n0_14 0.07848194332500001
R0_33 n0_15 n0_16 0.1083787828071429
R0_34 n0_17 n0_18 0.1382754903285715
C_16_17_0_0 n0_16 n0_18 7.586181672210153e-15
C_16_17_1_0 n0_15 n0_17 7.029757531795311e-15
C_5_12_0_0 n0_8 sbPin_1 2.541271206558531e-19
C_5_12_1_0 n0_8 n0_12 2.360105955872654e-19
C_5_14_0_0 n0_8 n0_11 1.18024614283051e-18
C_5_6_0_0 n0_7 n0_9 6.633242115100736e-15
C_5_6_1_0 n0_8 n0_10 6.448331956921556e-15
C_5_7_0_0 n0_8 n0_16 4.399556579260339e-17
C_5_7_1_0 n0_7 n0_8 5.547938475227632e-16
C_4_8_0_0 n0_4 n0_17 1.650407680463776e-16
C_4_8_1_0 sbPin_2 n0_17 1.918482800106841e-16
C_4_10_0_0 n0_4 n0_15 2.275885388849684e-17
C_4_13_0_0 n0_4 n0_5 1.240198813533751e-18
C_3_6_0_0 sbPin_2 n0_9 6.141261838362586e-19
C_3_6_1_0 n0_6 n0_9 5.736049612260978e-19
C_3_8_1_0 n0_6 n0_17 3.266084402643229e-17
C_3_10_0_0 sbPin_2 n0_15 5.559708877473442e-18
C_3_10_1_0 n0_6 n0_15 5.229028311080613e-18
C_2_17_0_0 n0_24 n0_17 6.033700391899283e-18
C_2_9_0_0 n0_25 n0_14 3.589855085113704e-18
C_2_7_0_0 n0_25 n0_16 1.191584563091536e-18
C_2_16_0_0 n0_24 n0_15 3.075693204920959e-16
C_2_5_0_0 n0_23 n0_7 6.862389940107653e-18
C_2_6_0_0 n0_23 n0_9 3.13157902027518e-16
C_2_13_0_0 n0_23 n0_5 2.893371298125348e-16
C_2_13_1_0 n0_25 n0_5 2.893371298125348e-16
C_0_13_0_0 n0_3 n0_5 1.511193126514797e-16
C_0_1_0_0 n0_2 n0_21 1.968641509210337e-16
C_0_8_0_0 n0_2 n0_17 1.286020702796484e-14
C_0_2_0_0 n0_3 n0_24 3.725998236612863e-16
C_0_4_0_0 n0_2 n0_4 1.446793862828429e-17
C_0_10_0_0 n0_3 n0_15 6.59018249460095e-15
C_0_10_1_0 n0_2 n0_15 6.493710814797576e-15
C_1_6_0_0 n0_22 n0_9 3.975098330314756e-18
C_1_6_1_0 n0_19 n0_9 3.789448867074022e-18
C_1_2_0_0 n0_22 n0_23 9.950387352567122e-19
C_1_2_1_0 n0_21 n0_24 9.950387352567122e-19
C_1_3_0_0 n0_20 sbPin_2 2.814417450224727e-17
C_1_10_1_0 n0_21 n0_15 3.357152218094387e-18
C_1_10_3_0 n0_20 n0_15 3.219663834232035e-18
C_1_8_0_0 n0_22 n0_7 3.389937757475559e-16
C_1_8_1_0 n0_21 n0_17 3.389937757475559e-16
C_1_8_2_0 n0_19 n0_7 3.372191734673572e-16
C_1_8_3_0 n0_20 n0_17 3.372191734673572e-16
C_1_4_0_0 n0_21 n0_4 3.304989349563841e-16
C_6_15_0_0 n0_9 n0_13 5.976361475948681e-19
C_6_15_1_0 n0_10 n0_14 5.955572548589243e-17
C_6_13_0_0 n0_9 n0_5 2.577664141830476e-18
C_6_9_1_0 n0_9 n0_10 5.47986570257721e-16
C_6_11_0_0 n0_10 n0_11 3.886340757430657e-18
C_7_16_0_0 n0_16 n0_15 1.341392774436318e-16
C_7_9_0_0 n0_16 n0_14 5.980883714695894e-15
C_7_11_0_0 n0_16 n0_11 2.543114613050556e-16
C_7_12_0_0 n0_16 sbPin_1 1.644500069223991e-17
C_8_17_0_0 n0_7 n0_17 1.522205899765672e-16
C_8_17_1_0 n0_17 n0_18 1.522205899765672e-16
C_9_17_0_0 n0_14 n0_18 5.607276520306693e-17
C_9_15_0_0 n0_14 n0_13 1.93797521291635e-16
C_9_10_1_0 n0_14 n0_15 1.22225573561709e-18
C_9_11_0_0 n0_14 n0_11 4.79040151976053e-17
C_9_12_0_0 n0_14 sbPin_1 1.316394924051311e-18
C_10_16_0_0 n0_9 n0_15 1.127698269404992e-16
C_10_15_0_0 n0_15 n0_13 5.361868721991105e-15
C_11_14_0_0 sbPin_1 n0_11 1.330081999011457e-16
C_12_16_1_0 n0_12 n0_16 4.45431654734233e-19
C_13_17_0_0 n0_13 n0_17 5.013463609828433e-17
C_13_15_0_0 n0_5 n0_13 4.072456249134374e-16
C_14_17_0_0 n0_11 n0_18 6.001769090143761e-17
C_0_sub_0_0 n0_5 sn_0 1.433400928731731e-15
C_0_sub_1_0 n0_13 sn_0 1.433400928731731e-15
C_1_sub_0_0 n0_12 sn_1 9.368564221781624e-16
C_1_sub_1_0 sbPin_1 sn_1 9.368564221781624e-16
C_2_sub_0_0 n0_14 sn_2 5.173419611653903e-15
C_2_sub_1_0 n0_10 sn_2 5.173419611653903e-15
C_3_sub_0_0 n0_8 sn_3 7.603318876395558e-15
C_3_sub_1_0 n0_7 sn_3 7.603318876395558e-15
C_4_sub_0_0 n0_16 sn_4 6.818393636173835e-15
C_4_sub_1_0 n0_8 sn_4 6.818393636173835e-15
C_5_sub_0_0 n0_3 sn_5 2.706247722884624e-15
C_5_sub_1_0 n0_2 sn_5 2.706247722884624e-15
C_6_sub_0_0 n0_18 sn_6 8.624095865745651e-15
C_6_sub_1_0 n0_17 sn_6 8.624095865745651e-15
C_7_sub_0_0 n0_14 sn_7 4.568957206384862e-15
C_7_sub_1_0 n0_13 sn_7 4.568957206384862e-15
C_8_sub_0_0 n0_19 sn_8 3.005582086029504e-16
C_8_sub_1_0 n0_22 sn_8 3.005582086029504e-16
C_8_sub_2_0 n0_21 sn_8 3.005582086029504e-16
C_8_sub_3_0 n0_20 sn_8 3.005582086029504e-16
C_9_sub_0_0 n0_9 sn_9 4.711648508886518e-15
C_9_sub_1_0 n0_15 sn_9 4.711648508886518e-15
C_10_sub_0_0 n0_10 sn_10 5.451557312506012e-15
C_10_sub_1_0 n0_9 sn_10 5.451557312506012e-15
C_11_sub_0_0 n0_16 sn_11 5.054319808760257e-15
C_11_sub_1_0 n0_15 sn_11 5.054319808760257e-15
C_12_sub_0_0 n0_7 sn_12 7.384716657347536e-15
C_12_sub_1_0 n0_17 sn_12 7.384716657347536e-15
C_13_sub_0_0 n0_4 sn_13 5.214626105127046e-16
C_13_sub_1_0 sbPin_2 sn_13 5.214626105127046e-16
C_14_sub_0_0 sbPin_1 sn_14 1.022589455580594e-15
C_14_sub_1_0 n0_11 sn_14 1.022589455580594e-15
C_15_sub_0_0 sbPin_2 sn_15 7.937944725145088e-16
C_15_sub_1_0 n0_6 sn_15 7.937944725145088e-16
C_16_sub_0_0 n0_11 sn_16 4.051366120124061e-15
C_16_sub_1_0 n0_18 sn_16 4.051366120124061e-15
C_17_sub_0_0 n0_24 sn_17 8.920214373616632e-16
C_17_sub_1_0 n0_23 sn_17 8.920214373616632e-16
C_17_sub_2_0 n0_26 sn_17 8.920214373616632e-16
C_17_sub_3_0 n0_25 sn_17 8.920214373616632e-16
Rsub_5_16 sn_5 sn_16 535569.0366085966
Csub_5_16 sn_5 sn_16 1.967343662910493e-17
Rsub_5_11 sn_5 sn_11 96657.25538079793
Csub_5_11 sn_5 sn_11 1.090087180803935e-16
Rsub_5_18 sn_5 0 58753.79130246133
Csub_5_18 sn_5 0 1.79332827187079e-16
Rsub_5_13 sn_5 sn_13 10908.0532722276
Csub_5_13 sn_5 sn_13 9.659361977133324e-16
Rsub_5_7 sn_5 sn_7 36196.55317720935
Csub_5_7 sn_5 sn_7 2.910907967022714e-16
Rsub_5_8 sn_5 sn_8 2551.682472498132
Csub_5_8 sn_5 sn_8 4.129229877067987e-15
Rsub_5_12 sn_5 sn_12 1628.159715829464
Csub_5_12 sn_5 sn_12 6.471406582407797e-15
Rsub_5_10 sn_5 sn_10 18375.24641577394
Csub_5_10 sn_5 sn_10 5.734063785498475e-16
Rsub_5_17 sn_5 sn_17 2888.723906491173
Csub_5_17 sn_5 sn_17 3.647452592666871e-15
Rsub_5_6 sn_5 sn_6 31695.80159073698
Csub_5_6 sn_5 sn_6 3.324252100729095e-16
Rsub_5_15 sn_5 sn_15 30614.44832402663
Csub_5_15 sn_5 sn_15 3.441670217509955e-16
Rsub_5_9 sn_5 sn_9 1688.055788303835
Csub_5_9 sn_5 sn_9 6.24178630542602e-15
Rsub_8_16 sn_8 sn_16 306221.5501120145
Csub_8_16 sn_8 sn_16 3.440804051307232e-17
Rsub_8_11 sn_8 sn_11 106608.1561192447
Csub_8_11 sn_8 sn_11 9.88337467392701e-17
Rsub_8_9 sn_8 sn_9 44704.15939052474
Csub_8_9 sn_8 sn_9 2.356935830106059e-16
Rsub_8_17 sn_8 sn_17 176010.5607989324
Csub_8_17 sn_8 sn_17 5.986279149616748e-17
Rsub_8_10 sn_8 sn_10 225649.7372106634
Csub_8_10 sn_8 sn_10 4.669397639224054e-17
Rsub_8_15 sn_8 sn_15 2809.797963170157
Csub_8_15 sn_8 sn_15 3.74990787250134e-15
Rsub_8_13 sn_8 sn_13 1233.162415441048
Csub_8_13 sn_8 sn_13 8.544278815423974e-15
Rsub_8_18 sn_8 0 101553.3794316317
Csub_8_18 sn_8 0 1.037531548551117e-16
Rsub_8_12 sn_8 sn_12 3249.449452818643
Csub_8_12 sn_8 sn_12 3.242544207939725e-15
Rsub_4_5 sn_4 sn_5 171316.3319142657
Csub_4_5 sn_4 sn_5 6.150308837748714e-17
Rsub_4_12 sn_4 sn_12 27690.39607274099
Csub_4_12 sn_4 sn_12 3.805103933707304e-16
Rsub_4_9 sn_4 sn_9 92320.17619256573
Csub_4_9 sn_4 sn_9 1.141298027882065e-16
Rsub_4_15 sn_4 sn_15 50931.57915751674
Csub_4_15 sn_4 sn_15 2.068752565013484e-16
Rsub_4_18 sn_4 0 11202.50110654264
Csub_4_18 sn_4 0 9.405474190113079e-16
Rsub_4_17 sn_4 sn_17 20789.6853445723
Csub_4_17 sn_4 sn_17 5.068130338480967e-16
Rsub_4_14 sn_4 sn_14 680.1328719025761
Csub_4_14 sn_4 sn_14 1.549180158394002e-14
Rsub_4_7 sn_4 sn_7 3628.054617476194
Csub_4_7 sn_4 sn_7 2.904168931602127e-15
Rsub_4_11 sn_4 sn_11 1459.760238846725
Csub_4_11 sn_4 sn_11 7.21795485439053e-15
Rsub_4_10 sn_4 sn_10 2474.99848885199
Csub_4_10 sn_4 sn_10 4.257167650682999e-15
Rsub_4_8 sn_4 sn_8 121792.1745092913
Csub_4_8 sn_4 sn_8 8.651199097710663e-17
Rsub_4_13 sn_4 sn_13 137645.3529506778
Csub_4_13 sn_4 sn_13 7.654805103377167e-17
Rsub_4_6 sn_4 sn_6 1837.655637552645
Csub_4_6 sn_4 sn_6 5.733655036839379e-15
Rsub_4_16 sn_4 sn_16 375.2147491317529
Csub_4_16 sn_4 sn_16 2.808120823238274e-14
Rsub_2_13 sn_2 sn_13 41404.62055406025
Csub_2_13 sn_2 sn_13 2.544760309655045e-16
Rsub_2_6 sn_2 sn_6 4575.474799235999
Csub_2_6 sn_2 sn_6 2.302817513930872e-15
Rsub_2_7 sn_2 sn_7 395.1615137612461
Csub_2_7 sn_2 sn_7 2.6663739092254e-14
Rsub_2_4 sn_2 sn_4 182.8975786835259
Csub_2_4 sn_2 sn_4 5.760865495361012e-14
Rsub_2_3 sn_2 sn_3 1666.226734823837
Csub_2_3 sn_2 sn_3 6.323559262385728e-15
Rsub_2_10 sn_2 sn_10 514.5952753313538
Csub_2_10 sn_2 sn_10 2.047528224087451e-14
Rsub_2_17 sn_2 sn_17 3613.922550267502
Csub_2_17 sn_2 sn_17 2.91552554203191e-15
Rsub_2_15 sn_2 sn_15 37006.69118607329
Csub_2_15 sn_2 sn_15 2.847183351046308e-16
Rsub_2_16 sn_2 sn_16 2942.965637437708
Csub_2_16 sn_2 sn_16 3.580226479097999e-15
Rsub_2_11 sn_2 sn_11 2358.944449327998
Csub_2_11 sn_2 sn_11 4.466609421528164e-15
Rsub_2_18 sn_2 0 12834.83033802465
Csub_2_18 sn_2 0 8.209289273590528e-16
Rsub_2_14 sn_2 sn_14 18990.60769127611
Csub_2_14 sn_2 sn_14 5.548260315582342e-16
Rsub_2_9 sn_2 sn_9 8776.630162254347
Csub_2_9 sn_2 sn_9 1.200515836652689e-15
Rsub_2_12 sn_2 sn_12 19000.32107500774
Csub_2_12 sn_2 sn_12 5.545423922382696e-16
Rsub_2_5 sn_2 sn_5 190259.4417977629
Csub_2_5 sn_2 sn_5 5.537955647651799e-17
Rsub_2_8 sn_2 sn_8 195801.7075175422
Csub_2_8 sn_2 sn_8 5.381201030274988e-17
Rsub_15_16 sn_15 sn_16 64324.37322486778
Csub_15_16 sn_15 sn_16 1.638023500889178e-16
Rsub_15_18 sn_15 0 11210.51679670306
Csub_15_18 sn_15 0 9.398749132893416e-16
Rsub_15_17 sn_15 sn_17 30661.38056781303
Csub_15_17 sn_15 sn_17 3.436402179910561e-16
Rsub_1_15 sn_1 sn_15 141272.2658214263
Csub_1_15 sn_1 sn_15 7.458281666939872e-17
Rsub_1_4 sn_1 sn_4 1029.73151969311
Csub_1_4 sn_1 sn_4 1.023226277988478e-14
Rsub_1_14 sn_1 sn_14 434.8953749000041
Csub_1_14 sn_1 sn_14 2.422762832245035e-14
Rsub_1_2 sn_1 sn_2 4393.542532870356
Csub_1_2 sn_1 sn_2 2.398174917711878e-15
Rsub_1_16 sn_1 sn_16 807.5337317851507
Csub_1_16 sn_1 sn_16 1.304773173863318e-14
Rsub_1_18 sn_1 0 19253.95019943617
Csub_1_18 sn_1 0 5.472374963626191e-16
Rsub_1_6 sn_1 sn_6 6056.376855060989
Csub_1_6 sn_1 sn_6 1.739733797018464e-15
Rsub_1_13 sn_1 sn_13 189778.0221296226
Csub_1_13 sn_1 sn_13 5.55200406453459e-17
Rsub_1_11 sn_1 sn_11 27640.58853094917
Csub_1_11 sn_1 sn_11 3.81196062103826e-16
Rsub_1_17 sn_1 sn_17 114391.0619963533
Csub_1_17 sn_1 sn_17 9.210932496252105e-17
Rsub_1_3 sn_1 sn_3 8331.008728201838
Csub_1_3 sn_1 sn_3 1.264730820238162e-15
Rsub_1_7 sn_1 sn_7 55510.2775111891
Csub_1_7 sn_1 sn_7 1.898114002421656e-16
Rsub_1_10 sn_1 sn_10 27252.74746122062
Csub_1_10 sn_1 sn_10 3.866209642614171e-16
Rsub_1_9 sn_1 sn_9 102183.0112862465
Csub_1_9 sn_1 sn_9 1.031138480810085e-16
Rsub_1_5 sn_1 sn_5 60430.77431222732
Csub_1_5 sn_1 sn_5 1.743562551059037e-16
Rsub_1_12 sn_1 sn_12 412970.8277801927
Csub_1_12 sn_1 sn_12 2.551386876130179e-17
Rsub_6_14 sn_6 sn_14 26672.23893475354
Csub_6_14 sn_6 sn_14 3.950355846768122e-16
Rsub_6_9 sn_6 sn_9 20743.58157895803
Csub_6_9 sn_6 sn_9 5.079394540486707e-16
Rsub_6_13 sn_6 sn_13 27966.15873464774
Csub_6_13 sn_6 sn_13 3.767583386121663e-16
Rsub_6_17 sn_6 sn_17 16532.81108020454
Csub_6_17 sn_6 sn_17 6.373074398004701e-16
Rsub_6_18 sn_6 0 4716.388717358531
Csub_6_18 sn_6 0 2.234015076715535e-15
Rsub_6_8 sn_6 sn_8 50658.50645190733
Csub_6_8 sn_6 sn_8 2.079904095126218e-16
Rsub_6_7 sn_6 sn_7 2233.642616932079
Csub_6_7 sn_6 sn_7 4.717175174917607e-15
Rsub_6_15 sn_6 sn_15 6727.176157301267
Csub_6_15 sn_6 sn_15 1.566256517720938e-15
Rsub_6_11 sn_6 sn_11 262.5443878737362
Csub_6_11 sn_6 sn_11 4.013219854959248e-14
Rsub_6_12 sn_6 sn_12 745.016572539035
Csub_6_12 sn_6 sn_12 1.41426162727111e-14
Rsub_6_16 sn_6 sn_16 397.1638874954491
Csub_6_16 sn_6 sn_16 2.652930901818392e-14
Rsub_6_10 sn_6 sn_10 13927.40381400984
Csub_6_10 sn_6 sn_10 7.565289010742368e-16
Rsub_13_14 sn_13 sn_14 720340.8904255123
Csub_13_14 sn_13 sn_14 1.462707954286199e-17
Rsub_13_16 sn_13 sn_16 66438.52053016295
Csub_13_16 sn_13 sn_16 1.58589977894623e-16
Rsub_13_18 sn_13 0 109126.0042456204
Csub_13_18 sn_13 0 9.655337034529849e-17
Rsub_13_17 sn_13 sn_17 92140.11549768275
Csub_13_17 sn_13 sn_17 1.143528358448279e-16
Rsub_13_15 sn_13 sn_15 379.7273033802999
Csub_13_15 sn_13 sn_15 2.774750039945806e-14
Rsub_11_13 sn_11 sn_13 147464.1630308186
Csub_11_13 sn_11 sn_13 7.145114640516406e-17
Rsub_11_15 sn_11 sn_15 17885.68536393443
Csub_11_15 sn_11 sn_15 5.891014678965719e-16
Rsub_11_16 sn_11 sn_16 10573.32748146883
Csub_11_16 sn_11 sn_16 9.965153846503478e-16
Rsub_11_18 sn_11 0 19080.6107087174
Csub_11_18 sn_11 0 5.522089236596699e-16
Rsub_11_12 sn_11 sn_12 2197.987719875264
Csub_11_12 sn_11 sn_12 4.793695345498993e-15
Rsub_11_14 sn_11 sn_14 196490.5258045247
Csub_11_14 sn_11 sn_14 5.362336661825641e-17
Rsub_11_17 sn_11 sn_17 29165.16500810159
Csub_11_17 sn_11 sn_17 3.612694630496054e-16
Rsub_10_13 sn_10 sn_13 49829.37250314972
Csub_10_13 sn_10 sn_13 2.114512580218422e-16
Rsub_10_11 sn_10 sn_11 29311.90668655408
Csub_10_11 sn_10 sn_11 3.594608707956648e-16
Rsub_10_14 sn_10 sn_14 82377.80933242796
Csub_10_14 sn_10 sn_14 1.279043906073176e-16
Rsub_10_15 sn_10 sn_15 9341.020785170873
Csub_10_15 sn_10 sn_15 1.127979879774699e-15
Rsub_10_17 sn_10 sn_17 1634.109451907712
Csub_10_17 sn_10 sn_17 6.447844414539903e-15
Rsub_10_16 sn_10 sn_16 19290.6803317917
Csub_10_16 sn_10 sn_16 5.461955369643194e-16
Rsub_10_12 sn_10 sn_12 3510.95218677364
Csub_10_12 sn_10 sn_12 3.001033036542834e-15
Rsub_10_18 sn_10 0 4884.741698296325
Csub_10_18 sn_10 0 2.15701958322686e-15
Rsub_7_8 sn_7 sn_8 104164.3759305379
Csub_7_8 sn_7 sn_8 1.0115246607205e-16
Rsub_7_13 sn_7 sn_13 73450.90808033251
Csub_7_13 sn_7 sn_13 1.434493293221965e-16
Rsub_7_18 sn_7 0 11928.10000154396
Csub_7_18 sn_7 0 8.833329282003142e-16
Rsub_7_12 sn_7 sn_12 10809.97261656913
Csub_7_12 sn_7 sn_12 9.747002953624571e-16
Rsub_7_9 sn_7 sn_9 3746.414247290817
Csub_7_9 sn_7 sn_9 2.812418170214187e-15
Rsub_7_10 sn_7 sn_10 5158.257801280499
Csub_7_10 sn_7 sn_10 2.04264383598943e-15
Rsub_7_11 sn_7 sn_11 348.9253479587223
Csub_7_11 sn_7 sn_11 3.019695635146708e-14
Rsub_7_14 sn_7 sn_14 36280.66672710154
Csub_7_14 sn_7 sn_14 2.904159281714435e-16
Rsub_7_15 sn_7 sn_15 50610.78223821241
Csub_7_15 sn_7 sn_15 2.081865372607241e-16
Rsub_7_17 sn_7 sn_17 2057.462011113922
Csub_7_17 sn_7 sn_17 5.121107191925982e-15
Rsub_7_16 sn_7 sn_16 10279.96561361966
Csub_7_16 sn_7 sn_16 1.02495318547277e-15
Rsub_17_18 sn_17 0 37407.88887526691
Csub_17_18 sn_17 0 2.816647455664477e-16
Rsub_0_1 sn_0 sn_1 733579.1073419556
Csub_0_1 sn_0 sn_1 1.436311830145737e-17
Rsub_0_3 sn_0 sn_3 67730.7151004183
Csub_0_3 sn_0 sn_3 1.555643327640716e-16
Rsub_0_11 sn_0 sn_11 16716.43920537553
Csub_0_11 sn_0 sn_11 6.303066922794041e-16
Rsub_0_2 sn_0 sn_2 70654.11978067987
Csub_0_2 sn_0 sn_2 1.491276592920087e-16
Rsub_0_6 sn_0 sn_6 21637.55217824584
Csub_0_6 sn_0 sn_6 4.869535803048584e-16
Rsub_0_7 sn_0 sn_7 623.8951121939045
Csub_0_7 sn_0 sn_7 1.688822896076047e-14
Rsub_0_17 sn_0 sn_17 2394.052389224476
Csub_0_17 sn_0 sn_17 4.401108158557535e-15
Rsub_0_10 sn_0 sn_10 14008.87759699815
Csub_0_10 sn_0 sn_10 7.521290288443796e-16
Rsub_0_13 sn_0 sn_13 390897.6969606898
Csub_0_13 sn_0 sn_13 2.695458065921936e-17
Rsub_0_9 sn_0 sn_9 1463.097250796078
Csub_0_9 sn_0 sn_9 7.201492242909385e-15
Rsub_0_12 sn_0 sn_12 31066.02885623589
Csub_0_12 sn_0 sn_12 3.391641574463744e-16
Rsub_0_15 sn_0 sn_15 26749.15409932096
Csub_0_15 sn_0 sn_15 3.938996898035544e-16
Rsub_0_5 sn_0 sn_5 65179.01075846442
Csub_0_5 sn_0 sn_5 1.616545476775541e-16
Rsub_0_4 sn_0 sn_4 71579.84166896077
Csub_0_4 sn_0 sn_4 1.471990333669451e-16
Rsub_0_16 sn_0 sn_16 439431.4386621792
Csub_0_16 sn_0 sn_16 2.397753682419184e-17
Rsub_0_18 sn_0 0 118170.6943705881
Csub_0_18 sn_0 0 8.916325285512129e-17
Rsub_12_16 sn_12 sn_16 62189.57316552795
Csub_12_16 sn_12 sn_16 1.694252423020397e-16
Rsub_12_13 sn_12 sn_13 1075.145727145304
Csub_12_13 sn_12 sn_13 9.800051505767659e-15
Rsub_12_17 sn_12 sn_17 29681.14478796757
Csub_12_17 sn_12 sn_17 3.549891211238383e-16
Rsub_12_15 sn_12 sn_15 618.371604257866
Csub_12_15 sn_12 sn_15 1.703908043267168e-14
Rsub_12_18 sn_12 0 6886.719461141914
Csub_12_18 sn_12 0 1.529971354529796e-15
Rsub_12_14 sn_12 sn_14 101712.1722945444
Csub_12_14 sn_12 sn_14 1.035911756138469e-16
Rsub_9_14 sn_9 sn_14 338461.9000383965
Csub_9_14 sn_9 sn_14 3.113048618185591e-17
Rsub_9_18 sn_9 0 29963.97676284896
Csub_9_18 sn_9 0 3.516383551362826e-16
Rsub_9_12 sn_9 sn_12 513.3080435951877
Csub_9_12 sn_9 sn_12 2.052662847134231e-14
Rsub_9_10 sn_9 sn_10 998.2604930904575
Csub_9_10 sn_9 sn_10 1.05548437258202e-14
Rsub_9_17 sn_9 sn_17 1221.049669377384
Csub_9_17 sn_9 sn_17 8.629037594844589e-15
Rsub_9_11 sn_9 sn_11 1699.016801606908
Csub_9_11 sn_9 sn_11 6.201518132289645e-15
Rsub_9_15 sn_9 sn_15 5989.242140991825
Csub_9_15 sn_9 sn_15 1.759234850452239e-15
Rsub_9_13 sn_9 sn_13 15549.89957542713
Csub_9_13 sn_9 sn_13 6.775917394913839e-16
Rsub_9_16 sn_9 sn_16 69741.05963996303
Csub_9_16 sn_9 sn_16 1.510800603923199e-16
Rsub_16_17 sn_16 sn_17 94924.39109539776
Csub_16_17 sn_16 sn_17 1.109986946520518e-16
Rsub_16_18 sn_16 0 6002.308298193839
Csub_16_18 sn_16 0 1.755405250576774e-15
Rsub_3_8 sn_3 sn_8 132191.6514680628
Csub_3_8 sn_3 sn_8 7.970611899629372e-17
Rsub_3_9 sn_3 sn_9 30064.09690273728
Csub_3_9 sn_3 sn_9 3.504673210812687e-16
Rsub_3_5 sn_3 sn_5 28719.80243203456
Csub_3_5 sn_3 sn_5 3.668717264739059e-16
Rsub_3_17 sn_3 sn_17 14492.68596275121
Csub_3_17 sn_3 sn_17 7.270207558012809e-16
Rsub_3_14 sn_3 sn_14 13989.87907447168
Csub_3_14 sn_3 sn_14 7.531504344063034e-16
Rsub_3_16 sn_3 sn_16 27297.86560950108
Csub_3_16 sn_3 sn_16 3.859819537891913e-16
Rsub_3_15 sn_3 sn_15 5319.648900737914
Csub_3_15 sn_3 sn_15 1.980672728376573e-15
Rsub_3_18 sn_3 0 4486.592445106493
Csub_3_18 sn_3 0 2.348437847017305e-15
Rsub_3_7 sn_3 sn_7 11030.49724208649
Csub_3_7 sn_3 sn_7 9.552138286231018e-16
Rsub_3_13 sn_3 sn_13 11371.43269088063
Csub_3_13 sn_3 sn_13 9.265748466927812e-16
Rsub_3_10 sn_3 sn_10 260.9257069216619
Csub_3_10 sn_3 sn_10 4.038116300052178e-14
Rsub_3_4 sn_3 sn_4 367.0157666159354
Csub_3_4 sn_3 sn_4 2.870853096961344e-14
Rsub_3_11 sn_3 sn_11 21046.65173047227
Csub_3_11 sn_3 sn_11 5.006251653309214e-16
Rsub_3_6 sn_3 sn_6 7439.955476038958
Csub_3_6 sn_3 sn_6 1.416202494243909e-15
Rsub_3_12 sn_3 sn_12 958.4136725572147
Csub_3_12 sn_3 sn_12 1.099366985668811e-14
Rsub_14_18 sn_14 0 12602.5434186225
Csub_14_18 sn_14 0 8.360600834479549e-16
Rsub_14_15 sn_14 sn_15 116734.0520237874
Csub_14_15 sn_14 sn_15 9.026058223424761e-17
Rsub_14_16 sn_14 sn_16 831.4365377260896
Csub_14_16 sn_14 sn_16 1.267262505812701e-14

.OP
.OPTIONS CUSTOM
.DC V1 0 5 1
.PRINT DC V(N0_14)
