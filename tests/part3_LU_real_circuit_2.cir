*** Copyright (C) 2000-2021 Helic, Inc.
*** Detailed model extracted by VeloceRaptor(TM) v5.6.0_b210705_r0_g6c6352c9-2021.R2.2
*** @ Wed May 11 13:55:04 2022

*** Extraction Time: 141 sec
***
*** Extraction temperature (if applicable)(Celsius): 27
***
***

V1 sbPin_1 0 5
V2 sbPin_2 0 2
V3 sbPin_3 0 2
V4 sbPin_4 0 1
V5 sbPin_5 0 3
V6 sbPin_6 0 10
V7 sbPin_7 0 12
V8 sbPin_8 0 8
V9 sbPin_9 0 9
V10 sbPin_10 0 8
V11 sbPin_11 0 0.7
R0_0 n0_4 n0_3 0.6302453577974029
R0_68 n0_137 n0_152 0.02544283394337973
R0_102 n0_60 n0_173 0.006817102058845711
R0_103 n0_163 n0_174 0.03290205355230387
R0_104 n0_158 n0_172 0.04651669640153284
R0_136 n0_182 n0_185 0.02544283394337876
R0_69 n0_149 n0_153 0.03290205355230386
R0_170 n0_193 n0_194 0.02724549360661227
R0_137 n0_183 n0_186 0.05616040175306777
R0_34 n0_122 n0_125 0.02544283394338006
R0_204 n0_17 n0_41 0.004612601203400369
R0_238 n0_31 n0_224 0.01845040481360164
R0_138 n0_177 n0_185 0.02544283394338135
R0_1 n0_3 n0_5 0.0199760191788079
R0_105 n0_155 n0_159 0.0385289808578354
R0_2 n0_6 n0_4 0.01997601917880796
R0_106 n0_60 n0_160 0.03289394959822699
R0_107 n0_160 n0_161 0.02724549360661227
R0_108 n0_163 n0_164 0.01361464284922912
R0_171 n0_62 n0_194 0.032893949598227
R0_109 n0_164 n0_165 0.009643705351537302
R0_110 n0_165 n0_166 0.04651669640153296
R0_111 n0_12 n0_166 0.0385289808578354
R0_239 n0_30 n0_225 0.01845040481360132
R1_408 n1_22 n1_145 0.008141044845405255
R0_240 n0_55 n0_226 0.009225202406800741
R0_272 n0_86 n0_85 0.07709782034326583
R1_340 n1_99 n1_102 0.01389934485800901
R0_35 n0_9 n0_126 0.05616040175307063
R1_510 n1_29 n1_25 0.1652068894886233
R0_36 n0_127 n0_128 0.03852898085783522
R0_205 n0_18 n0_42 0.004612601203400369
R0_172 n0_32 n0_196 0.03852898085783492
R0_206 n0_19 n0_43 0.004612601203400353
R0_112 n0_167 n0_174 0.007974290811691324
R0_139 n0_181 n0_187 0.03288249228384264
R0_113 n0_167 n0_168 0.005648455991614691
R0_114 n0_168 n0_169 0.03289394959822669
R0_140 n0_177 n0_31 0.03852898085783492
R2_612 n2_23 n2_25 0.02121339174265479
R1_442 n1_165 n1_167 0.003369538147396307
R1_443 n1_152 n1_169 0.004769501020540577
R2_680 n2_33 sbPin_3 0.005245076995647832
R0_70 n0_147 n0_154 0.009624144083075612
R1_341 n1_100 n1_103 0.008141044845405255
R0_71 n0_136 n0_137 0.0385289808578354
R0_72 n0_139 n0_141 0.009643705351537293
R1_342 n1_101 n1_104 0.01151258867027001
R0_73 n0_135 n0_140 0.04651669640153284
R1_476 n1_184 n1_187 0.006743087649729802
R1_544 n1_48 n1_17 0.05240119513699586
R3_782 n3_3 n3_36 0.007515772264534886
R1_545 n1_48 n1_50 0.1652068894886236
R1_374 n1_120 n1_123 0.01389934485800865
R2_578 n2_65 n2_68 0.005691059854054053
R1_375 n1_121 n1_125 0.002386756187739627
R2_579 n2_66 n2_69 0.0160914264057276
R1_306 n1_19 n1_77 0.008141044845405085
R1_409 n1_143 n1_146 0.006743087649729815
R0_141 n0_30 n0_179 0.04651669640153212
R2_613 n2_26 n2_24 0.03517546157972108
R0_142 n0_175 n0_178 0.009643705351537151
R0_241 n0_56 n0_32 0.004612601203400413
R0_273 n0_54 n0_86 0.03416131612210685
R0_274 n0_87 n0_50 0.01779469245207451
R2_681 sbPin_3 n2_10 0.01269945120581141
R0_275 n0_88 n0_87 0.08456902179239137
R2_682 n2_34 n2_35 0.05108153637659144
R2_683 n2_35 n2_37 0.0479923212571051
R0_3 n0_105 n0_106 0.07607552252603418
R2_748 n2_140 n2_148 0.01585091200987386
R2_749 n2_131 n2_146 0.004638917906302352
R1_511 n1_26 n1_30 0.1652068894886234
R1_512 n1_31 n1_27 0.1506106793793231
R1_513 n1_28 n1_32 0.1506106793793225
R1_514 n1_30 n1_15 0.05240119513699598
R1_515 n1_14 n1_31 0.04507883883391997
R1_516 n1_33 n1_29 0.07405685667972232
R1_477 n1_170 n1_188 0.004769501020540546
R3_783 n3_7 sbPin_5 0.005252364142208572
R1_478 n1_176 n1_189 0.004773512375477834
R1_546 n1_51 n1_49 0.1652068894886238
R1_479 n1_12 n1_186 0.005756294335135222
R0_207 n0_20 n0_44 0.004612601203400381
R0_173 n0_196 n0_197 0.04651669640153239
R0_208 n0_45 n0_21 0.004612601203400343
R0_209 n0_46 n0_22 0.004612601203400349
R0_115 n0_169 n0_170 0.02724549360661203
R0_210 n0_47 n0_23 0.004612601203400338
R0_116 n0_157 n0_171 0.0096437053515373
R1_307 n1_78 n1_81 0.01151258867026976
R0_117 n0_171 n0_172 0.0561604017530701
R1_308 n1_79 n1_82 0.008141044845405048
R1_309 n1_80 n1_83 0.01389934485800865
R1_310 n1_81 n1_85 0.002386756187739627
R1_311 n1_82 n1_86 0.001397957195676063
R0_242 n0_63 n0_33 0.03678442732102815
R1_312 n1_85 n1_87 0.003369538147396307
R0_243 n0_64 n0_63 0.09951095273676866
R2_714 n2_125 n2_126 0.04206142214641146
R0_244 n0_37 n0_64 0.02529037786330808
R2_715 n2_110 n2_127 0.009286520982851338
R0_4 n0_107 n0_108 0.07607552252603418
R2_716 n2_124 n2_128 0.009277835812604962
R0_5 n0_5 sbPin_11 0.0380377612630171
R2_717 n2_39 n2_36 0.02709292711987696
R1_517 n1_32 n1_34 0.06672934243334852
R3_784 sbPin_5 n3_4 0.008505878461302857
R0_37 n0_129 n0_134 0.03288249228384214
R1_547 n1_50 n1_51 0.1657542695211916
R0_38 n0_125 n0_130 0.02544283394337973
R1_376 n1_122 n1_126 0.00139795719567607
R0_39 n0_126 n0_131 0.05616040175306992
R1_377 n1_125 n1_127 0.003369538147396307
R0_211 n0_48 n0_24 0.004612601203400349
R1_378 n1_112 n1_129 0.004769501020540577
R1_410 n1_11 n1_144 0.00953567950466842
R0_212 n0_49 n0_25 0.004612601203400349
R1_411 n1_145 n1_147 0.006743087649729815
R0_118 n0_162 n0_173 0.0192874107030749
R0_143 n0_178 n0_179 0.05616040175306923
R0_119 n0_156 n0_174 0.0192712027949207
R1_444 n1_166 n1_168 0.004773512375479253
R0_120 n0_21 n0_13 0.1527211745627178
R1_445 n1_164 n1_169 0.001973586629189269
R0_245 n0_65 n0_35 0.02928870249386674
R0_74 n0_140 n0_141 0.05616040175307012
R1_343 n1_20 n1_105 0.008141044845405275
R0_75 n0_142 n0_143 0.02724549360661203
R1_344 n1_103 n1_106 0.006743087649729815
R2_718 n2_9 n2_38 0.03615182403898287
R1_518 n1_33 n1_36 0.02495441088095257
R2_719 n2_37 n2_40 0.08170160437527145
R2_720 n2_41 n2_39 0.06931840193978143
R3_785 n3_8 n3_9 0.05108303125635429
R2_721 n2_43 n2_40 0.04180010023085062
R3_786 n3_9 n3_12 0.04953991505270872
R2_722 n2_41 n2_42 0.03560779969290974
R2_580 n2_69 n2_71 0.006672813010488447
R2_723 n2_42 n2_43 0.03869832508293857
R2_724 n2_44 n2_45 0.03869832508293857
R1_379 n1_124 n1_128 0.004773512375479253
R2_725 n2_45 n2_46 0.03560779969291001
R1_380 n1_126 n1_129 0.001973586629189269
R1_381 n1_8 n1_115 0.005756294335134956
R2_646 n2_92 n2_93 0.01373677305691787
R1_412 n1_130 n1_148 0.004769501020540555
R2_647 n2_83 n2_94 0.004709306697619693
R1_413 n1_138 n1_149 0.004773512375477834
R1_414 n1_11 n1_146 0.008143050522874177
R1_313 n1_72 n1_89 0.004769501020540555
R1_415 n1_133 n1_147 0.0138993448580094
R1_314 n1_84 n1_88 0.004773512375479253
R1_416 n1_131 n1_136 0.009535679504668451
R1_446 n1_9 n1_155 0.008143050522874014
R1_315 n1_86 n1_89 0.00197358662918926
R2_750 n2_129 n2_133 0.05948720839111558
R1_316 n1_7 n1_75 0.005756294335135044
R1_345 n1_10 n1_104 0.009535679504668385
R2_751 n2_134 n2_135 0.04206142214641146
R2_752 n2_53 n2_135 0.0158552545949972
R1_548 n1_52 n1_53 0.1950432719930629
R1_549 n1_54 n1_52 0.1943996520925669
R1_550 n1_53 n1_55 0.1943996520925666
R3_787 n3_13 n3_8 0.05263510264391585
R3_788 n3_10 n3_11 0.03869832508293857
R3_789 n3_11 n3_14 0.037155294092119
R3_790 n3_15 n3_10 0.04025249649967941
R3_791 n3_12 n3_20 0.05546135604996429
R3_792 n3_14 n3_18 0.04307673179776001
R3_793 n3_23 n3_13 0.0616529302445543
R3_794 n3_21 n3_15 0.04926824722424571
R0_40 n0_124 n0_128 0.03852898085783522
R3_795 n3_16 sbPin_4 0.017782828156
R0_41 n0_129 n0_132 0.03288249228384214
R2_726 n2_47 n2_44 0.04180010023085017
R0_213 n0_50 n0_26 0.004612601203400349
R2_727 n2_46 n2_50 0.06931840193978143
R1_382 n1_114 n1_116 0.01151258867027009
R0_144 n0_176 n0_180 0.02325834820076642
R1_383 n1_110 n1_115 0.01389934485800915
R2_684 n2_38 n2_34 0.05418463670518369
R2_648 n2_77 n2_95 0.004713715175117791
R2_685 n2_7 n2_119 0.004950874848691051
R1_417 n1_136 n1_137 0.01628610104574886
R2_649 n2_27 n2_30 0.0274970070829403
R1_418 n1_137 n1_138 0.006739076294792746
R1_447 n1_154 n1_156 0.01389934485800897
R1_419 n1_139 n1_140 0.008138209232432383
R1_448 n1_150 n1_155 0.01151258867027009
R1_420 n1_140 n1_141 0.005756294335135071
R1_449 n1_9 n1_156 0.005756294335135044
R1_421 n1_22 n1_149 0.001687189718918942
R1_422 n1_142 n1_143 0.005215647905868308
R1_519 n1_6 n1_35 0.2090366500081174
R1_551 n1_55 n1_56 0.07105450658003286
R1_520 n1_194 n1_35 0.03528610648469373
R0_174 n0_197 n0_198 0.009643705351537146
R2_581 n2_3 n2_72 0.001777545990809876
R2_614 n2_25 n2_28 0.04145854000834235
R0_42 n0_130 n0_133 0.02107386245815297
R0_43 n0_58 n0_134 0.006817102058845204
R2_728 n2_52 n2_47 0.08170160437527145
R2_729 n2_48 sbPin_2 0.01827700327628573
R0_145 n0_180 n0_181 0.00482185267576865
R2_730 sbPin_2 n2_49 0.005275060993982146
R0_146 n0_181 n0_182 0.02544283394337988
R2_731 n2_51 n2_48 0.02120521225566857
R0_147 n0_182 n0_183 0.02107386245815304
R0_276 n0_55 n0_88 0.02928870249386661
R0_246 n0_66 n0_65 0.08456902179239113
R0_277 n0_89 n0_46 0.02154253279360004
R0_6 n0_106 n0_5 0.02841092044953743
R0_278 n0_89 n0_90 0.09204006592355948
R1_317 n1_74 n1_76 0.01151258867027009
R0_279 n0_90 n0_56 0.03303654701901284
R1_318 n1_70 n1_75 0.01389934485800906
R0_280 n0_91 n0_47 0.01779469245207447
R1_319 n1_7 n1_76 0.008143050522873925
R1_423 n1_143 n1_144 0.003689116811467809
R1_320 n1_71 n1_77 0.006296940764402002
R1_424 n1_144 n1_145 0.002607823952934194
R1_321 n1_77 n1_78 0.002607823952934154
R1_425 n1_134 n1_145 0.006296940764401962
R2_615 n2_27 n2_5 0.01834506133384072
R3_796 sbPin_4 n3_17 0.005769304798619999
R2_616 n2_26 n2_29 0.01375062366719038
R0_44 n0_10 n0_133 0.04651669640153284
R1_384 n1_8 n1_116 0.008143050522874014
R0_45 n0_122 n0_9 0.0385289808578354
R1_385 n1_111 n1_117 0.006296940764402043
R2_686 n2_112 n2_126 0.008452829788347943
R0_148 n0_61 n0_185 0.02325834820076648
R2_687 n2_109 n2_116 0.01858023839000279
R2_688 n2_114 n2_117 0.01586139796880001
R2_650 n2_31 n2_28 0.0243551701685431
R0_247 n0_39 n0_66 0.01779469245207445
R2_651 n2_30 n2_31 0.02592247326934775
R2_652 n2_7 n2_3 0.003760039212209303
R1_346 n1_105 n1_107 0.006743087649729832
R1_347 n1_90 n1_108 0.004769501020540555
R1_348 n1_98 n1_109 0.004773512375477796
R1_349 n1_10 n1_106 0.008143050522874264
R1_350 n1_93 n1_107 0.01389934485800948
R1_351 n1_91 n1_96 0.009535679504668451
R1_352 n1_96 n1_97 0.01628610104574903
R1_353 n1_97 n1_98 0.006739076294792568
R1_354 n1_99 n1_100 0.008138209232432383
R1_355 n1_100 n1_101 0.005756294335135134
R1_356 n1_20 n1_109 0.001687189718918879
R1_357 n1_102 n1_103 0.005215647905868308
R1_358 n1_103 n1_104 0.003689116811467849
R1_359 n1_104 n1_105 0.002607823952934114
R1_360 n1_94 n1_105 0.006296940764402002
R1_361 n1_92 n1_106 0.01151258867027044
R1_362 n1_10 n1_107 0.005756294335135134
R1_363 n1_95 n1_108 0.008143050522874265
R1_364 n1_101 n1_109 0.002381914897297249
R1_365 n1_110 n1_111 0.009535679504668125
R1_366 n1_113 n1_123 0.002386756187739627
R1_367 n1_115 n1_117 0.006743087649729607
R1_368 n1_8 n1_118 0.009535679504668184
R1_369 n1_116 n1_119 0.006743087649729638
R1_370 n1_114 n1_120 0.01151258867027009
R1_371 n1_21 n1_117 0.008141044845405048
R1_372 n1_118 n1_121 0.01151258867026983
R1_373 n1_119 n1_122 0.008141044845405085
R1_480 n1_173 n1_187 0.01151258867027044
R1_481 n1_176 n1_177 0.006739076294792568
R1_482 n1_177 n1_178 0.01628610104574903
R1_483 n1_174 n1_178 0.009535679504668451
R1_484 n1_179 n1_189 0.002381914897297249
R1_485 n1_179 n1_180 0.005756294335135134
R1_486 n1_180 n1_181 0.008138209232432383
R1_487 n1_171 n1_182 0.006296940764401962
R1_488 n1_182 n1_183 0.002607823952934154
R1_489 n1_183 n1_184 0.003689116811467849
R1_490 n1_184 n1_185 0.005215647905868308
R1_491 n1_172 n1_186 0.0138993448580094
R1_492 n1_12 n1_187 0.008143050522874264
R1_493 n1_175 n1_188 0.008143050522874265
R2_582 n2_67 n2_73 0.001290925455511505
R1_494 n1_24 n1_189 0.001687189718918942
R1_322 n1_78 n1_79 0.003689116811467809
R1_426 n1_132 n1_146 0.01151258867027044
R1_323 n1_79 n1_80 0.005215647905868308
R1_324 n1_81 n1_88 0.002381914897297312
R1_427 n1_11 n1_147 0.00575629433513531
R1_325 n1_81 n1_82 0.005756294335135071
R1_326 n1_82 n1_83 0.008138209232432383
R1_428 n1_135 n1_148 0.008143050522874177
R1_429 n1_141 n1_149 0.002381914897297312
R1_327 n1_84 n1_85 0.00673907629479233
R1_430 n1_151 n1_161 0.002386756187739627
R2_732 n2_53 n2_50 0.02709292711987673
R1_431 n1_153 n1_154 0.009535679504668125
R0_149 n0_185 n0_186 0.0192644904289177
R1_432 n1_150 n1_157 0.01151258867027009
R0_150 n0_184 n0_187 0.007987715543697687
R0_76 n0_143 n0_144 0.0328939495982267
R0_151 n0_62 n0_61 0.04203731578089442
R0_77 n0_144 n0_145 0.005648455991614687
R1_450 n1_157 n1_158 0.005215647905868308
R0_78 n0_138 n0_153 0.01927120279492069
R0_281 n0_92 n0_51 0.02154253279359996
R0_79 n0_11 n0_146 0.0385289808578354
R0_282 n0_91 n0_93 0.08456902179239127
R0_80 n0_146 n0_147 0.04651669640153297
R0_283 n0_96 n0_92 0.09204006592355833
R1_495 n1_7 n1_13 0.005380774846345518
R0_214 n0_214 n0_215 0.01845040481360135
R1_496 n1_8 n1_14 0.005380774846345518
R0_215 n0_216 n0_217 0.01845040481360131
R1_497 n1_9 n1_15 0.005380774846345518
R0_216 n0_51 n0_27 0.009225202406800666
R0_46 n0_58 n0_125 0.02325834820076634
R0_217 n0_215 n0_51 0.004612601203400358
R0_218 n0_214 n0_27 0.004612601203400358
R0_47 n0_125 n0_126 0.01926449042891758
R0_219 n0_216 n0_51 0.004612601203400379
R0_48 n0_123 n0_128 0.02325834820076625
R0_220 n0_217 n0_27 0.004612601203400379
R0_7 n0_108 sbPin_11 0.02841092044953743
R1_433 n1_155 n1_158 0.006743087649729638
R0_248 n0_36 n0_67 0.02554083455686974
R0_152 n0_32 n0_193 0.02325834820076675
R0_249 n0_67 n0_68 0.07709782034326543
R0_250 n0_68 n0_41 0.01404682710823065
R2_753 n2_11 n2_137 0.05948720839111558
R1_552 n1_58 n1_54 0.0887011931052948
R2_754 n2_137 n2_138 0.02242398820714293
R1_553 n1_56 sbPin_6 0.02167531618344161
R1_554 sbPin_6 n1_57 0.0063782011607143
R0_175 n0_198 n0_199 0.01361464284922891
R1_555 n1_58 n1_59 0.02495441088095215
R2_583 n2_14 n2_75 0.001665541985619784
R1_556 n1_59 n1_60 0.08137892968028268
R3_797 n3_22 n3_16 0.02754475107685714
R1_557 n1_61 n1_18 0.05972350449976055
R0_121 n0_22 n0_14 0.152721174562718
R2_617 n2_6 n2_82 0.0017775459908099
R1_386 n1_117 n1_118 0.002607823952934114
R2_733 n2_11 n2_134 0.003501954939656898
R1_387 n1_118 n1_119 0.003689116811467849
R2_689 n2_115 n2_118 0.005086521304123986
R0_49 n0_128 n0_129 0.004821852675768614
R0_221 n0_52 n0_28 0.004612601203400358
R0_50 n0_129 n0_130 0.02544283394337969
R1_434 n1_9 n1_159 0.009535679504668184
R0_153 n0_189 n0_200 0.04651669640153349
R1_435 n1_156 n1_160 0.006743087649729607
R0_251 n0_69 n0_70 0.03791434682822353
R1_451 n1_158 n1_159 0.003689116811467849
R0_252 n0_72 n0_69 0.01278181516449783
R2_755 n2_138 n2_139 0.004638917906302352
R0_253 n0_71 n0_72 0.03416653046472081
R0_284 n0_93 n0_94 0.03791434682822335
R0_254 n0_70 n0_73 0.08456902179239116
R0_81 n0_147 n0_148 0.009643705351537295
R0_255 n0_74 n0_71 0.07709782034326575
R3_798 n3_37 n3_45 0.004638903015878802
R0_256 n0_73 n0_42 0.01779469245207449
R3_799 n3_39 n3_6 0.06268378920843727
R0_257 n0_40 n0_74 0.01404682710823065
R2_618 n2_79 n2_91 0.003555091981619774
R0_258 n0_34 n0_75 0.03303654701901254
R3_800 n3_5 n3_42 0.07565137327545354
R2_690 n2_113 n2_119 0.007003909879313736
R3_801 n3_40 n3_43 0.03427989421185345
R0_222 n0_218 n0_53 0.005824808362582409
R0_51 n0_130 n0_131 0.02107386245815289
R0_223 n0_221 n0_54 0.005824808362582409
R0_224 n0_219 n0_53 0.005824808362582303
R0_154 n0_188 n0_193 0.0561604017530706
R0_225 n0_220 n0_54 0.005824808362582303
R1_436 n1_157 n1_161 0.01389934485800865
R0_226 n0_29 n0_222 0.002912404181291205
R0_227 n0_222 n0_223 0.002912404181291152
R1_437 n1_158 n1_162 0.008141044845405085
R0_228 n0_220 n0_223 0.01438371044637666
R0_285 n0_94 n0_95 0.0127818151644978
R0_229 n0_218 n0_29 0.01438371044637691
R0_286 n0_95 n0_96 0.04166214570090839
R0_230 n0_221 n0_29 0.01438371044637691
R0_231 n0_53 n0_222 0.007191855223188393
R0_287 n0_97 n0_45 0.02529037786330811
R1_558 n1_60 n1_62 0.1798035823414816
R0_288 n0_97 n0_98 0.0995109527367689
R1_559 n1_63 n1_61 0.1798035823414793
R2_734 n2_130 n2_141 0.007003909879313744
R1_560 n1_62 n1_63 0.1803990833394993
R2_735 n2_129 n2_134 0.008452829788347903
R2_736 n2_133 n2_135 0.006138785269861048
R0_8 n0_107 n0_5 0.02841092044953743
R2_737 n2_135 n2_137 0.002543260652062014
R2_691 n2_116 n2_121 0.0317018240197475
R3_802 n3_41 n3_44 0.03134189460421864
R2_692 n2_117 n2_122 0.01121199410357143
R0_52 n0_124 n0_132 0.0096437053515373
R2_693 n2_118 n2_123 0.003595524617799069
R0_53 n0_132 n0_133 0.0561604017530701
R1_452 n1_159 n1_160 0.002607823952934154
R1_521 n1_196 n1_199 0.03528610648469429
R1_453 n1_153 n1_160 0.006296940764401962
R1_522 n1_195 n1_35 0.03528610648469414
R2_584 n2_58 n2_73 0.003115966176867356
R1_498 n1_16 n1_10 0.005380774846345512
R0_82 n0_148 n0_149 0.01361464284922912
R1_499 n1_17 n1_11 0.005380774846345506
R0_83 n0_151 n0_152 0.02724549360661227
R0_232 n0_54 n0_222 0.007191855223188393
R0_84 n0_59 n0_152 0.032893949598227
R0_85 n0_145 n0_153 0.007974290811691324
R0_233 n0_219 n0_223 0.01438371044637666
R1_328 n1_85 n1_86 0.01628610104574785
R0_234 n0_31 n0_226 0.004612601203400429
R2_619 n2_76 n2_81 0.003115966176867335
R0_235 n0_225 n0_55 0.004612601203400345
R2_620 n2_80 n2_82 0.004290544555878382
R1_561 n1_64 sbPin_7 0.02018303441514149
R2_738 n2_138 n2_147 0.004649403865228582
R1_562 sbPin_7 n1_65 0.00787068055272562
R2_739 n2_136 n2_139 0.0131461523945379
R1_563 n1_67 n1_64 0.07105450658003286
R0_155 n0_192 n0_194 0.02544283394338006
R1_564 n1_66 n1_16 0.06704576692221426
R0_156 n0_194 n0_196 0.01053693122907665
R2_756 n2_139 n2_140 0.006573076197268995
R0_157 n0_197 n0_206 0.009624144083078144
R1_523 n1_34 n1_198 0.01764305324234691
R0_158 n0_195 n0_198 0.02722928569846499
R1_524 n1_197 n1_199 0.03528610648469389
R0_176 n0_200 n0_201 0.02724549360661227
R1_500 n1_18 n1_12 0.005380774846345499
R0_122 n0_23 n0_15 0.1527211745627176
R1_501 n1_191 sbPin_8 0.01372409023333347
R0_123 n0_24 n0_16 0.152721174562718
R0_289 n0_98 n0_99 0.0363702309115675
R1_502 n1_193 n1_5 0.01372409023333331
R1_503 n1_192 n1_5 0.01372409023333347
R1_329 n1_73 n1_86 0.009535679504668212
R1_504 n1_190 sbPin_8 0.01372409023333331
R1_505 n1_191 n1_192 0.03674880360000007
R0_259 n0_75 n0_76 0.09204006592355923
R2_621 n2_83 n2_85 0.006672813010488447
R0_260 n0_76 n0_43 0.02154253279359994
R0_9 n0_105 sbPin_11 0.02841092044953743
R3_803 n3_42 n3_45 0.02706281924445022
R0_10 n0_8 n0_119 0.0561604017530699
R0_11 n0_7 n0_114 0.04651669640153278
R2_740 n2_11 n2_141 0.004950874848691056
R0_12 n0_112 n0_115 0.02107386245815297
R0_13 n0_113 n0_116 0.03288249228384214
R2_694 n2_121 n2_124 0.0131461523945379
R0_54 n0_127 n0_134 0.007987715543697486
R2_695 n2_36 n2_128 0.003281295119171366
R1_438 n1_159 n1_163 0.01151258867026983
R2_757 n2_141 n2_142 0.04206142214641146
R1_454 n1_161 n1_162 0.008138209232432383
R2_758 n2_142 n2_143 0.0158552545949972
R2_585 n2_70 n2_74 0.008045713202863859
R2_759 n2_143 n2_144 0.002717787370705671
R1_525 n1_37 n1_198 0.01764305324234711
R2_760 n2_132 n2_148 0.009286520982851432
R0_124 n0_25 n0_17 0.152721174562718
R2_761 n2_130 n2_145 0.07179350616706552
R1_388 n1_119 n1_120 0.005215647905868308
R2_762 n2_145 n2_146 0.02706290611344537
R0_236 n0_224 n0_55 0.004612601203400429
R2_763 n2_136 n2_147 0.009277835812604706
R2_622 n2_86 n2_94 0.002359975882814426
R2_623 n2_81 n2_87 0.001290925455511522
R2_624 n2_85 n2_88 0.0160914264057276
R3_804 n3_43 n3_46 0.01226297079097807
R2_625 n2_86 n2_89 0.005691059854054053
R2_626 n2_87 n2_90 0.001825040721355831
R3_805 n3_19 n3_44 0.01121195811428571
R2_741 n2_137 n2_142 0.003595524617799072
R3_806 n3_46 n3_47 0.002319451507939402
R1_565 n1_66 n1_68 0.1943996520925674
R0_55 n0_11 n0_142 0.03290205355230386
R1_566 n1_69 n1_67 0.1943996520925685
R1_439 n1_23 n1_160 0.008141044845405048
R1_567 n1_68 n1_69 0.1950432719930629
R1_440 n1_162 n1_164 0.00139795719567607
R0_177 n0_201 n0_202 0.032893949598227
R0_86 n0_150 n0_154 0.01928741070307489
R0_178 n0_202 n0_203 0.005648455991614737
R0_87 n0_59 n0_60 0.04203731578089454
R0_290 n0_99 sbPin_10 0.01199933345753753
R0_125 n0_26 n0_18 0.152721174562718
R1_330 n1_19 n1_88 0.001687189718918879
R0_126 n0_27 n0_19 0.1527211745627174
R1_389 n1_121 n1_128 0.002381914897297249
R0_127 n0_28 n0_20 0.1527211745627183
R1_390 n1_121 n1_122 0.005756294335135134
R0_128 n0_29 n0_6 0.4317064174545454
R1_391 n1_122 n1_123 0.008138209232432383
R0_261 n0_77 n0_78 0.04540998627149541
R2_627 n2_6 n2_91 0.002512998565068508
R0_262 n0_80 n0_77 0.01278181516449779
R0_263 n0_79 n0_80 0.04166214570090803
R2_628 n2_78 n2_88 0.009431083159989922
R0_264 n0_78 n0_81 0.09951095273676852
R2_629 n2_89 n2_92 0.008051035736868479
R0_265 n0_82 n0_79 0.09204006592355871
R0_266 n0_81 n0_44 0.02529037786330817
R2_630 n2_90 n2_93 0.002581850911023025
R0_159 n0_32 n0_200 0.03290205355230243
R1_455 n1_162 n1_163 0.005756294335135134
R0_160 n0_196 n0_201 0.01490590271430276
R2_586 n2_68 n2_75 0.002359975882814426
R1_456 n1_23 n1_168 0.001687189718918942
R1_441 n1_163 n1_165 0.002386756187739627
R1_526 n1_195 n1_37 0.01428941502272727
R1_527 n1_194 n1_34 0.01428941502272727
R1_528 n1_196 n1_37 0.01428941502272734
R1_529 n1_197 n1_34 0.01428941502272734
R2_764 n2_144 n2_148 0.003850946241439995
R1_530 n1_35 n1_198 0.007144707511363634
R2_765 n2_55 n2_51 0.05418463670518372
R0_237 n0_30 n0_226 0.004612601203400345
R1_392 n1_124 n1_125 0.006739076294792153
R2_766 n2_52 n2_54 0.04799232125710512
R2_653 n2_97 n2_100 0.007515772264534886
R0_14 n0_111 n0_117 0.03852898085783522
R2_654 n2_99 n2_8 0.007515772264534886
R2_655 n2_98 n2_8 0.007515772264534886
R3_807 n3_38 n3_47 0.01121195811428572
R2_656 n2_96 n2_100 0.007515772264534886
R3_808 n3_48 n3_49 0.003843737479119641
R2_657 n2_4 n2_101 0.003757886132267442
R2_631 n2_29 n2_94 0.001665541985619842
R2_658 n2_101 n2_102 0.003757886132267442
R2_632 n2_84 n2_95 0.0080457132028638
R2_659 n2_98 n2_102 0.007515772264534886
R2_633 n2_79 n2_93 0.0364414337855405
R2_660 n2_96 n2_4 0.007515772264534886
R0_179 n0_191 n0_207 0.01927120279492087
R0_88 n0_12 n0_161 0.02325834820076676
R0_180 n0_189 n0_204 0.04651669640153355
R0_89 n0_158 n0_170 0.0465166964015328
R1_331 n1_87 n1_89 0.008143050522874177
R0_90 n0_155 n0_160 0.02544283394337973
R1_531 n1_198 n1_199 0.007144707511363666
R1_506 n1_190 n1_193 0.03674880360000007
R0_129 n0_31 n0_186 0.0561604017530735
R1_507 n1_5 sbPin_8 0.01837440180000003
R0_130 n0_175 n0_180 0.03852898085783463
R2_742 n2_138 n2_143 0.01121199410357143
R0_131 n0_178 n0_181 0.03288249228384164
R2_696 n2_123 n2_125 0.002543260652061975
R0_56 n0_136 n0_151 0.0561604017530699
R3_809 n3_6 n3_41 0.008021723405296432
R0_267 n0_38 n0_82 0.02154253279360001
R3_810 n3_5 n3_40 0.006646700479515854
R0_268 n0_83 n0_48 0.01404682710823063
R3_811 n3_40 n3_41 0.008021723405296421
R2_661 n2_99 n2_4 0.007515772264534886
R3_812 n3_42 n3_43 0.004895448298720278
R2_634 n2_76 n2_80 0.03019491986680463
R3_813 n3_43 n3_44 0.005908184416958023
R0_181 n0_204 n0_205 0.05616040175307099
R3_814 n3_39 n3_44 0.005908184416958032
R0_91 n0_159 n0_161 0.05616040175306992
R0_182 n0_195 n0_206 0.01928741070307429
R1_393 n1_125 n1_126 0.01628610104574803
R0_183 n0_203 n0_207 0.007974290811691395
R1_508 n1_25 n1_26 0.1657542695211923
R0_184 n0_208 n0_33 0.004612601203400346
R1_509 n1_27 n1_28 0.1511099400466933
R0_132 n0_179 n0_182 0.02107386245815265
R2_697 n2_7 n2_126 0.003501954939656843
R0_133 n0_30 n0_183 0.04651669640153208
R2_698 n2_111 n2_125 0.00613878526986108
R0_161 n0_197 n0_202 0.02325834820076551
R2_587 n2_57 n2_58 0.03019491986680472
R0_269 n0_83 n0_84 0.07709782034326541
R1_457 n1_151 n1_164 0.009535679504668212
R0_270 n0_84 n0_53 0.03416131612210685
R2_635 n2_29 n2_81 0.008047917441612949
R0_271 n0_85 n0_49 0.01404682710823063
R0_291 n0_100 sbPin_10 0.002308922329643249
R0_92 n0_162 n0_164 0.02722928569845781
R0_292 n0_101 n0_52 0.0252903778633082
R0_293 n0_103 n0_101 0.09951095273676946
R1_532 n1_36 n1_38 0.06673447590393208
R0_294 n0_102 n0_103 0.0363702309115675
R0_295 sbPin_9 n0_102 0.01275942826290582
R1_533 n1_39 n1_37 0.06672934243334842
R0_296 n0_104 sbPin_9 0.001547020793535346
R1_534 n1_38 n1_40 0.1506106793793225
R0_185 n0_8 n0_210 0.004612601203400389
R1_535 n1_41 n1_39 0.1506106793793233
R0_57 n0_135 n0_142 0.04651669640153278
R0_186 n0_209 n0_33 0.004612601203400389
R0_58 n0_140 n0_143 0.02107386245815297
R0_59 n0_141 n0_144 0.03288249228384214
R0_162 n0_198 n0_203 0.06580410710460487
R0_60 n0_139 n0_145 0.03852898085783522
R2_588 n2_60 n2_62 0.002354653348809764
R0_163 n0_201 n0_204 0.0210738624581533
R1_332 n1_20 n1_19 0.01039974961111404
R2_636 n2_81 n2_82 0.02134982134048866
R3_815 n3_45 n3_46 0.01586134705543191
R0_93 n0_165 n0_173 0.009624144083075612
R2_767 n2_54 n2_55 0.05108153637659144
R0_94 n0_160 n0_166 0.01053693122907665
R2_743 n2_139 n2_144 0.0317018240197475
R0_95 n0_164 n0_167 0.0658041071046077
R0_96 n0_165 n0_168 0.02325834820076653
R2_744 n2_142 n2_145 0.005086521304123991
R0_97 n0_166 n0_169 0.01490590271430341
R1_536 n1_40 n1_41 0.1511099400466926
R0_98 n0_12 n0_170 0.03290205355230388
R0_187 n0_7 n0_210 0.004612601203400346
R0_99 n0_157 n0_167 0.03852898085783522
R0_100 n0_168 n0_171 0.03288249228384214
R0_188 n0_209 n0_8 0.01845040481360148
R0_101 n0_169 n0_172 0.02107386245815297
R0_189 n0_208 n0_7 0.01845040481360148
R0_164 n0_202 n0_205 0.03288249228384264
R0_190 n0_33 n0_210 0.009225202406800741
R1_333 n1_92 n1_102 0.01151258867027045
R0_191 n0_10 n0_213 0.004612601203400387
R1_334 n1_93 n1_94 0.009535679504668479
R1_394 n1_113 n1_126 0.009535679504668212
R3_768 n3_2 n3_3 0.0159297116069809
R1_395 n1_21 n1_128 0.001687189718918879
R0_15 n0_117 n0_118 0.03852898085783522
R2_568 n2_12 n2_13 0.02592247326934775
R0_16 n0_114 n0_119 0.0561604017530699
R0_17 n0_115 n0_120 0.02544283394337973
R2_569 n2_15 n2_12 0.02435517016854307
R0_18 n0_57 n0_121 0.006817102058845204
R1_537 n1_42 n1_43 0.1803990833394976
R0_19 n0_109 n0_120 0.02544283394337973
R1_538 n1_44 n1_42 0.1798035823414801
R0_20 n0_116 n0_121 0.03288249228384214
R2_589 n2_56 n2_61 0.0364414337855405
R0_165 n0_190 n0_203 0.03852898085783583
R2_590 n2_61 n2_62 0.01373677305691795
R2_591 n2_63 n2_64 0.02134982134048866
R0_166 n0_62 n0_206 0.006817102058843178
R2_637 n2_84 n2_85 0.003336406505244248
R0_192 n0_212 n0_34 0.004612601203400387
R1_297 n1_3 n1_4 0.6302453577974038
R0_193 n0_211 n0_34 0.004612601203400387
R1_396 n1_127 n1_129 0.008143050522874265
R0_194 n0_9 n0_213 0.004612601203400387
R2_745 n2_143 n2_146 0.01586139796880001
R2_699 n2_120 n2_127 0.01585091200987375
R0_61 n0_143 n0_146 0.01490590271430341
R2_700 n2_122 n2_128 0.004649403865228582
R2_662 n2_100 n2_101 0.003757886132267442
R1_539 n1_43 n1_45 0.1798035823414811
R2_663 n2_8 n2_101 0.003757886132267442
R1_458 n1_164 n1_165 0.01628610104574803
R0_21 n0_8 n0_109 0.03852898085783492
R1_459 n1_165 n1_166 0.006739076294792153
R0_22 n0_111 n0_113 0.009643705351537293
R1_460 n1_163 n1_168 0.002381914897297249
R0_23 n0_7 n0_112 0.04651669640153284
R0_167 n0_199 n0_207 0.03290205355230243
R0_24 n0_112 n0_113 0.05616040175307012
R1_335 n1_96 n1_108 0.00197358662918926
R0_25 n0_114 n0_115 0.02107386245815304
R3_769 n3_30 n3_4 0.01128043890583301
R0_26 n0_115 n0_116 0.02544283394337988
R0_195 n0_10 n0_211 0.01845040481360148
R0_62 n0_144 n0_147 0.02325834820076653
R2_746 n2_131 n2_144 0.01858023839000291
R2_570 n2_13 n2_16 0.0274970070829403
R2_747 n2_53 n2_147 0.00328129511917148
R2_664 n2_97 n2_102 0.007515772264534886
R1_540 n1_13 n1_44 0.05972350449976076
R2_592 n2_64 n2_65 0.008047917441612998
R1_541 n1_45 n1_46 0.08137892968028237
R3_816 n3_19 n3_49 0.00328128458656975
R1_461 n1_167 n1_169 0.008143050522874265
R0_168 n0_190 n0_205 0.009643705351537442
R1_462 n1_23 n1_24 0.0103997496111146
R0_169 n0_188 n0_192 0.03852898085783589
R2_638 n2_85 n2_86 0.002354653348809846
R1_397 n1_22 n1_21 0.01039974961111457
R3_770 n3_33 n3_2 0.01128043890583301
R0_196 n0_9 n0_212 0.01845040481360148
R3_771 n3_31 n3_4 0.01128043890583301
R0_63 n0_145 n0_148 0.06580410710460773
R0_64 n0_148 n0_150 0.02722928569845783
R0_65 n0_11 n0_151 0.02325834820076675
R3_772 n3_32 n3_2 0.01128043890583301
R2_665 n2_103 n2_10 0.007515420741279071
R3_773 n3_31 n3_32 0.005017540027479075
R2_666 n2_105 n2_108 0.007515420741279071
R0_134 n0_180 n0_184 0.03852898085783583
R1_542 n1_47 n1_46 0.02495441088095209
R3_817 n3_37 n3_47 0.01858017874945182
R1_543 n1_49 n1_47 0.07405685667972249
R1_463 n1_171 n1_172 0.00953567950466842
R1_336 n1_95 n1_97 0.003369538147396293
R1_464 n1_173 n1_185 0.0115125886702704
R2_639 n2_86 n2_87 0.01138211970810807
R1_465 n1_175 n1_177 0.00336953814739628
R0_197 n0_34 n0_213 0.009225202406800741
R1_466 n1_178 n1_188 0.001973586629189257
R0_66 n0_146 n0_152 0.01053693122907665
R0_198 n0_35 n0_11 0.004612601203400392
R2_701 n2_111 n2_112 0.05948720839111576
R2_593 n2_65 n2_66 0.001379512908622681
R0_199 n0_12 n0_36 0.004612601203400392
R2_594 n2_59 n2_74 0.00471371517511784
R1_298 n1_5 n1_3 0.00316613340463066
R0_200 n0_13 n0_37 0.004612601203400364
R0_135 n0_61 n0_187 0.006817102058843178
R0_201 n0_14 n0_38 0.004612601203400369
R1_398 n1_132 n1_142 0.01151258867027045
R0_202 n0_15 n0_39 0.004612601203400359
R1_399 n1_133 n1_134 0.00953567950466842
R1_467 n1_177 n1_179 0.002386756187738898
R1_400 n1_136 n1_148 0.00197358662918926
R2_571 n2_3 n2_63 0.002512998565068511
R1_401 n1_135 n1_137 0.00336953814739628
R3_774 n3_30 n3_33 0.005017540027479075
R2_667 n2_104 n2_10 0.007515420741279071
R3_775 n3_4 n3_2 0.002508770013739537
R3_818 n3_47 n3_48 0.01858017874945179
R3_776 n3_34 n3_3 0.003757886132267443
R3_819 n3_46 n3_49 0.01586134705543188
R2_640 n2_6 n2_87 0.03019491986680463
R3_820 n3_25 n3_18 0.03406029535813285
R2_641 n2_88 n2_95 0.00195468935787243
R0_203 n0_16 n0_40 0.004612601203400369
R0_67 n0_59 n0_154 0.006817102058845711
R1_468 n1_178 n1_180 0.001397957195675645
R2_702 n2_113 n2_115 0.07179350616706552
R1_469 n1_174 n1_181 0.002386756187738908
R1_402 n1_131 n1_139 0.002386756187738917
R1_470 n1_24 n1_182 0.008141044845405255
R2_668 n2_9 n2_107 0.003757710370639535
R1_471 n1_179 n1_183 0.01151258867027005
R2_595 n2_3 n2_67 0.03019491986680454
R0_27 n0_116 n0_117 0.004821852675768647
R1_337 n1_91 n1_99 0.002386756187738917
R0_28 n0_110 n0_117 0.02325834820076642
R3_821 n3_19 n3_24 0.02864045878764413
R2_703 n2_109 n2_114 0.004638917906302512
R2_572 n2_57 n2_72 0.004290544555878412
R2_704 n2_114 n2_115 0.02706290611344521
R2_705 n2_116 n2_127 0.003850946241439995
R2_573 n2_56 n2_63 0.003555091981619778
R3_777 n3_6 n3_36 0.003757886132267443
R2_669 n2_106 n2_108 0.007515420741279071
R1_472 n1_180 n1_184 0.008141044845405239
R2_670 n2_5 n2_107 0.003757710370639535
R2_671 n2_104 n2_5 0.007515420741279062
R0_29 n0_119 n0_120 0.01926449042891758
R0_30 n0_57 n0_120 0.02325834820076634
R2_672 n2_103 n2_9 0.007515420741279071
R3_822 n3_27 n3_20 0.04644276234334542
R1_299 n1_4 n1_6 0.00316613340463066
R1_300 n1_70 n1_71 0.009535679504668184
R1_301 n1_73 n1_83 0.002386756187739627
R1_403 n1_136 n1_140 0.001397957195675648
R3_823 n3_21 n3_26 0.04334770396202155
R1_404 n1_137 n1_141 0.002386756187738898
R1_405 n1_139 n1_142 0.01389934485800901
R1_473 n1_181 n1_185 0.01389934485800895
R2_596 n2_67 n2_68 0.01138211970810811
R0_31 n0_118 n0_121 0.007987715543697581
R1_474 n1_182 n1_186 0.006743087649729815
R2_597 n2_68 n2_69 0.002354653348809764
R1_338 n1_96 n1_100 0.001397957195675648
R1_302 n1_75 n1_77 0.006743087649729638
R2_673 n2_105 n2_5 0.007515420741279062
R1_303 n1_7 n1_78 0.009535679504668125
R2_706 n2_116 n2_117 0.002717787370705766
R3_778 n3_5 n3_3 0.003757886132267443
R2_707 n2_117 n2_118 0.0158552545949971
R1_406 n1_140 n1_143 0.008141044845405255
R0_32 n0_57 n0_58 0.04203731578089435
R1_407 n1_141 n1_144 0.01151258867027005
R1_475 n1_12 n1_183 0.00953567950466842
R1_339 n1_97 n1_101 0.002386756187738908
R2_574 n2_61 n2_64 0.002581850911023028
R1_304 n1_76 n1_79 0.006743087649729607
R2_575 n2_62 n2_65 0.008051035736868479
R2_674 n2_106 n2_9 0.007515420741279071
R2_576 n2_60 n2_66 0.009431083159989981
R3_824 n3_24 n3_25 0.03250668216800714
R3_779 n3_35 n3_36 0.003757886132267443
R3_825 n3_29 n3_22 0.05882740318864324
R3_780 n3_5 n3_6 0.01503154452906977
R3_826 n3_23 n3_28 0.05573222553300362
R3_781 n3_34 n3_35 0.01503154452906977
R3_827 n3_26 n3_27 0.0448913833797
R3_828 n3_28 n3_29 0.05727463938164285
R2_577 n2_64 n2_67 0.001825040721355832
R2_642 n2_88 n2_89 0.001379512908622729
R2_708 n2_118 n2_119 0.04206142214641146
R0_33 n0_10 n0_131 0.0465166964015328
R2_709 n2_120 n2_121 0.006573076197268995
R2_710 n2_121 n2_122 0.004638917906302512
R1_305 n1_74 n1_80 0.01151258867027009
R2_711 n2_122 n2_123 0.02242398820714273
R2_712 n2_7 n2_123 0.05948720839111542
R2_643 n2_89 n2_90 0.008047917441612949
R2_713 n2_36 n2_125 0.0158552545949971
R2_675 n2_10 n2_107 0.003757710370639533
R2_676 n2_107 n2_108 0.003757710370639533
R2_644 n2_90 n2_91 0.02134982134048866
R2_645 n2_78 n2_92 0.002354653348809846
R2_598 n2_69 n2_70 0.003336406505244248
R2_599 n2_72 n2_73 0.02134982134048866
R2_600 n2_14 n2_73 0.008047917441612998
R2_601 n2_66 n2_74 0.00195468935787243
R2_602 n2_71 n2_75 0.004709306697619496
R2_677 n2_6 n2_11 0.003760039212209303
R2_678 n2_8 sbPin_1 0.01266954727644002
R2_603 n2_14 n2_17 0.01375062366719059
R2_604 n2_16 n2_4 0.007916476501280006
R2_605 n2_18 n2_15 0.04145854000834235
R2_606 n2_17 n2_19 0.03517546157972108
R2_607 n2_18 n2_20 0.02121339174265455
R2_679 sbPin_1 n2_32 0.005274976383171432
R2_608 n2_21 n2_19 0.01807147545914544
R2_609 n2_20 n2_21 0.01963960732099891
R2_610 n2_22 n2_23 0.01963960732099891
R2_611 n2_24 n2_22 0.01807147545914538
C_248_249_0_0 n3_26 n3_28 2.952943005636739e-15
C_248_249_1_0 n3_27 n3_29 3.062715351116484e-15
C_247_249_0_0 n3_23 n3_28 3.054461779736923e-16
C_247_249_1_0 n3_28 n3_29 3.594872544579346e-17
C_246_249_1_0 n3_22 n3_29 3.230939017244737e-17
C_245_247_0_0 n3_24 n3_28 3.936684441474556e-17
C_245_249_1_0 n3_25 n3_29 3.253321008463636e-17
C_245_248_0_0 n3_24 n3_26 3.04074998695364e-15
C_245_248_1_0 n3_25 n3_27 2.303325309246349e-15
C_244_247_0_0 n3_21 n3_23 2.86794152703313e-15
C_243_244_0_0 n3_27 n3_26 1.097559075981019e-17
C_243_246_0_0 n3_20 n3_22 2.568330557852883e-15
C_243_248_1_0 n3_20 n3_27 1.040315556033272e-17
C_242_246_0_0 n3_24 n3_29 1.339676162767528e-18
C_242_243_0_0 n3_24 n3_27 1.341019911745641e-18
C_242_245_0_0 n3_19 n3_24 1.366495843261589e-17
C_241_247_0_0 n3_25 n3_28 1.351637007188817e-18
C_241_242_0_0 n3_25 n3_24 3.062391753656909e-17
C_241_243_1_0 n3_18 n3_20 2.700592770046714e-15
C_241_244_0_0 n3_25 n3_26 2.155107693363884e-18
C_241_245_1_0 n3_18 n3_25 1.49159997830098e-16
C_241_246_0_0 n3_18 n3_22 2.877522425721178e-17
C_240_249_0_0 n3_38 n3_28 1.438441315359164e-18
C_240_248_0_0 n3_38 n3_26 2.85317199012628e-18
C_240_242_0_0 n3_37 n3_19 2.269260178657544e-16
C_240_247_0_0 n3_37 n3_23 2.31239497891796e-17
C_240_244_0_0 n3_37 n3_21 1.316623516561243e-15
C_240_245_0_0 n3_38 n3_24 2.849004357223722e-18
C_239_245_0_0 n3_22 n3_25 1.430357043963874e-18
C_239_246_0_0 n3_16 n3_22 1.149746400274907e-16
C_239_241_0_0 n3_16 n3_18 1.895140236089074e-17
C_238_241_0_0 sbPin_4 n3_18 2.851342362112669e-18
C_238_239_0_0 sbPin_4 n3_16 1.1296303539699e-16
C_238_246_0_0 sbPin_4 n3_22 1.362416264704826e-17
C_238_242_0_0 sbPin_4 n3_24 3.087693474880235e-19
C_238_242_1_0 n3_17 n3_24 2.81248474105123e-19
C_238_243_0_0 sbPin_4 n3_20 9.873329443465108e-18
C_237_245_0_0 n3_16 n3_25 1.326635387501286e-18
C_237_243_0_0 n3_16 n3_20 1.022591486028518e-15
C_236_245_0_0 n3_21 n3_24 3.117902750464727e-18
C_236_242_0_0 n3_21 n3_19 4.032574961547425e-17
C_236_244_0_0 n3_21 n3_26 1.194710943744229e-16
C_235_236_1_0 n3_13 n3_15 2.822234535643642e-15
C_235_241_0_0 n3_23 n3_25 7.580260549533799e-18
C_235_245_0_0 n3_23 n3_24 7.407791061342845e-18
C_234_248_0_0 n3_18 n3_27 1.459100623463401e-18
C_234_235_0_0 n3_14 n3_13 7.142029629364983e-19
C_234_235_1_0 n3_18 n3_23 6.968407311837022e-19
C_233_249_0_0 n3_20 n3_29 1.39348998342038e-18
C_233_245_0_0 n3_20 n3_25 1.39348998342038e-18
C_233_242_0_0 n3_20 n3_24 2.734507114257268e-18
C_233_234_0_0 n3_12 n3_14 2.850747390904543e-15
C_232_247_0_0 n3_15 n3_23 2.876218046619111e-18
C_232_242_0_0 n3_15 n3_19 1.341019911745641e-18
C_232_234_0_0 n3_10 n3_14 1.242794955535228e-20
C_232_241_0_0 n3_10 n3_18 7.80504739394619e-19
C_232_241_1_0 n3_15 n3_25 7.80504739394619e-19
C_232_236_0_0 n3_10 n3_15 2.032445484098778e-16
C_232_240_0_0 n3_15 n3_5 1.208234339771823e-17
C_231_246_0_0 n3_14 n3_22 1.339676162767528e-18
C_231_242_0_0 n3_14 n3_24 4.516841201620802e-19
C_231_242_1_0 n3_11 n3_19 4.493862213501144e-19
C_231_242_2_0 n3_14 n3_19 4.399495702334462e-19
C_231_239_0_0 n3_14 n3_16 4.124904482019542e-18
C_231_238_0_0 n3_14 sbPin_4 1.04498287750201e-18
C_231_243_0_0 n3_14 n3_20 1.497034326342851e-19
C_231_241_0_0 n3_14 n3_18 4.937798610742499e-18
C_231_232_0_0 n3_11 n3_10 7.735985180640866e-17
C_231_234_0_0 n3_11 n3_14 1.43530702007549e-16
C_231_236_0_0 n3_11 n3_15 1.347273719027834e-18
C_230_233_0_0 n3_11 n3_12 2.776200383090664e-18
C_229_230_0_0 n3_8 n3_10 2.751480321219784e-15
C_229_235_0_0 n3_8 n3_13 1.074263312301245e-16
C_228_243_0_0 n3_12 n3_20 2.850274098597122e-18
C_228_232_0_0 n3_9 n3_10 1.579200704944426e-18
C_228_239_0_0 n3_12 n3_16 7.336016902205115e-18
C_228_238_0_0 n3_12 sbPin_4 4.002733422519727e-18
C_228_229_0_0 n3_9 n3_8 8.240028039846252e-17
C_228_230_0_0 n3_9 n3_11 2.639250938148543e-15
C_228_233_0_0 n3_9 n3_12 1.743997912794826e-16
C_227_242_0_0 n3_8 n3_19 1.341019911745641e-18
C_227_236_0_0 n3_8 n3_15 8.511531162840939e-18
C_227_240_0_0 n3_8 n3_6 7.197696184973876e-19
C_227_240_1_0 n3_8 n3_5 6.872585802175344e-19
C_226_247_0_0 n3_4 n3_23 3.558887041672968e-16
C_226_236_0_0 n3_4 n3_21 2.368563697050163e-18
C_225_247_0_0 sbPin_5 n3_23 8.507384488200591e-17
C_225_244_0_0 sbPin_5 n3_21 1.301905816354242e-17
C_225_242_0_0 sbPin_5 n3_19 9.867513723996561e-19
C_225_232_0_0 sbPin_5 n3_15 9.93699958839206e-19
C_225_229_0_0 sbPin_5 n3_13 4.736859870625079e-18
C_224_248_0_0 n3_6 n3_26 7.454284969416156e-19
C_224_248_1_0 n3_5 n3_26 6.811574981215242e-19
C_224_235_0_0 n3_34 n3_13 1.046571286200489e-17
C_224_235_1_0 n3_5 n3_23 9.909238449446775e-18
C_224_230_0_0 n3_35 n3_10 9.215207314221459e-18
C_224_241_0_0 n3_6 n3_25 1.406285995534988e-18
C_224_232_0_0 n3_34 n3_15 3.237720824241036e-16
C_224_225_0_0 n3_5 sbPin_5 1.647899420619167e-18
C_224_225_1_0 n3_34 sbPin_5 1.545847543603447e-18
C_224_242_0_0 n3_5 n3_19 3.835861783138818e-17
C_224_236_1_0 n3_5 n3_21 2.799314976939316e-16
C_224_240_0_0 n3_6 n3_39 1.220104435910174e-16
C_224_240_1_0 n3_34 n3_5 1.191640624947512e-16
C_224_240_2_0 n3_5 n3_6 2.383281249895025e-16
C_224_240_3_0 n3_35 n3_6 1.191640624947512e-16
C_224_245_0_0 n3_6 n3_24 5.492908566852363e-18
C_224_226_0_0 n3_5 n3_4 1.262470159117498e-18
C_224_243_0_0 n3_6 n3_27 1.425137049298561e-18
C_223_229_0_0 n3_33 n3_13 5.08584346268367e-16
C_223_247_0_0 n3_32 n3_23 4.695806935125565e-16
C_223_247_1_0 n3_31 n3_23 2.197037805708278e-18
C_223_225_0_0 n3_31 sbPin_5 2.764202834256828e-17
C_223_226_0_0 n3_32 n3_4 2.434335110462853e-16
C_223_235_1_0 n3_30 n3_13 4.902109132572411e-16
C_222_232_0_0 n3_3 n3_15 5.168265999822902e-18
C_222_230_0_0 n3_3 n3_10 1.382710701627033e-18
C_222_229_0_0 n3_2 n3_13 1.322679858580994e-18
C_222_226_0_0 n3_2 n3_4 4.691947170741368e-18
C_222_242_0_0 n3_3 n3_19 1.341019911745641e-18
C_222_225_0_0 n3_2 sbPin_5 1.617685515653179e-18
C_222_236_0_0 n3_3 n3_21 6.912527276646115e-15
C_222_236_1_0 n3_2 n3_21 6.481209867344358e-15
C_222_224_0_0 n3_3 n3_5 2.402966251692843e-16
C_222_235_0_0 n3_2 n3_23 1.237656431199646e-14
C_222_223_0_0 n3_2 n3_32 2.824934359453985e-16
C_220_221_0_0 n2_52 n2_54 6.571777602094421e-16
C_219_225_0_0 n2_51 n3_7 2.365574753114497e-18
C_219_225_1_0 n2_51 sbPin_5 2.161456855234417e-18
C_219_229_0_0 n2_51 n3_13 1.031082811888696e-17
C_219_221_0_0 n2_55 n2_54 5.275697656108233e-16
C_218_219_0_0 n2_131 n2_55 2.257136021577378e-17
C_217_221_0_0 n2_53 n2_55 1.161147555197703e-17
C_217_219_0_0 n2_50 n2_51 4.628334658497675e-17
C_217_218_0_0 n2_53 n2_131 5.665362508633055e-16
C_216_220_0_0 n2_51 n2_54 5.926763678404586e-18
C_216_218_0_0 n2_51 n2_132 9.24243222287044e-19
C_216_219_0_0 n2_48 n2_51 2.488151247112105e-16
C_215_227_0_0 n2_49 n3_8 1.503659202714526e-18
C_215_226_0_0 n2_49 sbPin_5 7.434223922817437e-19
C_215_226_1_0 sbPin_2 sbPin_5 5.170135103212492e-19
C_215_226_2_0 n2_49 n3_4 4.988581051718618e-19
C_215_216_0_0 sbPin_2 n2_48 1.212410190208718e-16
C_215_232_0_0 n2_49 n3_15 6.884400887942813e-19
C_215_229_0_0 n2_49 n3_13 6.900890166502092e-19
C_215_217_0_0 sbPin_2 n2_50 1.315357646270989e-18
C_215_219_0_0 sbPin_2 n2_51 1.22800341960808e-17
C_215_225_0_0 n2_49 n3_7 2.072943986749759e-19
C_215_225_2_0 sbPin_2 n3_7 1.973534335003101e-19
C_213_218_0_0 n2_52 n2_129 3.076551483785035e-18
C_213_218_1_0 n2_52 n2_130 3.049239362587776e-18
C_212_217_0_0 n2_50 n2_53 4.598388291098829e-16
C_212_216_0_0 n2_50 n2_48 1.292652550403346e-17
C_211_213_0_0 n2_44 n2_47 3.935112108867699e-16
C_210_212_0_0 n2_45 n2_46 7.301423313562762e-16
C_209_217_0_0 n2_45 n2_50 5.749374880497442e-18
C_209_211_0_0 n2_45 n2_44 2.906906711400781e-16
C_208_213_0_0 n2_42 n2_52 5.854943620556437e-18
C_208_221_0_0 n2_42 n2_54 1.439649756818834e-15
C_208_221_1_0 n2_43 n2_55 1.519151173002178e-15
C_208_216_0_0 n2_43 n2_51 5.622542874054426e-18
C_208_217_0_0 n2_43 n2_53 2.936208718571545e-17
C_208_218_0_0 n2_43 n2_131 5.003339105516488e-16
C_207_218_0_0 n2_42 n2_130 6.279206479661456e-18
C_207_208_0_0 n2_41 n2_42 5.960512129488051e-16
C_207_213_0_0 n2_41 n2_52 2.026569502013044e-15
C_206_215_0_0 n2_40 sbPin_2 6.653745512277718e-18
C_206_214_0_0 n2_40 n2_48 6.758408777385918e-16
C_206_219_0_0 n2_40 n2_51 1.289254497144535e-15
C_206_208_0_0 n2_43 n2_42 3.450408839231546e-16
C_206_212_0_0 n2_40 n2_50 2.40893924926144e-15
C_205_218_0_0 n2_41 n2_129 3.069994089526589e-18
C_205_218_1_0 n2_41 n2_130 2.870481671173825e-18
C_205_206_0_0 n2_41 n2_43 5.862181149135437e-18
C_205_211_0_0 n2_39 n2_47 1.941493217517041e-15
C_205_217_0_0 n2_41 n2_53 5.832052997945841e-18
C_204_209_0_0 n2_37 n2_45 5.700989317297949e-18
C_204_208_0_0 n2_40 n2_43 3.142694428025548e-16
C_204_210_0_0 n2_37 n2_46 2.246328353370008e-15
C_203_213_0_0 n2_38 n2_47 2.641766176980086e-15
C_203_205_0_0 n2_38 n2_39 5.682788812361182e-17
C_202_205_0_0 n2_36 n2_39 3.554516802230505e-16
C_202_212_0_0 n2_36 n2_46 5.805658077349541e-18
C_202_209_0_0 n2_36 n2_44 3.777332806739978e-16
C_201_205_0_0 n2_110 n2_39 2.207315900487512e-19
C_201_202_0_0 n2_112 n2_36 4.774445972045875e-16
C_201_209_0_0 n2_109 n2_44 6.453304424202546e-16
C_201_210_0_0 n2_113 n2_45 5.692753435426519e-18
C_201_213_0_0 n2_110 n2_47 1.170271043990098e-17
C_200_202_0_0 n2_34 n2_36 2.336165198606333e-17
C_200_209_0_0 n2_34 n2_44 1.746050263801138e-15
C_200_203_0_0 n2_38 n2_9 2.333452091452689e-16
C_199_204_0_0 n2_35 n2_37 6.494149250829393e-16
C_199_209_0_0 n2_35 n2_45 1.544141743619848e-15
C_198_212_0_0 n2_35 n2_46 5.816069285473413e-18
C_198_200_0_0 n2_35 n2_34 5.080564350587964e-16
C_198_201_0_0 n2_34 n2_109 2.286927160712669e-17
C_197_205_0_0 n2_10 n2_41 2.966082750323569e-18
C_197_205_1_0 n2_10 n2_39 2.904520292088074e-18
C_197_213_0_0 n2_10 n2_52 2.687052913140355e-17
C_197_213_1_0 n2_10 n2_47 2.616707000798527e-17
C_197_203_0_0 n2_10 n2_9 1.522348618204274e-16
C_196_220_0_0 sbPin_3 n2_52 1.079498737621516e-18
C_196_203_0_0 sbPin_3 n2_9 4.904254371243873e-17
C_196_200_0_0 sbPin_3 n2_38 6.535156398298866e-19
C_196_202_0_0 sbPin_3 n2_39 1.055078851934319e-18
C_196_205_0_0 sbPin_3 n2_41 1.39077413664197e-19
C_195_219_0_0 sbPin_1 n2_51 3.526498700993277e-19
C_195_219_1_0 n2_32 n2_51 3.377010074011505e-19
C_195_215_0_0 n2_32 n2_49 2.099594844487378e-18
C_195_215_1_0 sbPin_1 sbPin_2 1.236421535912718e-17
C_195_215_2_0 n2_32 sbPin_2 6.928177409152138e-18
C_195_215_3_0 sbPin_1 n2_49 4.463529937035576e-18
C_195_216_0_0 sbPin_1 n2_48 1.169722129594367e-17
C_195_216_1_0 n2_32 n2_48 8.814266798554496e-19
C_195_204_0_0 sbPin_1 n2_37 4.459756510913383e-18
C_195_210_0_0 sbPin_1 n2_46 7.48233541858314e-18
C_194_212_0_0 n2_8 n2_46 5.741428833510541e-18
C_194_195_0_0 sbPin_1 n2_32 6.737156217384277e-17
C_194_216_0_0 n2_8 n2_48 6.816008345543766e-18
C_194_215_2_0 n2_8 sbPin_2 4.86062737892958e-18
C_194_204_0_0 n2_8 n2_37 2.673257156247409e-17
C_193_221_0_0 n2_6 n2_54 1.97158771048093e-17
C_193_219_0_0 n2_11 n2_55 1.489609215862718e-18
C_193_218_0_0 n2_11 n2_129 2.79156823823962e-16
C_193_218_1_0 n2_6 n2_130 2.79156823823962e-16
C_193_217_0_0 n2_11 n2_53 4.737530472961187e-17
C_193_212_0_0 n2_11 n2_50 8.809086311422751e-18
C_193_196_0_0 n2_6 sbPin_3 9.575731297050592e-19
C_193_196_1_0 n2_6 n2_33 8.736261135295525e-19
C_193_207_0_0 n2_6 n2_42 7.95815747281479e-16
C_193_205_0_0 n2_6 n2_41 2.384100551605956e-18
C_193_206_0_0 n2_11 n2_43 8.794761278570056e-18
C_192_213_0_0 n2_106 n2_47 5.435017201868961e-16
C_192_196_0_0 n2_104 sbPin_3 2.086568659144772e-17
C_192_203_0_0 n2_103 n2_9 1.365359262413465e-16
C_192_203_1_0 n2_105 n2_9 1.365359262413465e-16
C_192_197_0_0 n2_103 n2_10 2.812693835687639e-16
C_192_197_1_0 n2_105 n2_10 2.812693835687639e-16
C_192_202_0_0 n2_106 n2_39 7.794352151641979e-18
C_191_215_0_0 n2_98 sbPin_2 1.403159548776902e-18
C_191_215_1_0 n2_98 n2_49 1.290626546130222e-18
C_191_218_0_0 n2_97 n2_133 7.880406355654427e-19
C_191_218_1_0 n2_97 n2_132 7.470627535566001e-19
C_191_194_0_0 n2_97 n2_8 2.820982770426116e-16
C_191_194_1_0 n2_99 n2_8 2.820982770426116e-16
C_191_229_0_0 n2_98 n3_13 1.322679858580995e-18
C_191_212_0_0 n2_96 n2_46 9.300916766491472e-18
C_191_195_0_0 n2_98 sbPin_1 2.431378528099483e-17
C_191_216_0_0 n2_98 n2_48 2.402982119882811e-18
C_191_216_1_0 n2_97 n2_48 2.23662181927554e-18
C_191_199_0_0 n2_96 n2_37 8.709969771291341e-16
C_190_213_0_0 n2_7 n2_47 3.613111001403714e-18
C_190_212_0_0 n2_3 n2_46 8.878751729449057e-18
C_190_211_0_0 n2_7 n2_44 8.621160730194144e-18
C_190_210_0_0 n2_3 n2_45 8.226860300323554e-16
C_190_205_0_0 n2_7 n2_39 1.597730208322873e-18
C_190_204_0_0 n2_3 n2_37 1.44792467813487e-18
C_190_202_0_0 n2_7 n2_36 4.250087808982615e-17
C_190_191_0_0 n2_3 n2_96 1.462857655592814e-18
C_190_215_0_0 n2_3 sbPin_2 1.746600224801356e-19
C_190_215_1_0 n2_3 n2_49 1.623038621399176e-19
C_190_198_0_0 n2_3 n2_35 2.829988470136985e-17
C_190_200_0_0 n2_7 n2_34 8.394777790111191e-18
C_190_201_0_0 n2_7 n2_111 5.083650259581749e-16
C_189_220_0_0 n2_30 n2_54 4.437778930554351e-14
C_189_208_0_0 n2_31 n2_43 2.000090833193994e-15
C_189_221_0_0 n2_31 n2_55 4.452572688565302e-14
C_189_207_0_0 n2_30 n2_42 3.685416929601373e-17
C_188_189_0_0 n2_28 n2_31 7.286656670244856e-17
C_188_206_0_0 n2_28 n2_40 5.517171120137576e-14
C_187_196_0_0 n2_27 sbPin_3 3.454661673221434e-19
C_187_196_1_0 n2_27 n2_33 3.147175728699044e-19
C_187_213_0_0 n2_27 n2_52 3.179653278888902e-15
C_187_189_0_0 n2_30 n2_31 3.957887463836057e-16
C_187_197_0_0 n2_27 n2_10 1.162672790088982e-19
C_187_205_0_0 n2_27 n2_41 2.017464477272187e-17
C_186_193_0_0 n2_79 n2_6 3.926519073787566e-16
C_186_220_0_0 n2_78 n2_54 1.987581668175892e-17
C_186_207_0_0 n2_78 n2_42 3.758415977991179e-15
C_186_205_0_0 n2_77 n2_41 2.474491001088159e-17
C_186_218_0_0 n2_79 n2_130 6.536105656330364e-18
C_186_218_1_0 n2_80 n2_129 6.536105656330364e-18
C_185_213_0_0 n2_26 n2_52 4.080998983873496e-17
C_185_208_0_0 n2_29 n2_42 1.376105978530597e-17
C_185_186_0_0 n2_29 n2_78 4.42216411935651e-16
C_185_193_0_0 n2_29 n2_6 5.390373121598888e-17
C_185_207_0_0 n2_26 n2_41 4.402369080888434e-14
C_185_219_0_0 n2_29 n2_55 5.68764365807138e-18
C_185_187_0_0 n2_26 n2_27 6.880529892652987e-18
C_184_187_0_0 n2_5 n2_27 7.950226103010976e-16
C_184_192_0_0 n2_5 n2_104 5.547678370246489e-16
C_184_196_0_0 n2_5 sbPin_3 6.668450935916231e-17
C_184_203_0_0 n2_5 n2_9 2.620889403615525e-17
C_184_197_0_0 n2_5 n2_10 3.043633127908166e-16
C_183_215_0_0 n2_28 sbPin_2 9.390102903129441e-19
C_183_219_0_0 n2_28 n2_51 2.48973322991903e-15
C_183_214_0_0 n2_28 n2_48 9.445666330028039e-17
C_183_195_0_0 n2_25 sbPin_1 2.731461654040131e-18
C_183_212_0_0 n2_25 n2_46 2.28250164953908e-15
C_183_204_1_0 n2_25 n2_37 5.489685316527806e-14
C_183_191_0_0 n2_25 n2_96 6.37390854829039e-16
C_182_212_0_0 n2_24 n2_46 2.893035508452441e-18
C_182_212_1_0 n2_26 n2_50 2.893035508452441e-18
C_182_203_0_0 n2_24 n2_38 1.823382573007839e-18
C_182_196_0_0 n2_26 sbPin_3 1.639333644462902e-18
C_182_213_0_0 n2_24 n2_47 2.375272640710826e-15
C_182_185_0_0 n2_26 n2_29 2.314870044138534e-17
C_182_202_0_0 n2_24 n2_39 4.353801295110053e-14
C_181_183_0_0 n2_23 n2_25 1.888576956346385e-16
C_181_210_0_0 n2_23 n2_45 3.292492715854881e-14
C_180_211_0_0 n2_22 n2_44 3.289776025522236e-14
C_180_182_0_0 n2_22 n2_24 4.15167178025837e-16
C_180_201_0_0 n2_22 n2_113 3.569023482232561e-15
C_180_190_0_0 n2_22 n2_7 5.266332366771862e-16
C_180_198_0_0 n2_22 n2_34 1.183416653451375e-17
C_179_181_0_0 n2_22 n2_23 1.051175589534518e-16
C_179_198_0_0 n2_23 n2_35 2.080807920797585e-15
C_178_218_0_0 n2_21 n2_131 3.597953778948433e-15
C_178_208_0_0 n2_21 n2_43 3.27743119007269e-14
C_178_208_1_0 n2_20 n2_42 3.271191848048595e-14
C_178_220_0_0 n2_20 n2_54 1.835659607936137e-15
C_178_186_0_0 n2_20 n2_78 4.723228474485278e-16
C_178_193_0_0 n2_21 n2_11 5.338374433688544e-16
C_178_188_0_0 n2_21 n2_31 1.082815977068417e-15
C_178_189_0_0 n2_20 n2_30 1.239511193580029e-15
C_177_216_0_0 n2_19 n2_51 9.24243222287044e-19
C_177_178_0_0 n2_19 n2_21 1.678555551632183e-16
C_177_217_0_0 n2_19 n2_50 4.296969649551117e-14
C_177_183_0_0 n2_19 n2_28 1.546169040926683e-15
C_176_196_0_0 n2_18 sbPin_3 3.415998850094894e-19
C_176_213_0_0 n2_18 n2_52 5.501496430813607e-14
C_176_205_0_0 n2_18 n2_41 2.250091015730889e-15
C_176_187_1_0 n2_18 n2_27 2.02109684395042e-15
C_176_178_0_0 n2_20 n2_21 1.970719264401252e-16
C_176_185_0_0 n2_18 n2_26 1.734520519277506e-15
C_175_202_0_0 n2_17 n2_36 5.805658077349541e-18
C_175_193_0_0 n2_19 n2_11 1.489609215862718e-18
C_175_191_0_0 n2_17 n2_96 3.084388963339066e-18
C_175_190_0_0 n2_17 n2_3 1.459494798264256e-18
C_175_195_0_0 n2_17 sbPin_1 6.5890878827947e-19
C_175_212_1_0 n2_17 n2_46 4.32158738475763e-14
C_175_183_1_0 n2_17 n2_25 1.470037283007932e-15
C_175_204_0_0 n2_19 n2_40 2.360238714132315e-15
C_174_213_0_0 n2_15 n2_47 5.531252141114197e-14
C_174_203_0_0 n2_15 n2_38 2.675239789553975e-15
C_174_192_0_0 n2_18 n2_105 5.245805168163364e-16
C_174_180_0_0 n2_15 n2_24 1.661099812951224e-15
C_174_202_0_0 n2_15 n2_39 1.020359089929087e-17
C_173_214_0_0 n2_4 n2_48 3.03273115168801e-18
C_173_204_0_0 n2_16 n2_37 2.614372199265221e-15
C_173_181_0_0 n2_16 n2_25 7.454432246080929e-16
C_173_181_1_0 n2_4 n2_25 2.07475357059572e-16
C_173_212_0_0 n2_16 n2_46 4.823773518517044e-17
C_173_195_0_0 n2_4 sbPin_1 4.753107904687861e-17
C_173_194_0_0 n2_4 n2_8 1.949202110984027e-16
C_173_191_0_0 n2_4 n2_96 3.976382519189167e-16
C_172_201_0_0 n2_14 n2_112 5.692753435426519e-18
C_172_205_0_0 n2_14 n2_39 5.666273154158407e-18
C_172_181_1_0 n2_14 n2_23 3.603099959864913e-16
C_172_190_0_0 n2_14 n2_3 5.459305602977752e-17
C_172_204_0_0 n2_17 n2_37 4.49380874031688e-17
C_171_199_0_0 n2_60 n2_35 1.863414577318606e-17
C_171_212_0_0 n2_59 n2_46 5.301423547238839e-18
C_171_210_0_0 n2_56 n2_45 3.782070647668151e-15
C_171_201_0_0 n2_56 n2_113 6.338627841444539e-18
C_171_201_1_0 n2_57 n2_112 6.338627841444539e-18
C_171_200_0_0 n2_56 n2_34 6.984540998977544e-18
C_171_172_0_0 n2_57 n2_14 4.315197458447389e-16
C_171_179_0_0 n2_60 n2_23 4.379311018806152e-16
C_171_190_0_0 n2_57 n2_3 5.650575171353836e-16
C_170_181_1_0 n2_13 n2_23 1.14406857275807e-15
C_170_198_0_0 n2_13 n2_35 4.502904437871163e-14
C_170_216_0_0 n2_16 n2_48 9.24243222287044e-19
C_170_191_0_0 n2_16 n2_96 1.884872549414286e-17
C_170_190_0_0 n2_13 n2_3 1.44792467813487e-18
C_170_194_0_0 n2_16 n2_8 1.285494958582675e-17
C_170_209_0_0 n2_13 n2_45 3.088714024241018e-17
C_170_173_0_0 n2_16 n2_4 6.129963849331822e-16
C_169_209_0_0 n2_12 n2_44 1.985161551094775e-15
C_169_200_0_0 n2_12 n2_34 4.406970183833919e-14
C_169_174_0_0 n2_12 n2_15 2.608404328267117e-16
C_169_179_0_0 n2_12 n2_22 1.22530614460542e-15
C_168_190_0_0 n2_12 n2_7 1.44792467813487e-18
C_168_170_0_0 n2_12 n2_13 4.307607316922509e-16
C_166_167_0_0 n1_67 n1_69 1.204007249031094e-16
C_166_167_1_0 n1_69 n1_68 2.776129397054173e-16
C_77_86_0_0 n0_87 n0_92 1.180476151878528e-15
C_77_157_0_0 n0_87 n1_61 9.281206734033781e-16
C_77_135_0_0 n0_87 n1_39 6.065390671954063e-16
C_77_84_0_0 n0_50 n0_51 3.272051267016257e-16
C_77_143_0_0 n0_87 n1_49 2.623628553563303e-14
C_77_78_0_0 n0_50 n0_87 1.407520154232173e-17
C_76_78_0_0 n0_86 n0_88 1.913940152581318e-15
C_76_135_0_0 n0_86 n1_41 3.02338248445643e-14
C_76_147_0_0 n0_86 n1_51 5.370807643249133e-16
C_75_166_0_0 n0_86 n1_69 2.750064685504848e-17
C_75_166_1_0 n0_85 n1_67 2.750064685504843e-17
C_75_159_0_0 n0_86 n1_63 2.346025366904481e-17
C_75_159_1_0 n0_85 n1_61 2.34602536690448e-17
C_75_76_0_0 n0_86 n0_54 4.473020019577719e-16
C_75_146_0_0 n0_85 n1_49 6.958913859771312e-16
C_75_78_0_0 n0_85 n0_87 1.191365005002382e-15
C_75_133_0_0 n0_85 n1_39 2.297573048266887e-14
C_74_130_0_0 n0_49 n1_35 8.607534742487766e-18
C_74_77_0_0 n0_49 n0_50 7.361483289866124e-16
C_74_75_0_0 n0_49 n0_85 2.460709032575339e-16
C_73_147_0_0 n0_84 n1_50 7.345206820172766e-16
C_73_134_0_0 n0_84 n1_40 3.108062556122523e-14
C_73_87_0_0 n0_53 n0_94 1.04454037524517e-15
C_72_145_0_0 n0_83 n1_48 6.300808011077254e-16
C_72_132_0_0 n0_83 n1_38 2.351520673036967e-14
C_72_73_0_0 n0_84 n0_53 3.044032191075113e-16
C_72_83_0_0 n0_83 n0_91 1.334128828783401e-15
C_72_85_1_0 n0_84 n0_93 1.287240088127857e-15
C_72_130_0_0 n0_83 n1_6 5.183400827495906e-17
C_71_72_0_0 n0_48 n0_83 2.555675101525694e-16
C_71_83_0_0 n0_48 n0_47 8.720883522814035e-16
C_70_152_0_0 n0_82 n1_54 7.208084988809715e-16
C_70_138_0_0 n0_82 n1_44 2.89591597718923e-14
C_70_127_0_0 n0_82 n1_29 7.00367103084911e-16
C_69_141_0_0 n0_81 n1_45 6.786846730176043e-16
C_69_154_0_0 n0_44 sbPin_6 6.782968135200867e-18
C_69_150_0_0 n0_81 n1_55 3.227962915593596e-14
C_68_149_1_0 n0_79 n1_52 8.552441276791704e-16
C_68_138_0_0 n0_79 n1_42 3.742926613329782e-14
C_68_121_1_0 n0_79 n1_25 8.368273690167994e-16
C_67_139_1_0 n0_78 n1_43 1.107639229761563e-15
C_67_150_1_0 n0_78 n1_53 4.071502927695262e-14
C_65_148_0_0 n0_77 n1_53 2.596948762740986e-15
C_65_137_0_0 n0_77 n1_43 1.246945739136687e-15
C_65_137_1_0 n0_80 n1_42 1.167205609405844e-15
C_65_66_0_0 n0_77 n0_80 6.093935854373346e-16
C_64_249_0_0 n0_77 n3_29 7.438677373002284e-19
C_64_249_1_0 n0_78 n3_29 6.945735780589355e-19
C_64_67_0_0 n0_77 n0_78 3.597392484367646e-16
C_63_151_0_0 n0_76 n1_55 8.78737068753416e-16
C_63_69_0_0 n0_43 n0_44 6.700659588206661e-16
C_63_125_0_0 n0_76 n1_30 5.888786658539061e-16
C_63_139_0_0 n0_76 n1_45 2.787908906836423e-14
C_62_150_1_0 n0_75 n1_53 1.16407562212102e-15
C_62_63_0_0 n0_76 n0_43 1.022945067685713e-16
C_62_67_0_0 n0_76 n0_81 1.732125290521786e-15
C_62_67_1_0 n0_75 n0_78 2.934101408979246e-15
C_62_137_0_0 n0_75 n1_43 3.322120902094437e-14
C_62_122_1_0 n0_75 n1_26 8.195567735117643e-16
C_61_62_0_0 n0_34 n0_75 3.875621583293127e-16
C_60_121_0_0 n0_74 n1_29 6.141053861824989e-16
C_60_123_0_0 n0_74 n1_31 2.24909360249216e-14
C_59_128_0_0 n0_73 n1_32 5.53186458839232e-16
C_59_62_0_0 n0_73 n0_76 1.732210266094232e-15
C_59_122_0_0 n0_73 n1_30 2.619765655537883e-14
C_59_63_0_0 n0_42 n0_43 9.948490032411575e-16
C_58_113_0_0 n0_74 n1_14 4.654801656777743e-17
C_58_60_0_0 n0_74 n0_40 4.005255765141842e-16
C_58_102_0_0 n0_74 n1_4 2.586705460582772e-17
C_58_102_1_0 n0_74 n1_6 2.396715013125336e-17
C_58_123_0_0 n0_71 n1_27 3.08429655221262e-14
C_58_121_1_0 n0_71 n1_25 9.590338851519896e-16
C_57_61_0_0 n0_70 n0_75 2.823146664090291e-15
C_57_124_1_0 n0_70 n1_28 9.654073693373023e-16
C_57_59_0_0 n0_73 n0_42 1.244230212622184e-16
C_57_139_0_0 n0_73 n1_45 4.513937716057297e-16
C_57_139_1_0 n0_70 n1_43 9.262574702884216e-16
C_57_122_1_0 n0_70 n1_26 3.449475399437723e-14
C_56_58_0_0 n0_72 n0_71 4.197502960285172e-16
C_55_137_0_0 n0_69 n1_43 5.294481381654683e-17
C_55_120_0_0 n0_69 n1_28 1.176947026689933e-15
C_55_120_1_0 n0_72 n1_27 1.101034420355296e-15
C_55_119_0_0 n0_69 n1_26 2.638393054264514e-15
C_55_56_0_0 n0_69 n0_72 2.869355301274828e-16
C_53_130_0_0 n0_41 n1_35 8.142744794040511e-18
C_53_59_0_0 n0_41 n0_42 7.242426174033111e-16
C_53_124_0_0 n0_68 n1_32 2.334214471257862e-14
C_53_125_0_0 n0_68 n1_30 4.65870841061031e-16
C_52_59_0_0 n0_68 n0_73 1.571103885140372e-15
C_52_53_0_0 n0_68 n0_41 4.5487138740702e-16
C_52_139_0_0 n0_68 n1_45 2.631206165097308e-17
C_52_139_1_0 n0_67 n1_43 2.631206165097303e-17
C_52_122_1_0 n0_67 n1_26 6.04099601153158e-16
C_52_57_1_0 n0_67 n0_70 2.436786996487597e-15
C_52_120_0_0 n0_67 n1_28 2.858844889889634e-14
C_50_140_0_0 n0_66 n1_44 5.61063304482295e-16
C_50_127_0_0 n0_66 n1_29 2.596209745812392e-14
C_50_60_0_0 n0_39 n0_40 6.296527183920655e-16
C_50_126_0_0 n0_66 n1_31 5.210488868202169e-16
C_50_70_0_0 n0_39 n0_38 7.214702709284255e-16
C_49_137_0_0 n0_65 n1_42 8.185128052186723e-16
C_49_123_1_0 n0_65 n1_27 5.11710058807146e-16
C_49_70_0_0 n0_66 n0_82 1.031941131972787e-15
C_49_121_0_0 n0_65 n1_25 3.103454784359551e-14
C_49_56_0_0 n0_65 n0_71 2.131613118457891e-15
C_49_58_0_0 n0_66 n0_74 1.580035053452089e-15
C_49_68_1_0 n0_65 n0_79 2.186173348709183e-15
C_48_49_0_0 n0_35 n0_65 2.346978566608234e-16
C_47_68_0_0 n0_64 n0_82 2.354162299384931e-15
C_47_152_0_0 n0_64 n1_54 3.321128679427531e-14
C_47_70_0_0 n0_37 n0_38 1.08808107224998e-15
C_47_140_0_0 n0_64 n1_44 6.751213089512899e-16
C_46_68_1_0 n0_63 n0_79 3.803437902219531e-15
C_46_138_1_0 n0_63 n1_42 1.041593798008928e-15
C_46_47_0_0 n0_64 n0_37 1.641849485861177e-16
C_46_149_0_0 n0_63 n1_52 3.808760820476493e-14
C_45_46_0_0 n0_33 n0_63 2.440216094702516e-16
C_45_249_0_0 n0_63 n3_28 1.473950576533166e-18
C_45_120_0_0 n0_63 n1_27 5.142159120530717e-17
C_44_167_0_0 n0_56 n1_68 4.689769845055735e-17
C_44_87_0_0 n0_32 n0_94 3.802599353694128e-16
C_44_160_0_0 n0_56 n1_62 3.481771383856862e-15
C_44_92_0_0 n0_56 n0_99 2.164799024931149e-16
C_44_147_0_0 n0_56 n1_50 7.767234267293123e-17
C_43_160_0_0 n0_224 n1_63 1.176856451596878e-16
C_43_88_0_0 n0_31 n0_95 4.311308963494502e-16
C_43_76_0_0 n0_30 n0_54 1.984418169002516e-16
C_43_136_0_0 n0_225 n1_41 2.577561852744699e-17
C_43_136_1_0 n0_224 n1_41 2.349090759213851e-17
C_43_79_0_0 n0_31 n0_55 1.369081550256912e-16
C_43_79_1_0 n0_225 n0_55 1.369081550256906e-16
C_43_147_0_0 n0_224 n1_51 9.83451864085167e-16
C_43_147_1_0 n0_225 n1_51 9.497681350751528e-16
C_42_43_0_0 n0_220 n0_30 4.054287421384628e-17
C_42_73_0_0 n0_218 n0_53 3.963021694363498e-16
C_42_87_0_0 n0_219 n0_94 8.617200397434224e-17
C_42_136_0_0 n0_219 n1_40 1.147205867067849e-15
C_42_136_1_0 n0_220 n1_41 1.147205867067849e-15
C_42_136_2_0 n0_218 n1_40 1.117720135135223e-15
C_42_136_3_0 n0_221 n1_41 1.117720135135223e-15
C_42_76_0_0 n0_221 n0_54 3.314441280217081e-16
C_41_157_0_0 n0_28 n1_18 2.312137725434969e-16
C_41_161_0_0 n0_28 n1_64 3.594750799370977e-15
C_41_95_0_0 n0_28 n0_52 8.327786899060847e-16
C_40_157_0_0 n0_217 n1_18 2.878089493075317e-15
C_40_143_0_0 n0_214 n1_47 1.444701332169933e-16
C_40_41_0_0 n0_217 n0_28 1.550222546078539e-16
C_40_41_1_0 n0_216 n0_52 2.02197831463572e-16
C_40_77_0_0 n0_215 n0_50 9.264458007054215e-17
C_40_84_0_0 n0_217 n0_51 1.563124116137474e-16
C_40_84_1_0 n0_215 n0_51 1.563124116137453e-16
C_40_163_0_0 n0_217 n1_64 1.096425840337422e-16
C_39_143_0_0 n0_26 n1_47 4.035161140441783e-15
C_39_77_0_0 n0_26 n0_50 8.527369058256596e-16
C_39_40_0_0 n0_26 n0_214 9.264458007054216e-17
C_38_130_0_0 n0_25 n1_35 4.249966362056794e-16
C_38_39_0_0 n0_25 n0_26 4.823769667984369e-16
C_38_74_0_0 n0_25 n0_49 1.152530414878911e-15
C_38_143_0_0 n0_25 n1_47 5.418161161520313e-16
C_38_133_0_0 n0_25 n1_37 3.699074782499055e-15
C_37_144_0_0 n0_24 n1_17 9.118780930053101e-17
C_37_71_0_0 n0_24 n0_48 7.972704827437625e-16
C_37_132_0_0 n0_24 n1_36 3.269162007614267e-15
C_36_80_0_0 n0_47 n0_46 6.026769932956703e-16
C_36_144_0_0 n0_23 n1_17 6.262754362607487e-15
C_36_156_0_0 n0_23 n1_59 5.998720958881735e-17
C_36_37_0_0 n0_23 n0_24 3.526372031447972e-16
C_36_83_0_0 n0_23 n0_47 4.746484871439268e-16
C_15_109_0_0 n0_18 n1_154 1.847259754124315e-15
C_15_117_0_0 n0_26 n1_18 2.074171140500855e-16
C_15_32_0_0 n0_18 n0_19 3.684474029185623e-16
C_15_16_1_0 n0_26 n0_27 1.954422995039432e-16
C_15_110_0_0 n0_26 n1_24 2.24611169303786e-15
C_15_131_0_0 n0_18 n1_197 9.541675678543801e-17
C_15_131_1_0 n0_26 n1_196 9.541675678543801e-17
C_15_125_0_0 n0_18 n1_15 6.622677424122232e-15
C_15_31_0_0 n0_18 n0_42 2.95446062626541e-16
C_14_135_0_0 n0_25 n1_39 3.261389721982219e-17
C_14_128_0_0 n0_17 n1_34 3.970497194861499e-16
C_14_15_0_0 n0_17 n0_18 3.899101463023606e-16
C_14_30_0_0 n0_17 n0_41 7.070102818086905e-16
C_14_131_0_0 n0_17 n1_197 1.166672011026912e-16
C_14_131_1_0 n0_25 n1_196 1.166672011026912e-16
C_14_114_0_0 n0_17 n1_15 1.412202106821278e-16
C_13_126_0_0 n0_16 n1_14 6.318069296518246e-15
C_13_28_0_0 n0_16 n0_15 4.068680522202483e-16
C_13_107_0_0 n0_24 n1_22 1.377454309361413e-15
C_13_106_0_0 n0_16 n1_114 2.037737404497996e-15
C_13_29_0_0 n0_16 n0_40 6.219989370772949e-17
C_13_100_0_0 n0_24 n1_4 5.517074959413648e-15
C_12_126_0_0 n0_15 n1_14 3.7628425298773e-16
C_12_100_0_0 n0_23 n1_4 5.682643061288494e-15
C_12_28_0_0 n0_15 n0_39 5.353129003480875e-16
C_12_27_0_0 n0_15 n0_14 3.893027367336929e-16
C_12_112_0_0 n0_15 n1_13 1.387859725304852e-16
C_12_129_0_0 n0_23 n1_36 1.336432230296585e-16
C_12_108_0_0 n0_23 n1_133 1.590377794929626e-15
C_12_127_0_0 n0_15 n1_33 3.463079685709035e-15
C_12_107_0_0 n0_23 n1_22 1.290880872354308e-15
C_11_127_0_0 n0_14 n1_33 7.063908098349246e-17
C_11_156_0_0 n0_22 n1_59 4.393774966180886e-15
C_11_116_0_0 n0_22 n1_17 3.543452492212629e-16
C_11_115_0_0 n0_22 n1_16 3.982140263280248e-16
C_11_108_0_0 n0_22 n1_132 1.580109440993257e-16
C_11_104_0_0 n0_22 n1_20 2.203720497573774e-15
C_11_12_1_0 n0_22 n0_23 2.935476676522298e-16
C_11_112_0_0 n0_14 n1_13 5.706264181722168e-15
C_11_27_0_0 n0_14 n0_38 4.706997398263253e-16
C_11_103_0_0 n0_14 n1_74 1.952905724369164e-15
C_11_35_0_0 n0_22 n0_46 8.150217926507688e-16
C_11_100_0_0 n0_22 n1_3 5.319514022073183e-15
C_10_156_0_0 n0_21 n1_59 1.510471383416605e-16
C_10_34_0_0 n0_21 n0_45 7.896743944637005e-16
C_10_100_0_0 n0_21 n1_3 5.244949958748464e-15
C_10_26_0_0 n0_13 n0_37 5.528656142748009e-16
C_10_112_0_0 n0_13 n1_13 5.18142810708285e-16
C_10_11_0_0 n0_13 n0_14 3.231577457530994e-16
C_10_11_1_0 n0_21 n0_22 3.796314382670225e-16
C_10_104_0_0 n0_21 n1_20 2.391941561180528e-15
C_10_105_0_0 n0_21 n1_93 1.177532102366977e-15
C_10_152_0_0 n0_13 n1_58 3.52216161065237e-15
C_10_115_0_0 n0_21 n1_16 7.708077335690106e-15
C_10_103_0_0 n0_13 n1_70 2.98663340429816e-17
C_9_120_0_0 n0_158 n1_28 6.971199597404958e-17
C_9_120_1_0 n0_159 n1_28 6.728952209527047e-17
C_9_55_0_0 n0_155 n0_69 7.394412383935163e-17
C_9_25_0_0 n0_158 n0_12 5.806197709926244e-16
C_8_9_0_0 n0_60 n0_157 2.590964651354325e-16
C_8_54_0_0 n0_60 n0_69 9.870905340747508e-17
C_8_55_0_0 n0_60 n0_72 3.134692303052273e-15
C_8_119_0_0 n0_59 n1_25 6.842952014039791e-17
C_7_8_0_0 n0_136 n0_59 7.439644006106364e-17
C_7_66_0_0 n0_139 n0_80 1.029488885742024e-16
C_7_24_0_0 n0_136 n0_11 2.458561152640635e-16
C_7_119_0_0 n0_136 n1_25 2.931845468685121e-17
C_7_119_1_0 n0_135 n1_25 2.850477437451616e-17
C_7_55_0_0 n0_138 n0_69 9.454753003928038e-17
C_6_137_0_0 n0_10 n1_43 3.506146641089352e-17
C_6_137_1_0 n0_9 n1_43 3.426709201184451e-17
C_6_148_0_0 n0_9 n1_53 2.30319257506206e-17
C_6_148_1_0 n0_10 n1_53 2.212738229350754e-17
C_6_148_2_0 n0_122 n1_53 2.128638201546557e-17
C_6_23_0_0 n0_122 n0_9 1.205177145214022e-16
C_1_249_0_0 n0_5 n3_29 6.853540129225788e-20
C_1_148_0_0 n0_3 n1_53 8.075446243564605e-16
C_1_22_0_0 n0_3 n0_7 5.370504699001625e-17
C_1_64_0_0 n0_3 n0_77 1.259499215065052e-15
C_1_4_0_0 n0_3 n0_110 8.818807908599176e-16
C_0_137_0_0 n0_3 n1_43 3.576131273804889e-17
C_0_137_1_0 n0_4 n1_43 3.356724568468913e-17
C_0_25_0_0 n0_4 n0_12 7.94276811731119e-17
C_0_6_0_0 n0_3 n0_122 6.827232218047366e-16
C_0_6_1_0 n0_3 n0_9 6.535933619390015e-16
C_0_5_0_0 n0_3 n0_57 5.164107293092352e-15
C_0_56_0_0 n0_4 n0_72 1.006088269517997e-15
C_0_2_0_0 n0_4 n0_6 1.227932267210617e-15
C_0_1_0_0 n0_3 n0_5 1.591642529938018e-16
C_0_7_0_0 n0_4 n0_137 9.96062649320377e-16
C_0_120_0_0 n0_4 n1_28 4.444048575662543e-16
C_0_9_0_0 n0_4 n0_157 1.031531357667302e-15
C_0_119_0_0 n0_4 n1_26 1.274310259354179e-16
C_0_8_0_0 n0_4 n0_60 4.437557870328773e-15
C_0_54_0_0 n0_4 n0_69 1.654003312121343e-16
C_0_66_0_0 n0_3 n0_80 3.325258361010864e-16
C_2_51_0_0 n0_4 n0_36 3.395103596001845e-17
C_3_249_0_0 n0_108 n3_29 4.265978098614011e-18
C_3_148_0_0 n0_107 n1_53 5.266207117588309e-17
C_3_148_1_0 n0_106 n1_52 5.266207117588309e-17
C_4_66_0_0 n0_109 n0_80 8.380654751869166e-17
C_4_148_0_0 n0_8 n1_52 8.922570465127127e-17
C_4_148_1_0 n0_7 n1_52 8.754515233935745e-17
C_4_148_2_0 n0_109 n1_52 8.242431026111326e-17
C_4_22_0_0 n0_109 n0_8 3.074825723003007e-16
C_4_5_0_0 n0_8 n0_57 2.347633731343435e-16
C_5_66_0_0 n0_58 n0_80 2.668727092413535e-15
C_5_23_0_0 n0_58 n0_10 3.600507875866984e-17
C_16_161_0_0 n0_27 n1_64 5.439041998289625e-17
C_16_110_0_0 n0_27 n1_24 1.859276267339193e-15
C_16_125_0_0 n0_19 n1_15 4.215959765339562e-16
C_16_142_0_0 n0_19 n1_46 3.683445672794413e-15
C_16_142_1_0 n0_27 n1_47 1.374106743615806e-16
C_16_32_0_0 n0_19 n0_43 1.018538799784167e-15
C_16_117_0_0 n0_27 n1_18 4.518401792847927e-15
C_16_17_0_0 n0_19 n0_20 3.587704724627721e-16
C_16_17_1_0 n0_27 n0_28 1.567487257239237e-16
C_16_111_0_0 n0_27 n1_173 1.716020555695115e-15
C_16_40_0_0 n0_27 n0_217 3.932454605300622e-16
C_17_154_0_0 n0_20 sbPin_6 1.533954922366885e-17
C_17_142_0_0 n0_20 n1_46 1.122844499302711e-16
C_17_153_0_0 n0_20 n1_56 4.977219630041043e-15
C_17_33_0_0 n0_20 n0_44 4.926595011220959e-16
C_17_162_0_0 n0_28 sbPin_7 4.860627685970072e-17
C_17_111_0_0 n0_28 n1_173 1.910005221656977e-16
C_18_160_0_0 n0_29 n1_63 5.885883067391711e-17
C_18_146_0_0 n0_29 n1_51 4.874430829677647e-17
C_18_136_0_0 n0_29 n1_41 4.959444747542813e-16
C_18_130_0_0 n0_6 n1_6 7.04331525700391e-16
C_18_130_1_0 n0_29 n1_6 6.768789157703158e-16
C_18_130_2_0 n0_6 n1_35 6.768789157703152e-16
C_18_130_3_0 n0_29 n1_35 6.514860547614805e-16
C_18_56_0_0 n0_6 n0_72 4.943457223988054e-17
C_18_42_0_0 n0_29 n0_221 3.67529396089518e-16
C_18_76_0_0 n0_29 n0_54 5.417077970396863e-17
C_18_137_0_0 n0_6 n1_43 5.134108120554459e-17
C_19_147_0_0 n0_31 n1_51 2.495924493333426e-17
C_19_147_1_0 n0_30 n1_51 2.435170396892798e-17
C_19_147_2_0 n0_177 n1_51 2.280971153553633e-17
C_19_136_0_0 n0_30 n1_41 1.659528303064537e-17
C_19_136_1_0 n0_31 n1_41 1.557213384585119e-17
C_19_76_0_0 n0_175 n0_54 1.402091745098259e-16
C_19_42_0_0 n0_175 n0_220 1.138702701449444e-16
C_19_43_0_0 n0_177 n0_31 3.701884602950468e-16
C_19_20_0_0 n0_31 n0_61 1.862492638861668e-16
C_19_88_0_0 n0_176 n0_94 1.639504598125186e-16
C_20_160_0_0 n0_61 n1_63 1.185197910267012e-16
C_20_88_0_0 n0_62 n0_95 3.608497207869882e-15
C_21_160_0_0 n0_189 n1_62 6.040363645574799e-18
C_21_160_1_0 n0_188 n1_62 5.91889571049799e-18
C_21_44_0_0 n0_189 n0_32 3.369514023629222e-16
C_21_93_0_0 n0_189 n0_99 3.565385833485548e-17
C_21_89_0_0 n0_191 n0_95 4.97110623190926e-17
C_21_147_0_0 n0_188 n1_50 6.834386539404835e-18
C_21_147_1_0 n0_189 n1_50 6.490215060134654e-18
C_21_147_2_0 n0_192 n1_50 6.250146936278837e-18
C_21_88_0_0 n0_192 n0_94 3.938867372632325e-17
C_22_65_0_0 n0_8 n0_80 3.366415284697518e-16
C_22_148_0_0 n0_209 n1_52 1.506617820909282e-15
C_22_148_1_0 n0_208 n1_52 1.468405288203104e-15
C_23_119_0_0 n0_211 n1_26 5.672683835905928e-17
C_23_54_0_0 n0_10 n0_69 5.976805889271385e-16
C_23_61_0_0 n0_10 n0_34 1.718025573906829e-16
C_23_61_1_0 n0_212 n0_34 1.718025573906822e-16
C_23_64_0_0 n0_9 n0_77 1.820862319145948e-16
C_23_148_0_0 n0_212 n1_53 5.178373066122567e-17
C_23_148_1_0 n0_211 n1_53 4.907042833095107e-17
C_23_137_0_0 n0_211 n1_43 1.523192051592737e-15
C_23_137_1_0 n0_212 n1_43 1.475256344949537e-15
C_24_120_0_0 n0_35 n1_27 1.649338292705987e-16
C_24_48_0_0 n0_11 n0_35 3.698738895752858e-16
C_24_55_0_0 n0_11 n0_72 5.693217270230357e-16
C_24_66_0_0 n0_11 n0_80 3.803796859571271e-16
C_24_119_0_0 n0_35 n1_25 3.135349471257802e-15
C_25_120_0_0 n0_36 n1_28 3.086541274395503e-15
C_25_55_0_0 n0_12 n0_69 3.947729673419095e-16
C_25_51_0_0 n0_12 n0_36 4.248857737467903e-16
C_27_152_0_0 n0_14 n1_58 7.035059692525625e-18
C_29_129_0_0 n0_16 n1_33 1.747994208861136e-16
C_29_130_0_0 n0_16 n1_6 9.909388888029152e-18
C_30_130_0_0 n0_17 n1_35 9.800435325812874e-18
C_30_128_0_0 n0_41 n1_32 3.549603132105812e-15
C_31_128_0_0 n0_42 n1_32 6.937554638642433e-17
C_31_141_0_0 n0_18 n1_46 4.924599285108636e-17
C_32_151_0_0 n0_19 n1_56 2.434202183643761e-16
C_34_35_1_0 n0_45 n0_46 9.232079695075619e-16
C_78_159_0_0 n0_88 n1_63 6.623250206958593e-16
C_78_79_0_0 n0_88 n0_55 1.279737248636319e-16
C_78_86_0_0 n0_88 n0_96 2.345206034047122e-15
C_78_135_1_0 n0_88 n1_41 5.32254075159621e-16
C_78_146_1_0 n0_88 n1_51 3.133023054862292e-14
C_80_91_0_0 n0_89 n0_97 2.007872720399609e-15
C_80_164_0_0 n0_89 n1_66 6.591937306394618e-16
C_80_156_0_0 n0_89 n1_60 2.834434077805721e-14
C_80_145_0_0 n0_89 n1_48 7.842372047747467e-16
C_80_81_0_0 n0_46 n0_89 3.108617109204409e-16
C_80_85_0_0 n0_89 n0_91 1.715870477899739e-15
C_81_147_0_0 n0_90 n1_50 7.241536165224895e-16
C_81_87_0_0 n0_90 n0_93 3.340484386184728e-15
C_81_167_0_0 n0_90 n1_68 9.524394234345362e-16
C_81_158_0_0 n0_90 n1_62 3.365038545634072e-14
C_81_92_0_0 n0_90 n0_98 2.991957048886058e-15
C_83_85_0_0 n0_47 n0_91 3.259812390602833e-16
C_83_132_0_0 n0_91 n1_38 4.688205394980438e-16
C_83_144_0_0 n0_91 n1_48 2.644850595897355e-14
C_83_156_0_0 n0_91 n1_60 7.659630053414182e-16
C_84_96_0_0 n0_92 n0_101 2.106169932987256e-15
C_84_86_0_0 n0_51 n0_92 6.802826190401145e-17
C_84_163_0_0 n0_92 n1_67 6.626269172893927e-16
C_84_95_0_0 n0_51 n0_52 1.096106710603507e-15
C_84_143_0_0 n0_92 n1_49 5.491107840932551e-16
C_84_157_0_0 n0_92 n1_61 2.845191331131235e-14
C_85_158_0_0 n0_93 n1_62 7.707332902419274e-16
C_85_145_0_0 n0_93 n1_50 3.642244709507841e-14
C_85_134_1_0 n0_93 n1_40 8.84633328844725e-16
C_85_87_0_0 n0_93 n0_94 2.93083318013304e-16
C_86_160_0_0 n0_96 n1_63 3.691511290428791e-14
C_86_166_0_0 n0_96 n1_69 1.019390471586289e-15
C_86_89_0_0 n0_96 n0_95 1.869729476227438e-16
C_86_96_0_0 n0_96 n0_103 3.456173607188263e-15
C_86_146_0_0 n0_96 n1_51 9.048079696623535e-16
C_88_160_0_0 n0_94 n1_62 1.307087835279293e-15
C_88_160_1_0 n0_95 n1_63 1.224651935230769e-15
C_88_147_0_0 n0_94 n1_50 2.055793722083116e-15
C_88_89_0_0 n0_94 n0_95 4.813934595375929e-16
C_90_118_0_0 n0_45 n1_192 3.166938985094135e-18
C_90_115_0_0 n0_45 n1_16 4.373809036239223e-17
C_90_164_0_0 n0_97 n1_66 3.220508164868877e-14
C_90_156_0_0 n0_97 n1_60 8.396692421556125e-16
C_91_92_0_0 n0_98 n0_99 2.231841058512228e-16
C_91_158_0_0 n0_98 n1_62 9.284988670965923e-16
C_91_165_0_0 n0_98 n1_68 3.731926167572901e-14
C_92_93_0_0 n0_99 sbPin_10 4.768792366042299e-16
C_93_99_0_0 sbPin_10 sbPin_9 3.719772627684062e-17
C_93_99_1_0 sbPin_10 n0_104 2.770489312397799e-17
C_93_167_0_0 n0_99 n1_68 2.738005542627694e-15
C_93_98_0_0 n0_99 n0_102 7.198164571712504e-18
C_93_94_0_0 sbPin_10 n0_100 4.679614850236483e-16
C_94_99_0_0 n0_100 n0_104 1.59084678604492e-17
C_94_99_2_0 n0_100 sbPin_9 1.771439164777572e-17
C_94_167_0_0 sbPin_10 n1_68 2.056867189150302e-17
C_94_167_1_0 n0_100 n1_68 1.933245325965162e-17
C_94_160_0_0 sbPin_10 n1_62 5.709961031702037e-18
C_94_160_1_0 n0_100 n1_62 5.224129186702235e-18
C_95_157_0_0 n0_101 n1_61 9.286239888480674e-16
C_95_96_0_0 n0_52 n0_101 4.585125572876024e-16
C_95_166_0_0 n0_101 n1_67 3.23905133454905e-14
C_95_161_0_0 n0_52 n1_64 4.96442541920837e-17
C_96_97_0_0 n0_103 n0_102 1.238674082060793e-16
C_96_167_0_0 n0_103 n1_69 3.73202254022172e-14
C_96_159_0_0 n0_103 n1_63 1.579379557343999e-15
C_96_146_0_0 n0_103 n1_51 2.775622412627489e-17
C_96_146_1_0 n0_101 n1_49 2.775622412627477e-17
C_97_99_0_0 n0_102 sbPin_9 5.038706307140112e-17
C_98_167_0_0 n0_102 n1_69 3.330196551994716e-15
C_98_99_0_0 sbPin_9 n0_104 1.417894016845703e-16
C_99_167_0_0 sbPin_9 n1_69 5.717498072481703e-17
C_99_167_1_0 n0_104 n1_69 5.37098895501203e-17
C_99_160_0_0 sbPin_9 n1_63 7.558887484302019e-18
C_99_160_1_0 n0_104 n1_63 6.959417485689678e-18
C_100_130_0_0 n1_4 n1_6 4.084742905790631e-16
C_100_103_0_0 n1_3 n1_71 1.042238389139388e-16
C_100_101_0_0 n1_3 n1_5 3.388334207299002e-16
C_100_107_0_0 n1_4 n1_21 6.729393002326793e-16
C_100_155_0_0 n1_3 n1_58 6.649324293396099e-16
C_100_104_0_0 n1_3 n1_20 4.718836014044088e-16
C_101_140_0_0 n1_3 n1_13 5.70943696356113e-17
C_101_164_0_0 n1_3 n1_16 3.405711866186643e-17
C_101_118_0_0 n1_5 n1_191 1.274535033468805e-16
C_101_115_0_0 n1_3 n1_10 2.745478751524955e-16
C_101_105_0_0 n1_3 n1_91 3.076628186431742e-16
C_101_127_0_0 n1_3 n1_33 3.05753851252952e-17
C_102_126_0_0 n1_4 n1_14 5.028423168510048e-17
C_102_132_0_0 n1_4 n1_36 8.632175343559311e-16
C_102_164_0_0 n1_4 n1_16 5.428855925763937e-17
C_102_113_0_0 n1_4 n1_8 5.961913513606137e-16
C_102_106_0_0 n1_4 n1_112 2.627969128666508e-16
C_102_123_0_0 n1_4 n1_31 1.477110477502471e-17
C_102_123_1_0 n1_6 n1_31 2.349533920954317e-17
C_103_155_0_0 n1_72 n1_59 1.04436762122352e-16
C_103_127_0_0 n1_73 n1_33 3.847568075269171e-16
C_103_112_0_0 n1_74 n1_7 3.064740283955777e-16
C_103_104_0_0 n1_73 n1_19 1.125641946873429e-16
C_104_156_0_0 n1_20 n1_59 2.47700848114511e-15
C_104_112_0_0 n1_19 n1_7 1.644130232525584e-16
C_104_105_0_0 n1_20 n1_93 1.938558400651012e-16
C_105_155_0_0 n1_94 n1_59 7.859248907365624e-17
C_105_115_0_0 n1_93 n1_10 5.97922818118656e-16
C_106_113_0_0 n1_114 n1_8 4.211588017626374e-16
C_106_107_0_0 n1_113 n1_21 7.664148111982569e-17
C_107_113_0_0 n1_21 n1_8 7.379862572736469e-17
C_107_155_0_0 n1_22 n1_59 6.44225935430848e-17
C_107_127_0_0 n1_22 n1_33 6.419785081307921e-17
C_107_129_0_0 n1_22 n1_36 3.773439871971012e-15
C_108_155_0_0 n1_132 n1_59 5.879546226111408e-17
C_108_155_1_0 n1_131 n1_59 5.693962927138889e-17
C_108_132_0_0 n1_134 n1_36 1.997691560633292e-16
C_108_116_0_0 n1_133 n1_11 4.419896396007091e-16
C_109_142_0_0 n1_152 n1_47 3.567912435490577e-16
C_109_110_0_0 n1_151 n1_23 2.212141871711688e-16
C_109_131_0_0 n1_151 n1_197 9.663127270633671e-17
C_109_114_0_0 n1_154 n1_9 5.886288420002626e-16
C_109_128_0_0 n1_151 n1_34 2.939455016261747e-18
C_109_128_1_0 n1_150 n1_34 2.721953239823719e-18
C_110_114_0_0 n1_23 n1_9 5.923365535641362e-17
C_110_117_0_0 n1_24 n1_12 8.197469704900605e-17
C_110_141_0_0 n1_23 n1_46 1.260945173323003e-16
C_110_142_0_0 n1_24 n1_47 3.019514367567241e-15
C_111_163_0_0 n1_173 n1_64 3.348907563866748e-16
C_111_117_0_0 n1_173 n1_12 7.513306313766683e-17
C_111_142_0_0 n1_171 n1_47 8.257542340238348e-17
C_111_162_0_0 n1_173 sbPin_7 3.151656461505404e-18
C_112_156_0_0 n1_7 n1_59 3.208473368001917e-17
C_112_113_0_0 n1_13 n1_14 2.967280186065547e-17
C_112_113_1_0 n1_7 n1_8 2.967280186065547e-17
C_112_127_0_0 n1_7 n1_33 3.593454569503569e-16
C_112_140_0_0 n1_7 n1_13 2.549127215944925e-16
C_112_118_0_0 n1_7 n1_193 1.312084162330986e-17
C_112_152_0_0 n1_7 n1_58 7.28429378956111e-16
C_113_127_0_0 n1_8 n1_33 2.638649339728839e-16
C_113_126_0_0 n1_8 n1_14 5.09495496092612e-16
C_114_130_0_0 n1_9 n1_35 1.789938854661901e-17
C_114_128_0_0 n1_9 n1_34 3.381937533192188e-16
C_114_125_0_0 n1_9 n1_15 4.064777902776361e-16
C_114_142_0_0 n1_9 n1_46 5.662837240793114e-16
C_114_131_0_0 n1_9 n1_197 1.031325377794777e-16
C_115_118_0_0 n1_10 n1_192 6.463533118642257e-17
C_115_156_0_0 n1_10 n1_59 6.640402339425776e-16
C_115_164_0_0 n1_10 n1_16 4.371861130443712e-16
C_116_130_0_0 n1_11 n1_6 8.142744794040514e-18
C_116_129_0_0 n1_11 n1_36 1.098405127262547e-15
C_116_144_0_0 n1_11 n1_17 5.554167871821047e-16
C_116_156_0_0 n1_11 n1_59 8.246065036495887e-16
C_117_161_0_0 n1_18 n1_64 1.132683322846229e-15
C_117_157_0_0 n1_12 n1_18 8.856239404159738e-16
C_117_143_0_0 n1_12 n1_47 1.118092976359975e-15
C_118_155_0_0 n1_193 n1_58 8.640572494984546e-17
C_118_126_0_0 n1_193 n1_14 3.166938985094135e-18
C_118_140_0_0 n1_193 n1_13 3.166938985094135e-18
C_118_127_0_0 n1_193 n1_33 2.923836524841857e-18
C_118_127_1_0 n1_192 n1_33 2.745427136853951e-18
C_119_138_0_0 n1_25 n1_42 4.113287411716161e-15
C_119_121_0_0 n1_25 n1_29 1.297382700316212e-16
C_119_121_1_0 n1_26 n1_25 1.28873891232103e-16
C_119_124_0_0 n1_26 n1_28 3.540372400662031e-15
C_119_120_1_0 n1_25 n1_27 3.411549972516027e-15
C_119_137_0_0 n1_26 n1_43 3.91831389716447e-15
C_120_137_0_0 n1_28 n1_43 1.170606838019907e-16
C_120_137_1_0 n1_27 n1_42 1.319291027072406e-16
C_120_123_0_0 n1_27 n1_31 1.51867607830364e-16
C_120_123_1_0 n1_28 n1_27 2.413621209658359e-16
C_120_124_0_0 n1_28 n1_32 9.111833220010265e-17
C_121_126_0_0 n1_29 n1_31 2.786249786827598e-15
C_121_140_0_0 n1_29 n1_44 3.098005236995841e-15
C_121_149_0_0 n1_29 n1_54 2.134083382677928e-16
C_121_149_1_0 n1_25 n1_52 9.402483779382304e-17
C_122_130_0_0 n1_30 n1_35 8.142744794040511e-18
C_122_150_0_0 n1_30 n1_55 5.974494426184655e-17
C_122_150_1_0 n1_26 n1_53 5.974494426184649e-17
C_122_141_0_0 n1_30 n1_45 3.454768247230193e-15
C_122_124_0_0 n1_30 n1_32 3.082970924035413e-15
C_123_126_0_0 n1_31 n1_14 3.367787719071463e-16
C_123_138_0_0 n1_31 n1_44 5.684360054289432e-17
C_123_149_0_0 n1_31 n1_54 3.149857245474474e-17
C_123_149_1_0 n1_27 n1_52 5.4182524281322e-19
C_124_150_0_0 n1_32 n1_55 2.761391887382265e-17
C_124_150_1_0 n1_28 n1_53 2.761391887382262e-17
C_124_139_0_0 n1_32 n1_45 8.36243190219613e-17
C_125_154_0_0 n1_15 sbPin_6 5.853180578314025e-18
C_125_142_0_0 n1_15 n1_46 8.577124599270892e-17
C_125_153_0_0 n1_15 n1_56 5.735164023230607e-17
C_126_130_0_0 n1_14 n1_6 4.686273363136763e-17
C_126_152_0_0 n1_14 n1_58 3.183768530873513e-17
C_127_152_0_0 n1_33 n1_58 5.763322695935925e-17
C_127_155_0_0 n1_33 n1_59 1.181891392865652e-16
C_128_130_0_0 n1_34 n1_35 6.182410906987762e-16
C_128_162_0_0 n1_34 sbPin_7 3.151656461505404e-18
C_128_131_0_0 n1_34 n1_197 1.93443950672702e-16
C_128_141_0_0 n1_34 n1_46 1.114682588111389e-16
C_128_143_0_0 n1_34 n1_47 1.10947528474859e-16
C_129_130_0_0 n1_36 n1_6 1.061633911332228e-16
C_129_132_0_0 n1_33 n1_36 3.641729540981271e-16
C_130_157_0_0 n1_35 n1_18 8.142744794040511e-18
C_130_146_0_0 n1_35 n1_49 1.725697365953458e-17
C_130_143_0_0 n1_35 n1_47 9.002855809007081e-17
C_130_158_0_0 n1_6 n1_60 8.142744794040511e-18
C_130_153_0_0 n1_35 n1_56 8.142744794040511e-18
C_130_136_0_0 n1_6 n1_40 9.077485490543235e-18
C_130_133_0_0 n1_35 n1_37 2.283123178713812e-16
C_130_134_0_0 n1_6 n1_38 1.628548958808102e-17
C_130_135_0_0 n1_35 n1_39 1.628548958808102e-17
C_131_143_0_0 n1_196 n1_47 6.657742113201249e-16
C_131_141_0_0 n1_197 n1_46 1.182181317204637e-17
C_131_133_0_0 n1_195 n1_37 1.055247076358505e-16
C_132_145_0_0 n1_38 n1_48 3.460285680020411e-15
C_133_157_0_0 n1_39 n1_61 8.580301050718915e-17
C_133_143_0_0 n1_37 n1_47 1.693385179112046e-15
C_133_146_0_0 n1_39 n1_49 1.816757206540169e-15
C_134_158_0_0 n1_40 n1_62 5.793740008479667e-17
C_134_158_1_0 n1_38 n1_60 5.793740008479664e-17
C_134_147_0_0 n1_40 n1_50 3.564395914031761e-15
C_134_135_0_0 n1_40 n1_41 2.818223260053578e-16
C_134_136_0_0 n1_38 n1_40 5.213323872693235e-17
C_134_165_0_0 n1_40 n1_68 5.644792692094586e-17
C_134_165_1_0 n1_38 n1_66 2.774204045512378e-17
C_135_166_0_0 n1_41 n1_69 8.486901498108065e-17
C_135_166_1_0 n1_39 n1_67 5.616312851525851e-17
C_135_136_0_0 n1_39 n1_41 1.702579165772003e-16
C_135_146_1_0 n1_41 n1_51 3.501145296473101e-15
C_135_159_0_0 n1_41 n1_63 2.62558440555375e-17
C_137_149_0_0 n1_42 n1_52 3.802540732892693e-15
C_137_148_0_0 n1_43 n1_53 3.788231917687094e-15
C_137_138_0_0 n1_42 n1_44 1.102082874380225e-16
C_137_138_1_0 n1_43 n1_42 1.094758901059449e-16
C_138_149_0_0 n1_44 n1_54 3.161141446618862e-15
C_138_140_0_0 n1_44 n1_13 2.192972524799861e-16
C_139_162_0_0 n1_45 sbPin_7 1.638772289585423e-18
C_139_162_1_0 n1_45 n1_65 1.512884171919982e-18
C_139_141_0_0 n1_45 n1_46 4.334466063820607e-16
C_139_150_0_0 n1_45 n1_55 2.603573020758841e-15
C_140_155_0_0 n1_13 n1_58 5.886058898172915e-17
C_141_162_0_0 n1_46 sbPin_7 6.848936275668975e-18
C_141_154_0_0 n1_46 sbPin_6 2.384827093893939e-17
C_141_142_0_0 n1_46 n1_47 1.053678262411374e-15
C_141_151_0_0 n1_46 n1_56 9.961388430800327e-16
C_142_161_0_0 n1_47 n1_64 5.66919774475895e-17
C_143_157_0_0 n1_49 n1_61 2.911377215989696e-15
C_143_146_0_0 n1_47 n1_49 2.076540008359518e-16
C_143_163_0_0 n1_49 n1_67 1.783392270755837e-16
C_144_156_0_0 n1_48 n1_60 3.582288015970417e-15
C_145_147_0_0 n1_48 n1_50 1.072846837983932e-16
C_145_147_1_0 n1_50 n1_51 1.674660544585269e-16
C_145_158_0_0 n1_50 n1_62 3.25084373255384e-15
C_146_147_0_0 n1_49 n1_51 6.124846793335278e-17
C_146_167_0_0 n1_51 n1_69 1.455148951445036e-16
C_146_159_0_0 n1_51 n1_63 2.734417696894873e-15
C_148_249_0_0 n1_52 n3_28 7.220036925357395e-18
C_148_246_0_0 n1_53 n3_29 2.976895515886509e-18
C_148_150_0_0 n1_53 n1_55 2.07178042943864e-16
C_148_150_1_0 n1_52 n1_53 2.058041898979859e-16
C_150_151_0_0 n1_55 n1_56 8.205678080298245e-17
C_151_162_0_0 n1_56 sbPin_7 6.395068843783372e-18
C_151_154_0_0 n1_56 sbPin_6 5.780017397080119e-16
C_152_155_0_0 n1_58 n1_59 4.179840292581964e-16
C_153_162_0_0 sbPin_6 sbPin_7 1.898732015658947e-17
C_153_162_1_0 sbPin_6 n1_65 1.836585430504265e-17
C_154_162_0_0 n1_57 n1_65 1.179477923407267e-17
C_154_162_3_0 n1_57 sbPin_7 1.118382437729013e-17
C_156_164_0_0 n1_60 n1_66 3.033430332738249e-15
C_156_158_0_0 n1_59 n1_60 2.986082757172958e-16
C_157_162_0_0 n1_18 sbPin_7 1.087858163146772e-17
C_157_159_0_0 n1_18 n1_61 1.10158490114363e-16
C_157_166_0_0 n1_61 n1_67 2.393329551594006e-15
C_158_165_0_0 n1_62 n1_68 4.134089279830031e-15
C_158_160_0_0 n1_60 n1_62 1.956884635242668e-16
C_158_160_1_0 n1_62 n1_63 1.944474468562985e-16
C_159_166_0_0 n1_63 n1_69 4.232016459936484e-15
C_161_163_0_0 sbPin_7 n1_64 5.755540319706044e-16
C_163_166_0_0 n1_64 n1_67 3.938444454868708e-16
C_164_165_0_0 n1_16 n1_66 3.427769165276481e-16
C_165_167_0_0 n1_66 n1_68 1.589864449149568e-16
C_0_sub_0_0 n2_19 sn_0 6.34765322572273e-15
C_0_sub_1_0 n2_17 sn_0 6.34765322572273e-15
C_1_sub_0_0 n1_59 sn_1 5.101818578235222e-17
C_1_sub_1_0 n1_58 sn_1 5.101818578235222e-17
C_2_sub_0_0 n1_10 sn_2 1.529156152336029e-16
C_2_sub_1_0 n1_16 sn_2 1.529156152336029e-16
C_3_sub_0_0 n1_29 sn_3 7.063908098349246e-17
C_3_sub_1_0 n1_33 sn_3 7.063908098349246e-17
C_4_sub_0_0 n1_18 sn_4 6.095394122586433e-17
C_4_sub_1_0 n1_61 sn_4 6.095394122586433e-17
C_5_sub_0_0 n1_61 sn_5 1.244930623892292e-16
C_5_sub_1_0 n1_63 sn_5 1.244930623892292e-16
C_6_sub_0_0 n1_195 sn_6 8.013352040740097e-19
C_6_sub_1_0 n1_194 sn_6 8.013352040740097e-19
C_6_sub_2_0 n1_197 sn_6 8.013352040740097e-19
C_6_sub_3_0 n1_196 sn_6 8.013352040740097e-19
C_7_sub_0_0 n1_14 sn_7 1.640644796420525e-16
C_7_sub_1_0 n1_8 sn_7 1.640644796420525e-16
C_8_sub_0_0 n1_47 sn_8 1.181955954508205e-16
C_8_sub_1_0 n1_49 sn_8 1.181955954508205e-16
C_9_sub_0_0 n1_24 sn_9 1.99382484640556e-16
C_9_sub_1_0 n1_23 sn_9 1.99382484640556e-16
C_10_sub_0_0 n1_46 sn_10 3.319704819605481e-16
C_10_sub_1_0 n1_45 sn_10 3.319704819605481e-16
C_11_sub_0_0 n1_111 sn_11 2.620735134781691e-17
C_11_sub_1_0 n1_110 sn_11 2.620735134781691e-17
C_11_sub_2_0 n1_114 sn_11 2.620735134781691e-17
C_11_sub_3_0 n1_113 sn_11 2.620735134781691e-17
C_11_sub_4_0 n1_112 sn_11 2.620735134781691e-17
C_12_sub_0_0 n1_38 sn_12 4.261200992869577e-16
C_12_sub_1_0 n1_36 sn_12 4.261200992869577e-16
C_13_sub_0_0 n1_15 sn_13 4.04667928350915e-17
C_13_sub_1_0 n1_30 sn_13 4.04667928350915e-17
C_14_sub_0_0 n1_11 sn_14 1.224885882481027e-16
C_14_sub_1_0 n1_17 sn_14 1.224885882481027e-16
C_15_sub_0_0 n1_43 sn_15 1.361523427255285e-17
C_15_sub_1_0 n1_42 sn_15 1.361523427255285e-17
C_16_sub_0_0 n1_51 sn_16 3.807405023318125e-18
C_16_sub_1_0 n1_50 sn_16 3.807405023318125e-18
C_17_sub_0_0 n1_16 sn_17 4.52667880617597e-16
C_17_sub_1_0 n1_66 sn_17 4.52667880617597e-16
C_18_sub_0_0 n1_13 sn_18 6.018466489642792e-17
C_18_sub_1_0 n1_7 sn_18 6.018466489642792e-17
C_19_sub_0_0 n1_45 sn_19 1.054575130510956e-16
C_19_sub_1_0 n1_43 sn_19 1.054575130510956e-16
C_20_sub_0_0 n1_44 sn_20 1.712831089068339e-16
C_20_sub_1_0 n1_13 sn_20 1.712831089068339e-16
C_21_sub_0_0 n1_49 sn_21 9.524804308121424e-17
C_21_sub_1_0 n1_51 sn_21 9.524804308121424e-17
C_22_sub_0_0 n1_41 sn_22 2.891054982539356e-16
C_22_sub_1_0 n1_40 sn_22 2.891054982539356e-16
C_23_sub_0_0 n1_63 sn_23 2.385238256044589e-16
C_23_sub_1_0 n1_62 sn_23 2.385238256044589e-16
C_24_sub_0_0 n1_17 sn_24 1.6857847316866e-16
C_24_sub_1_0 n1_48 sn_24 1.6857847316866e-16
C_25_sub_0_0 n1_39 sn_25 3.787988935538383e-16
C_25_sub_1_0 n1_41 sn_25 3.787988935538383e-16
C_26_sub_0_0 n1_15 sn_26 1.079105588159045e-16
C_26_sub_1_0 n1_9 sn_26 1.079105588159045e-16
C_27_sub_0_0 n1_42 sn_27 2.323311505839024e-16
C_27_sub_1_0 n1_44 sn_27 2.323311505839024e-16
C_28_sub_0_0 n1_25 sn_28 1.205845868506588e-16
C_28_sub_1_0 n1_29 sn_28 1.205845868506588e-16
C_29_sub_0_0 n1_34 sn_29 1.04474509578049e-16
C_29_sub_1_0 n1_32 sn_29 1.04474509578049e-16
C_30_sub_0_0 n1_32 sn_30 7.353547750353886e-16
C_30_sub_1_0 n1_28 sn_30 7.353547750353886e-16
C_31_sub_0_0 n1_55 sn_31 8.592326606703309e-16
C_31_sub_1_0 n1_53 sn_31 8.592326606703309e-16
C_32_sub_0_0 sbPin_6 sn_32 5.480258081099593e-16
C_32_sub_1_0 n1_56 sn_32 5.480258081099593e-16
C_33_sub_0_0 sbPin_7 sn_33 1.583551832433863e-16
C_33_sub_1_0 n1_64 sn_33 1.583551832433863e-16
C_34_sub_0_0 n1_52 sn_34 1.02797430426755e-15
C_34_sub_1_0 n1_54 sn_34 1.02797430426755e-15
C_35_sub_0_0 n1_67 sn_35 1.158483718316745e-15
C_35_sub_1_0 n1_69 sn_35 1.158483718316745e-15
C_36_sub_0_0 n1_56 sn_36 1.248393603706731e-16
C_36_sub_1_0 n1_55 sn_36 1.248393603706731e-16
C_37_sub_0_0 n1_28 sn_37 4.164369295969255e-16
C_37_sub_1_0 n1_27 sn_37 4.164369295969255e-16
C_38_sub_0_0 n1_53 sn_38 3.323612913504833e-16
C_38_sub_1_0 n1_52 sn_38 3.323612913504833e-16
C_39_sub_0_0 n1_54 sn_39 2.725375114829572e-16
C_39_sub_1_0 n1_58 sn_39 2.725375114829572e-16
C_40_sub_0_0 n1_36 sn_40 6.692353443354384e-17
C_40_sub_1_0 n1_33 sn_40 6.692353443354384e-17
C_41_sub_0_0 n1_6 sn_41 1.396016108825669e-15
C_41_sub_1_0 n1_4 sn_41 1.396016108825669e-15
C_42_sub_0_0 n1_37 sn_42 3.20060791025246e-16
C_42_sub_1_0 n1_39 sn_42 3.20060791025246e-16
C_43_sub_0_0 n1_68 sn_43 1.022606547111048e-15
C_43_sub_1_0 n1_66 sn_43 1.022606547111048e-15
C_44_sub_0_0 n1_57 sn_44 6.575037117222715e-16
C_44_sub_1_0 sbPin_6 sn_44 6.575037117222715e-16
C_45_sub_0_0 n1_65 sn_45 8.182863489053829e-16
C_45_sub_1_0 sbPin_7 sn_45 8.182863489053829e-16
C_46_sub_0_0 n1_4 sn_46 4.848457637161355e-15
C_46_sub_1_0 n1_3 sn_46 4.848457637161355e-15
C_47_sub_0_0 n1_27 sn_47 7.585414282427293e-16
C_47_sub_1_0 n1_31 sn_47 7.585414282427293e-16
C_48_sub_0_0 n1_190 sn_48 3.482028705439835e-16
C_48_sub_1_0 n1_193 sn_48 3.482028705439835e-16
C_48_sub_2_0 n1_192 sn_48 3.482028705439835e-16
C_48_sub_3_0 n1_191 sn_48 3.482028705439835e-16
C_49_sub_0_0 n1_40 sn_49 5.190024250412047e-16
C_49_sub_1_0 n1_38 sn_49 5.190024250412047e-16
C_50_sub_0_0 n1_31 sn_50 2.178731589601952e-16
C_50_sub_1_0 n1_14 sn_50 2.178731589601952e-16
C_51_sub_0_0 n1_3 sn_51 1.540340960544626e-15
C_51_sub_1_0 n1_5 sn_51 1.540340960544626e-15
C_52_sub_0_0 n1_35 sn_52 8.676481821925474e-15
C_52_sub_1_0 n1_6 sn_52 8.676481821925474e-15
C_53_sub_0_0 n2_30 sn_53 6.428830495546804e-15
C_53_sub_1_0 n2_27 sn_53 6.428830495546804e-15
C_54_sub_0_0 n0_61 sn_54 4.245115537310373e-16
C_54_sub_1_0 n0_62 sn_54 4.245115537310373e-16
C_55_sub_0_0 n0_77 sn_55 1.370728167612148e-16
C_55_sub_1_0 n0_80 sn_55 1.370728167612148e-16
C_56_sub_0_0 n0_26 sn_56 6.833916260563949e-16
C_56_sub_1_0 n0_50 sn_56 6.833916260563949e-16
C_57_sub_0_0 n0_28 sn_57 3.573274876325629e-16
C_57_sub_1_0 n0_52 sn_57 3.573274876325629e-16
C_58_sub_0_0 n0_95 sn_58 3.450701567520244e-16
C_58_sub_1_0 n0_94 sn_58 3.450701567520244e-16
C_59_sub_0_0 n0_50 sn_59 8.545872382958175e-16
C_59_sub_1_0 n0_87 sn_59 8.545872382958175e-16
C_60_sub_0_0 n0_22 sn_60 5.825715220129636e-16
C_60_sub_1_0 n0_46 sn_60 5.825715220129636e-16
C_61_sub_0_0 n0_82 sn_61 9.027042684908003e-16
C_61_sub_1_0 n0_38 sn_61 9.027042684908003e-16
C_62_sub_0_0 n2_15 sn_62 7.353327164992231e-15
C_62_sub_1_0 n2_18 sn_62 7.353327164992231e-15
C_63_sub_0_0 n0_137 sn_63 1.487777241874508e-16
C_63_sub_1_0 n0_136 sn_63 1.487777241874508e-16
C_63_sub_2_0 n0_135 sn_63 1.487777241874508e-16
C_63_sub_3_0 n0_139 sn_63 1.487777241874508e-16
C_63_sub_4_0 n0_138 sn_63 1.487777241874508e-16
C_64_sub_0_0 n0_25 sn_64 4.836273684631147e-16
C_64_sub_1_0 n0_49 sn_64 4.836273684631147e-16
C_65_sub_0_0 n2_39 sn_65 6.804820498550329e-16
C_65_sub_1_0 n2_41 sn_65 6.804820498550329e-16
C_66_sub_0_0 sbPin_3 sn_66 8.820125596573236e-16
C_66_sub_1_0 n2_33 sn_66 8.820125596573236e-16
C_67_sub_0_0 n0_40 sn_67 4.86448192841415e-16
C_67_sub_1_0 n0_16 sn_67 4.86448192841415e-16
C_68_sub_0_0 n2_20 sn_68 3.344945003230164e-15
C_68_sub_1_0 n2_18 sn_68 3.344945003230164e-15
C_69_sub_0_0 n2_3 sn_69 1.436377951810387e-15
C_69_sub_1_0 n2_7 sn_69 1.436377951810387e-15
C_70_sub_0_0 n0_9 sn_70 3.995405959285062e-16
C_70_sub_1_0 n0_212 sn_70 3.995405959285062e-16
C_70_sub_2_0 n0_211 sn_70 3.995405959285062e-16
C_70_sub_3_0 n0_10 sn_70 3.995405959285062e-16
C_71_sub_0_0 n2_11 sn_71 1.443502895216755e-15
C_71_sub_1_0 n2_6 sn_71 1.443502895216755e-15
C_72_sub_0_0 n0_37 sn_72 2.190849446227653e-16
C_72_sub_1_0 n0_13 sn_72 2.190849446227653e-16
C_73_sub_0_0 n2_10 sn_73 5.087192412650046e-16
C_73_sub_1_0 sbPin_3 sn_73 5.087192412650046e-16
C_74_sub_0_0 n0_41 sn_74 3.07931500786479e-16
C_74_sub_1_0 n0_17 sn_74 3.07931500786479e-16
C_75_sub_0_0 n2_22 sn_75 3.432437973763145e-15
C_75_sub_1_0 n2_24 sn_75 3.432437973763145e-15
C_76_sub_0_0 n0_16 sn_76 1.154744367323314e-15
C_76_sub_1_0 n0_24 sn_76 1.154744367323314e-15
C_77_sub_0_0 n2_32 sn_77 9.156001916156935e-16
C_77_sub_1_0 sbPin_1 sn_77 9.156001916156935e-16
C_78_sub_0_0 n0_39 sn_78 5.457455966416905e-16
C_78_sub_1_0 n0_15 sn_78 5.457455966416905e-16
C_79_sub_0_0 n2_49 sn_79 8.831210901525895e-16
C_79_sub_1_0 sbPin_2 sn_79 8.831210901525895e-16
C_80_sub_0_0 n0_35 sn_80 1.278641432506188e-15
C_80_sub_1_0 n0_65 sn_80 1.278641432506188e-15
C_81_sub_0_0 n2_97 sn_81 7.434341758529091e-16
C_81_sub_1_0 n2_96 sn_81 7.434341758529091e-16
C_81_sub_2_0 n2_99 sn_81 7.434341758529091e-16
C_81_sub_3_0 n2_98 sn_81 7.434341758529091e-16
C_82_sub_0_0 n0_11 sn_82 3.308963764588825e-16
C_82_sub_1_0 n0_35 sn_82 3.308963764588825e-16
C_83_sub_0_0 n2_24 sn_83 6.849619876917519e-15
C_83_sub_1_0 n2_26 sn_83 6.849619876917519e-15
C_84_sub_0_0 n0_18 sn_84 2.483091382144276e-15
C_84_sub_1_0 n0_26 sn_84 2.483091382144276e-15
C_85_sub_0_0 n2_104 sn_85 6.574930638125391e-16
C_85_sub_1_0 n2_103 sn_85 6.574930638125391e-16
C_85_sub_2_0 n2_106 sn_85 6.574930638125391e-16
C_85_sub_3_0 n2_105 sn_85 6.574930638125391e-16
C_86_sub_0_0 n0_36 sn_86 6.58688055553136e-16
C_86_sub_1_0 n0_12 sn_86 6.58688055553136e-16
C_87_sub_0_0 n2_28 sn_87 4.429665120880722e-15
C_87_sub_1_0 n2_31 sn_87 4.429665120880722e-15
C_88_sub_0_0 n0_191 sn_88 1.826920494455627e-16
C_88_sub_1_0 n0_190 sn_88 1.826920494455627e-16
C_88_sub_2_0 n0_189 sn_88 1.826920494455627e-16
C_88_sub_3_0 n0_188 sn_88 1.826920494455627e-16
C_88_sub_4_0 n0_192 sn_88 1.826920494455627e-16
C_89_sub_0_0 n2_4 sn_89 1.474505676247046e-15
C_89_sub_1_0 n2_16 sn_89 1.474505676247046e-15
C_90_sub_0_0 n0_122 sn_90 1.008755781521861e-17
C_90_sub_1_0 n0_9 sn_90 1.008755781521861e-17
C_90_sub_2_0 n0_10 sn_90 1.008755781521861e-17
C_90_sub_3_0 n0_124 sn_90 1.008755781521861e-17
C_90_sub_4_0 n0_123 sn_90 1.008755781521861e-17
C_91_sub_0_0 n2_17 sn_91 2.997132562797956e-15
C_91_sub_1_0 n2_14 sn_91 2.997132562797956e-15
C_92_sub_0_0 n2_25 sn_92 3.730311868409198e-15
C_92_sub_1_0 n2_23 sn_92 3.730311868409198e-15
C_93_sub_0_0 n0_17 sn_93 2.595212701608018e-15
C_93_sub_1_0 n0_25 sn_93 2.595212701608018e-15
C_94_sub_0_0 n2_76 sn_94 5.264260816951486e-16
C_94_sub_1_0 n2_80 sn_94 5.264260816951486e-16
C_94_sub_2_0 n2_79 sn_94 5.264260816951486e-16
C_94_sub_3_0 n2_78 sn_94 5.264260816951486e-16
C_94_sub_4_0 n2_77 sn_94 5.264260816951486e-16
C_95_sub_0_0 n0_176 sn_95 1.242807072671193e-16
C_95_sub_1_0 n0_175 sn_95 1.242807072671193e-16
C_95_sub_2_0 n0_30 sn_95 1.242807072671193e-16
C_95_sub_3_0 n0_31 sn_95 1.242807072671193e-16
C_95_sub_4_0 n0_177 sn_95 1.242807072671193e-16
C_96_sub_0_0 sbPin_2 sn_96 1.08125032913736e-15
C_96_sub_1_0 n2_48 sn_96 1.08125032913736e-15
C_97_sub_0_0 n0_64 sn_97 1.510369583308594e-15
C_97_sub_1_0 n0_37 sn_97 1.510369583308594e-15
C_98_sub_0_0 n2_23 sn_98 3.271935249196057e-15
C_98_sub_1_0 n2_22 sn_98 3.271935249196057e-15
C_99_sub_0_0 n0_15 sn_99 1.287166501686285e-15
C_99_sub_1_0 n0_23 sn_99 1.287166501686285e-15
C_100_sub_0_0 n2_21 sn_100 3.204414363309976e-15
C_100_sub_1_0 n2_20 sn_100 3.204414363309976e-15
C_101_sub_0_0 n0_14 sn_101 2.017563020650639e-15
C_101_sub_1_0 n0_22 sn_101 2.017563020650639e-15
C_102_sub_0_0 n2_46 sn_102 7.38546034632359e-17
C_102_sub_1_0 n2_45 sn_102 7.38546034632359e-17
C_103_sub_0_0 n0_30 sn_103 1.870855790695357e-16
C_103_sub_1_0 n0_225 sn_103 1.870855790695357e-16
C_103_sub_2_0 n0_224 sn_103 1.870855790695357e-16
C_103_sub_3_0 n0_31 sn_103 1.870855790695357e-16
C_104_sub_0_0 sbPin_1 sn_104 4.788687321406733e-16
C_104_sub_1_0 n2_8 sn_104 4.788687321406733e-16
C_105_sub_0_0 n0_38 sn_105 3.851965249514443e-16
C_105_sub_1_0 n0_14 sn_105 3.851965249514443e-16
C_106_sub_0_0 n2_132 sn_106 1.86669862373329e-16
C_106_sub_1_0 n2_131 sn_106 1.86669862373329e-16
C_106_sub_2_0 n2_130 sn_106 1.86669862373329e-16
C_106_sub_3_0 n2_129 sn_106 1.86669862373329e-16
C_106_sub_4_0 n2_133 sn_106 1.86669862373329e-16
C_107_sub_0_0 n0_67 sn_107 1.391017806222867e-15
C_107_sub_1_0 n0_36 sn_107 1.391017806222867e-15
C_108_sub_0_0 n2_58 sn_108 5.594301110108566e-16
C_108_sub_1_0 n2_57 sn_108 5.594301110108566e-16
C_108_sub_2_0 n2_56 sn_108 5.594301110108566e-16
C_108_sub_3_0 n2_60 sn_108 5.594301110108566e-16
C_108_sub_4_0 n2_59 sn_108 5.594301110108566e-16
C_109_sub_0_0 n2_50 sn_109 7.604805735016881e-16
C_109_sub_1_0 n2_53 sn_109 7.604805735016881e-16
C_110_sub_0_0 n0_66 sn_110 7.639271544957556e-16
C_110_sub_1_0 n0_39 sn_110 7.639271544957556e-16
C_111_sub_0_0 n2_50 sn_111 6.778622375621443e-16
C_111_sub_1_0 n2_46 sn_111 6.778622375621443e-16
C_112_sub_0_0 n0_33 sn_112 2.484900259971017e-15
C_112_sub_1_0 n0_63 sn_112 2.484900259971017e-15
C_113_sub_0_0 n2_110 sn_113 1.918696617101854e-16
C_113_sub_1_0 n2_109 sn_113 1.918696617101854e-16
C_113_sub_2_0 n2_113 sn_113 1.918696617101854e-16
C_113_sub_3_0 n2_112 sn_113 1.918696617101854e-16
C_113_sub_4_0 n2_111 sn_113 1.918696617101854e-16
C_114_sub_0_0 n0_21 sn_114 7.897886625255651e-16
C_114_sub_1_0 n0_45 sn_114 7.897886625255651e-16
C_115_sub_0_0 n2_34 sn_115 2.200094360540634e-15
C_115_sub_1_0 n2_38 sn_115 2.200094360540634e-15
C_116_sub_0_0 n0_44 sn_116 4.133420181955125e-16
C_116_sub_1_0 n0_20 sn_116 4.133420181955125e-16
C_117_sub_0_0 n2_55 sn_117 9.847178117384194e-16
C_117_sub_1_0 n2_54 sn_117 9.847178117384194e-16
C_118_sub_0_0 n0_70 sn_118 1.476577991560806e-15
C_118_sub_1_0 n0_69 sn_118 1.476577991560806e-15
C_119_sub_0_0 n2_36 sn_119 6.747560821629686e-16
C_119_sub_1_0 n2_39 sn_119 6.747560821629686e-16
C_120_sub_0_0 n0_217 sn_120 1.757144753913635e-16
C_120_sub_1_0 n0_216 sn_120 1.757144753913635e-16
C_120_sub_2_0 n0_215 sn_120 1.757144753913635e-16
C_120_sub_3_0 n0_214 sn_120 1.757144753913635e-16
C_121_sub_0_0 n2_42 sn_121 7.202516931046312e-17
C_121_sub_1_0 n2_41 sn_121 7.202516931046312e-17
C_122_sub_0_0 n2_35 sn_122 9.354437788893471e-16
C_122_sub_1_0 n2_34 sn_122 9.354437788893471e-16
C_123_sub_0_0 n0_42 sn_123 2.911187730079182e-16
C_123_sub_1_0 n0_18 sn_123 2.911187730079182e-16
C_124_sub_0_0 n2_43 sn_124 1.264897149356361e-16
C_124_sub_1_0 n2_42 sn_124 1.264897149356361e-16
C_125_sub_0_0 n3_20 sn_125 2.704756388233152e-15
C_125_sub_1_0 n3_12 sn_125 2.704756388233152e-15
C_126_sub_0_0 n0_80 sn_126 1.286714394363502e-15
C_126_sub_1_0 n0_79 sn_126 1.286714394363502e-15
C_127_sub_0_0 n3_26 sn_127 2.101720280059729e-15
C_127_sub_1_0 n3_21 sn_127 2.101720280059729e-15
C_128_sub_0_0 n3_9 sn_128 3.085016867447865e-15
C_128_sub_1_0 n3_8 sn_128 3.085016867447865e-15
C_129_sub_0_0 n0_74 sn_129 3.316978728018406e-16
C_129_sub_1_0 n0_40 sn_129 3.316978728018406e-16
C_130_sub_0_0 sbPin_5 sn_130 9.267571332658865e-16
C_130_sub_1_0 n3_7 sn_130 9.267571332658865e-16
C_131_sub_0_0 n0_71 sn_131 4.557808765894238e-15
C_131_sub_1_0 n0_74 sn_131 4.557808765894238e-15
C_132_sub_0_0 n3_17 sn_132 9.456779022979098e-16
C_132_sub_1_0 sbPin_4 sn_132 9.456779022979098e-16
C_133_sub_0_0 n0_48 sn_133 5.613393819299175e-16
C_133_sub_1_0 n0_83 sn_133 5.613393819299175e-16
C_134_sub_0_0 n3_14 sn_134 2.127520784769058e-15
C_134_sub_1_0 n3_11 sn_134 2.127520784769058e-15
C_135_sub_0_0 n0_78 sn_135 2.087130161012764e-15
C_135_sub_1_0 n0_77 sn_135 2.087130161012764e-15
C_136_sub_0_0 n3_3 sn_136 2.579270921841827e-15
C_136_sub_1_0 n3_2 sn_136 2.579270921841827e-15
C_137_sub_0_0 n3_16 sn_137 1.608062574908825e-15
C_137_sub_1_0 n3_22 sn_137 1.608062574908825e-15
C_138_sub_0_0 n0_84 sn_138 3.986508667719081e-15
C_138_sub_1_0 n0_83 sn_138 3.986508667719081e-15
C_139_sub_0_0 n3_12 sn_139 3.26966588420884e-15
C_139_sub_1_0 n3_9 sn_139 3.26966588420884e-15
C_140_sub_0_0 n0_75 sn_140 1.784024133188049e-15
C_140_sub_1_0 n0_34 sn_140 1.784024133188049e-15
C_141_sub_0_0 n3_22 sn_141 3.825441212950512e-15
C_141_sub_1_0 n3_29 sn_141 3.825441212950512e-15
C_142_sub_0_0 n0_88 sn_142 1.130976425596854e-15
C_142_sub_1_0 n0_55 sn_142 1.130976425596854e-15
C_143_sub_0_0 n2_45 sn_143 2.949492152434622e-17
C_143_sub_1_0 n2_44 sn_143 2.949492152434622e-17
C_144_sub_0_0 n0_219 sn_144 2.815452745327475e-16
C_144_sub_1_0 n0_218 sn_144 2.815452745327475e-16
C_144_sub_2_0 n0_221 sn_144 2.815452745327475e-16
C_144_sub_3_0 n0_220 sn_144 2.815452745327475e-16
C_145_sub_0_0 n3_4 sn_145 3.332944496371188e-16
C_145_sub_1_0 sbPin_5 sn_145 3.332944496371188e-16
C_146_sub_0_0 n0_42 sn_146 7.881419095665068e-16
C_146_sub_1_0 n0_73 sn_146 7.881419095665068e-16
C_147_sub_0_0 n3_38 sn_147 2.499919005914742e-16
C_147_sub_1_0 n3_37 sn_147 2.499919005914742e-16
C_147_sub_2_0 n3_5 sn_147 2.499919005914742e-16
C_147_sub_3_0 n3_6 sn_147 2.499919005914742e-16
C_147_sub_4_0 n3_39 sn_147 2.499919005914742e-16
C_148_sub_0_0 n0_53 sn_148 1.86425049235585e-15
C_148_sub_1_0 n0_84 sn_148 1.86425049235585e-15
C_149_sub_0_0 n3_30 sn_149 2.86195630693131e-16
C_149_sub_1_0 n3_33 sn_149 2.86195630693131e-16
C_149_sub_2_0 n3_32 sn_149 2.86195630693131e-16
C_149_sub_3_0 n3_31 sn_149 2.86195630693131e-16
C_150_sub_0_0 n0_72 sn_150 1.197961143217342e-15
C_150_sub_1_0 n0_71 sn_150 1.197961143217342e-15
C_151_sub_0_0 n3_10 sn_151 2.37860329760167e-15
C_151_sub_1_0 n3_15 sn_151 2.37860329760167e-15
C_152_sub_0_0 n3_13 sn_152 2.573952696278361e-15
C_152_sub_1_0 n3_23 sn_152 2.573952696278361e-15
C_153_sub_0_0 n0_79 sn_153 3.431804642215361e-15
C_153_sub_1_0 n0_82 sn_153 3.431804642215361e-15
C_154_sub_0_0 n3_18 sn_154 2.432293448680016e-15
C_154_sub_1_0 n3_14 sn_154 2.432293448680016e-15
C_155_sub_0_0 n0_81 sn_155 5.858764897469812e-15
C_155_sub_1_0 n0_78 sn_155 5.858764897469812e-15
C_156_sub_0_0 sbPin_4 sn_156 1.023734796591859e-15
C_156_sub_1_0 n3_16 sn_156 1.023734796591859e-15
C_157_sub_0_0 n3_8 sn_157 3.412380142795389e-15
C_157_sub_1_0 n3_13 sn_157 3.412380142795389e-15
C_158_sub_0_0 n0_76 sn_158 5.284486419048451e-15
C_158_sub_1_0 n0_75 sn_158 5.284486419048451e-15
C_159_sub_0_0 n3_24 sn_159 1.823600084098076e-15
C_159_sub_1_0 n3_19 sn_159 1.823600084098076e-15
C_160_sub_0_0 n0_85 sn_160 3.002044042346465e-15
C_160_sub_1_0 n0_86 sn_160 3.002044042346465e-15
C_161_sub_0_0 n3_15 sn_161 1.391522832236416e-15
C_161_sub_1_0 n3_21 sn_161 1.391522832236416e-15
C_162_sub_0_0 n0_44 sn_162 1.317072447989757e-15
C_162_sub_1_0 n0_81 sn_162 1.317072447989757e-15
C_163_sub_0_0 n2_37 sn_163 1.848613486870145e-16
C_163_sub_1_0 n2_35 sn_163 1.848613486870145e-16
C_164_sub_0_0 n0_43 sn_164 6.35775063140371e-16
C_164_sub_1_0 n0_19 sn_164 6.35775063140371e-16
C_165_sub_0_0 n3_25 sn_165 1.841854452373848e-15
C_165_sub_1_0 n3_24 sn_165 1.841854452373848e-15
C_166_sub_0_0 n0_87 sn_166 4.101578134555626e-15
C_166_sub_1_0 n0_88 sn_166 4.101578134555626e-15
C_167_sub_0_0 n2_12 sn_167 4.275302656381475e-15
C_167_sub_1_0 n2_15 sn_167 4.275302656381475e-15
C_168_sub_0_0 n0_4 sn_168 1.213803508552952e-15
C_168_sub_1_0 n0_6 sn_168 1.213803508552952e-15
C_169_sub_0_0 n3_27 sn_169 2.025184287251907e-15
C_169_sub_1_0 n3_26 sn_169 2.025184287251907e-15
C_170_sub_0_0 n0_90 sn_170 3.052525357768777e-15
C_170_sub_1_0 n0_89 sn_170 3.052525357768777e-15
C_171_sub_0_0 n0_41 sn_171 5.387511578797867e-16
C_171_sub_1_0 n0_68 sn_171 5.387511578797867e-16
C_172_sub_0_0 n2_54 sn_172 1.602381809368954e-16
C_172_sub_1_0 n2_52 sn_172 1.602381809368954e-16
C_173_sub_0_0 n2_44 sn_173 6.514105775892353e-17
C_173_sub_1_0 n2_47 sn_173 6.514105775892353e-17
C_174_sub_0_0 n0_32 sn_174 4.409092298076796e-16
C_174_sub_1_0 n0_56 sn_174 4.409092298076796e-16
C_175_sub_0_0 n2_13 sn_175 5.121427506278024e-15
C_175_sub_1_0 n2_12 sn_175 5.121427506278024e-15
C_176_sub_0_0 n0_5 sn_176 1.513366148859732e-15
C_176_sub_1_0 n0_3 sn_176 1.513366148859732e-15
C_177_sub_0_0 n3_28 sn_177 3.699533911597981e-15
C_177_sub_1_0 n3_23 sn_177 3.699533911597981e-15
C_178_sub_0_0 n0_46 sn_178 1.061958146391314e-15
C_178_sub_1_0 n0_89 sn_178 1.061958146391314e-15
C_179_sub_0_0 n2_16 sn_179 6.100510095538141e-15
C_179_sub_1_0 n2_13 sn_179 6.100510095538141e-15
C_180_sub_0_0 n0_108 sn_180 4.780970976420264e-16
C_180_sub_1_0 n0_107 sn_180 4.780970976420264e-16
C_180_sub_2_0 n0_106 sn_180 4.780970976420264e-16
C_180_sub_3_0 n0_105 sn_180 4.780970976420264e-16
C_181_sub_0_0 n3_29 sn_181 3.311019450985251e-15
C_181_sub_1_0 n3_28 sn_181 3.311019450985251e-15
C_182_sub_0_0 n0_56 sn_182 1.54230607808171e-15
C_182_sub_1_0 n0_90 sn_182 1.54230607808171e-15
C_183_sub_0_0 n3_11 sn_183 2.227427880814418e-15
C_183_sub_1_0 n3_10 sn_183 2.227427880814418e-15
C_184_sub_0_0 n0_43 sn_184 5.926985653449994e-16
C_184_sub_1_0 n0_76 sn_184 5.926985653449994e-16
C_185_sub_0_0 n3_18 sn_185 1.990357033516996e-15
C_185_sub_1_0 n3_25 sn_185 1.990357033516996e-15
C_186_sub_0_0 n0_49 sn_186 4.599110482317837e-16
C_186_sub_1_0 n0_85 sn_186 4.599110482317837e-16
C_187_sub_0_0 n2_40 sn_187 3.740354491058678e-16
C_187_sub_1_0 n2_37 sn_187 3.740354491058678e-16
C_188_sub_0_0 n0_24 sn_188 3.717946730458011e-16
C_188_sub_1_0 n0_48 sn_188 3.717946730458011e-16
C_189_sub_0_0 n3_34 sn_189 8.871138452807941e-16
C_189_sub_1_0 n3_35 sn_189 8.871138452807941e-16
C_189_sub_2_0 n3_6 sn_189 8.871138452807941e-16
C_189_sub_3_0 n3_5 sn_189 8.871138452807941e-16
C_190_sub_0_0 n0_73 sn_190 3.154738883827761e-15
C_190_sub_1_0 n0_70 sn_190 3.154738883827761e-15
C_191_sub_0_0 n3_20 sn_191 2.232880688157966e-15
C_191_sub_1_0 n3_27 sn_191 2.232880688157966e-15
C_192_sub_0_0 n0_86 sn_192 2.281609545328179e-15
C_192_sub_1_0 n0_54 sn_192 2.281609545328179e-15
C_193_sub_0_0 n2_40 sn_193 7.465353298349586e-17
C_193_sub_1_0 n2_43 sn_193 7.465353298349586e-17
C_194_sub_0_0 n2_47 sn_194 1.716489673551107e-16
C_194_sub_1_0 n2_52 sn_194 1.716489673551107e-16
C_195_sub_0_0 n0_63 sn_195 5.796586573233214e-15
C_195_sub_1_0 n0_64 sn_195 5.796586573233214e-15
C_196_sub_0_0 n0_102 sn_196 1.190455300656196e-15
C_196_sub_1_0 sbPin_9 sn_196 1.190455300656196e-15
C_197_sub_0_0 n0_51 sn_197 9.28988429142152e-16
C_197_sub_1_0 n0_92 sn_197 9.28988429142152e-16
C_198_sub_0_0 n0_93 sn_198 3.575192332090521e-15
C_198_sub_1_0 n0_91 sn_198 3.575192332090521e-15
C_199_sub_0_0 n0_47 sn_199 6.608374645439717e-16
C_199_sub_1_0 n0_91 sn_199 6.608374645439717e-16
C_200_sub_0_0 sbPin_10 sn_200 1.168857014133942e-15
C_200_sub_1_0 n0_99 sn_200 1.168857014133942e-15
C_201_sub_0_0 n0_23 sn_201 4.871818205976086e-16
C_201_sub_1_0 n0_47 sn_201 4.871818205976086e-16
C_202_sub_0_0 n2_38 sn_202 2.064023606782743e-15
C_202_sub_1_0 n2_9 sn_202 2.064023606782743e-15
C_203_sub_0_0 n0_96 sn_203 1.90927074765272e-15
C_203_sub_1_0 n0_95 sn_203 1.90927074765272e-15
C_204_sub_0_0 n0_13 sn_204 2.320354525054601e-15
C_204_sub_1_0 n0_21 sn_204 2.320354525054601e-15
C_205_sub_0_0 n2_19 sn_205 3.352492044475695e-15
C_205_sub_1_0 n2_21 sn_205 3.352492044475695e-15
C_206_sub_0_0 n0_45 sn_206 1.779415597133097e-15
C_206_sub_1_0 n0_97 sn_206 1.779415597133097e-15
C_207_sub_0_0 n0_52 sn_207 1.684514261308917e-15
C_207_sub_1_0 n0_101 sn_207 1.684514261308917e-15
C_208_sub_0_0 n0_19 sn_208 2.405459183426359e-15
C_208_sub_1_0 n0_27 sn_208 2.405459183426359e-15
C_209_sub_0_0 n2_28 sn_209 7.483891296526658e-15
C_209_sub_1_0 n2_25 sn_209 7.483891296526658e-15
C_210_sub_0_0 n0_3 sn_210 4.238950980623294e-15
C_210_sub_1_0 n0_4 sn_210 4.238950980623294e-15
C_211_sub_0_0 n1_69 sn_211 9.587267799600269e-16
C_211_sub_1_0 n1_68 sn_211 9.587267799600269e-16
C_212_sub_0_0 sbPin_9 sn_212 5.879434813660295e-16
C_212_sub_1_0 n0_104 sn_212 5.879434813660295e-16
C_213_sub_0_0 n0_94 sn_213 2.064555176853951e-15
C_213_sub_1_0 n0_93 sn_213 2.064555176853951e-15
C_214_sub_0_0 n0_99 sn_214 1.915905685646981e-15
C_214_sub_1_0 n0_98 sn_214 1.915905685646981e-15
C_215_sub_0_0 n0_98 sn_215 5.744801897532188e-15
C_215_sub_1_0 n0_97 sn_215 5.744801897532188e-15
C_216_sub_0_0 n0_68 sn_216 4.543260015565541e-15
C_216_sub_1_0 n0_67 sn_216 4.543260015565541e-15
C_217_sub_0_0 n2_51 sn_217 2.112144695029772e-15
C_217_sub_1_0 n2_55 sn_217 2.112144695029772e-15
C_218_sub_0_0 n0_92 sn_218 3.805095546664806e-15
C_218_sub_1_0 n0_96 sn_218 3.805095546664806e-15
C_219_sub_0_0 n0_65 sn_219 2.936338458679061e-15
C_219_sub_1_0 n0_66 sn_219 2.936338458679061e-15
C_220_sub_0_0 n2_48 sn_220 1.205397395357694e-15
C_220_sub_1_0 n2_51 sn_220 1.205397395357694e-15
C_221_sub_0_0 n0_103 sn_221 2.120761569460186e-15
C_221_sub_1_0 n0_102 sn_221 2.120761569460186e-15
C_222_sub_0_0 n0_6 sn_222 1.890937802736391e-14
C_222_sub_1_0 n0_29 sn_222 1.890937802736391e-14
C_223_sub_0_0 n2_29 sn_223 2.759596187775667e-15
C_223_sub_1_0 n2_26 sn_223 2.759596187775667e-15
C_224_sub_0_0 n0_20 sn_224 3.046317381604436e-15
C_224_sub_1_0 n0_28 sn_224 3.046317381604436e-15
C_225_sub_0_0 n2_5 sn_225 3.852793641493583e-15
C_225_sub_1_0 n2_27 sn_225 3.852793641493583e-15
C_226_sub_0_0 n0_101 sn_226 5.557262581176439e-15
C_226_sub_1_0 n0_103 sn_226 5.557262581176439e-15
C_227_sub_0_0 sbPin_10 sn_227 6.929302453974402e-16
C_227_sub_1_0 n0_100 sn_227 6.929302453974402e-16
C_228_sub_0_0 n0_208 sn_228 2.694691436256829e-16
C_228_sub_1_0 n0_7 sn_228 2.694691436256829e-16
C_228_sub_2_0 n0_8 sn_228 2.694691436256829e-16
C_228_sub_3_0 n0_209 sn_228 2.694691436256829e-16
C_229_sub_0_0 n2_31 sn_229 4.901854153751706e-15
C_229_sub_1_0 n2_30 sn_229 4.901854153751706e-15
Rsub_1_15 sn_1 sn_15 1439909641.64485
Rsub_1_194 sn_1 sn_194 1393139446.791772
Rsub_1_187 sn_1 sn_187 192524038.4421827
Csub_1_187 sn_1 sn_187 5.472814505391871e-20
Rsub_1_28 sn_1 sn_28 1331800710.743451
Rsub_1_203 sn_1 sn_203 914572945.737144
Csub_1_203 sn_1 sn_203 1.15206595070857e-20
Rsub_1_228 sn_1 sn_228 1393139446.791772
Rsub_1_122 sn_1 sn_122 696569723.3958858
Csub_1_122 sn_1 sn_122 1.51262438609347e-20
Rsub_1_100 sn_1 sn_100 1393139446.791772
Rsub_1_89 sn_1 sn_89 563344759.6966182
Csub_1_89 sn_1 sn_89 1.870343749696772e-20
Rsub_1_118 sn_1 sn_118 220396184.1764719
Csub_1_118 sn_1 sn_118 4.780701418039709e-20
Rsub_1_123 sn_1 sn_123 1393139446.791772
Rsub_1_128 sn_1 sn_128 90036852.65209578
Csub_1_128 sn_1 sn_128 1.170241205891902e-19
Rsub_1_126 sn_1 sn_126 560113368.0779876
Csub_1_126 sn_1 sn_126 1.881134088690943e-20
Rsub_1_47 sn_1 sn_47 249919554.0115619
Csub_1_47 sn_1 sn_47 4.215950025960177e-20
Rsub_1_214 sn_1 sn_214 129743671.0853996
Csub_1_214 sn_1 sn_214 8.120999979486243e-20
Rsub_1_83 sn_1 sn_83 225637270.7795021
Csub_1_83 sn_1 sn_83 4.669655622863163e-20
Rsub_1_51 sn_1 sn_51 2077677.948058443
Csub_1_51 sn_1 sn_51 5.071278497264786e-18
Rsub_1_218 sn_1 sn_218 384535915.7102235
Csub_1_218 sn_1 sn_218 2.740051857774978e-20
Rsub_1_130 sn_1 sn_130 138692249.996105
Csub_1_130 sn_1 sn_130 7.5970239883814e-20
Rsub_1_115 sn_1 sn_115 157274540.9706897
Csub_1_115 sn_1 sn_115 6.699420921656749e-20
Rsub_1_183 sn_1 sn_183 556597918.2678733
Csub_1_183 sn_1 sn_183 1.893015255073074e-20
Rsub_1_229 sn_1 sn_229 38449762.00950687
Csub_1_229 sn_1 sn_229 2.740324764461432e-19
Rsub_1_62 sn_1 sn_62 245326660.286022
Csub_1_62 sn_1 sn_62 4.294879117477775e-20
Rsub_1_111 sn_1 sn_111 267084421.9707863
Csub_1_111 sn_1 sn_111 3.945001144013739e-20
Rsub_1_170 sn_1 sn_170 56054404.58274768
Csub_1_170 sn_1 sn_170 1.879688773908215e-19
Rsub_1_3 sn_1 sn_3 1393139446.791772
Rsub_1_91 sn_1 sn_91 697874388.2123233
Csub_1_91 sn_1 sn_91 1.509796559409535e-20
Rsub_1_72 sn_1 sn_72 29333557.37512351
Csub_1_72 sn_1 sn_72 3.591955577527575e-19
Rsub_1_167 sn_1 sn_167 454642934.8591666
Csub_1_167 sn_1 sn_167 2.317529360814516e-20
Rsub_1_114 sn_1 sn_114 171938619.2526011
Csub_1_114 sn_1 sn_114 6.128049386479301e-20
Rsub_1_76 sn_1 sn_76 61949395.68692344
Csub_1_76 sn_1 sn_76 1.700821030681029e-19
Rsub_1_155 sn_1 sn_155 132514152.999079
Csub_1_155 sn_1 sn_155 7.95121371096356e-20
Rsub_1_154 sn_1 sn_154 109082026.9565325
Csub_1_154 sn_1 sn_154 9.659229660655855e-20
Rsub_1_75 sn_1 sn_75 626774426.5538896
Csub_1_75 sn_1 sn_75 1.681064679068249e-20
Rsub_1_139 sn_1 sn_139 38084007.9884721
Csub_1_139 sn_1 sn_139 2.766642498714778e-19
Rsub_1_153 sn_1 sn_153 44097775.80169672
Csub_1_153 sn_1 sn_153 2.389345791409416e-19
Rsub_1_41 sn_1 sn_41 108918107.35712
Csub_1_41 sn_1 sn_41 9.673766610434247e-20
Rsub_1_208 sn_1 sn_208 1839940270.584801
Rsub_1_120 sn_1 sn_120 278217352.5530456
Csub_1_120 sn_1 sn_120 3.787141026806044e-20
Rsub_1_217 sn_1 sn_217 111885400.6209577
Csub_1_217 sn_1 sn_217 9.417210327489656e-20
Rsub_1_50 sn_1 sn_50 51816603.49242941
Csub_1_50 sn_1 sn_50 2.033418401067029e-19
Rsub_1_215 sn_1 sn_215 38654880.3432864
Csub_1_215 sn_1 sn_215 2.725783499692034e-19
Rsub_1_48 sn_1 sn_48 84551.90901446767
Csub_1_48 sn_1 sn_48 1.246155601339185e-16
Rsub_1_95 sn_1 sn_95 888373062.2597499
Csub_1_95 sn_1 sn_95 1.186042660436867e-20
Rsub_1_180 sn_1 sn_180 1393139446.791772
Rsub_1_34 sn_1 sn_34 52996898.23565751
Csub_1_34 sn_1 sn_34 1.988132108293994e-19
Rsub_1_201 sn_1 sn_201 104462933.703497
Csub_1_201 sn_1 sn_201 1.008633697014129e-19
Rsub_1_45 sn_1 sn_45 81826414.04747964
Csub_1_45 sn_1 sn_45 1.287662868388223e-19
Rsub_1_212 sn_1 sn_212 56847281.7676118
Csub_1_212 sn_1 sn_212 1.853471823912795e-19
Rsub_1_141 sn_1 sn_141 30774792.08905416
Csub_1_141 sn_1 sn_141 3.423738321851269e-19
Rsub_1_223 sn_1 sn_223 265337264.5471387
Csub_1_223 sn_1 sn_223 3.970977661284411e-20
Rsub_1_2 sn_1 sn_2 1853431716.32519
Rsub_1_169 sn_1 sn_169 181797953.3266138
Csub_1_169 sn_1 sn_169 5.795710737898359e-20
Rsub_1_39 sn_1 sn_39 6700358.271864026
Csub_1_39 sn_1 sn_39 1.572525389645884e-18
Rsub_1_206 sn_1 sn_206 17737156.74813705
Csub_1_206 sn_1 sn_206 5.940345260430006e-19
Rsub_1_24 sn_1 sn_24 53981863.96725625
Csub_1_24 sn_1 sn_24 1.951856184258682e-19
Rsub_1_191 sn_1 sn_191 223403379.6814742
Csub_1_191 sn_1 sn_191 4.716349196351816e-20
Rsub_1_97 sn_1 sn_97 7212929.423666133
Csub_1_97 sn_1 sn_97 1.46077729079936e-18
Rsub_1_222 sn_1 sn_222 4372393.787142273
Csub_1_222 sn_1 sn_222 2.409774602922139e-18
Rsub_1_129 sn_1 sn_129 995258253.2504071
Csub_1_129 sn_1 sn_129 1.058668287132407e-20
Rsub_1_67 sn_1 sn_67 19769777.9744281
Csub_1_67 sn_1 sn_67 5.329591215368619e-19
Rsub_1_17 sn_1 sn_17 17733331.06551373
Csub_1_17 sn_1 sn_17 5.941626794934457e-19
Rsub_1_44 sn_1 sn_44 260953896.0287473
Csub_1_44 sn_1 sn_44 4.037680089309446e-20
Rsub_1_79 sn_1 sn_79 200717704.0022549
Csub_1_79 sn_1 sn_79 5.249404159242292e-20
Rsub_1_158 sn_1 sn_158 4708651.293212804
Csub_1_158 sn_1 sn_158 2.237686090158686e-18
Rsub_1_195 sn_1 sn_195 13599558.26015251
Csub_1_195 sn_1 sn_195 7.747665990815677e-19
Rsub_1_99 sn_1 sn_99 64636588.16216736
Csub_1_99 sn_1 sn_99 1.630111335052976e-19
Rsub_1_178 sn_1 sn_178 70174586.57883826
Csub_1_178 sn_1 sn_178 1.501467128757886e-19
Rsub_1_20 sn_1 sn_20 10948280.43124299
Csub_1_20 sn_1 sn_20 9.623870678505965e-19
Rsub_1_105 sn_1 sn_105 21153696.32488926
Csub_1_105 sn_1 sn_105 4.980918389110496e-19
Rsub_1_40 sn_1 sn_40 1799730561.854852
Rsub_1_226 sn_1 sn_226 50858923.03191045
Csub_1_226 sn_1 sn_226 2.071707947024181e-19
Rsub_1_112 sn_1 sn_112 138412950.0169819
Csub_1_112 sn_1 sn_112 7.612353830286312e-20
Rsub_1_53 sn_1 sn_53 144044290.4753118
Csub_1_53 sn_1 sn_53 7.314752613562202e-20
Rsub_1_220 sn_1 sn_220 207647910.524285
Csub_1_220 sn_1 sn_220 5.074206369631507e-20
Rsub_1_132 sn_1 sn_132 88296406.10984679
Csub_1_132 sn_1 sn_132 1.193308308508264e-19
Rsub_1_125 sn_1 sn_125 129631825.4067798
Csub_1_125 sn_1 sn_125 8.128006736900378e-20
Rsub_1_204 sn_1 sn_204 46691901.29259179
Csub_1_204 sn_1 sn_204 2.256597656241027e-19
Rsub_1_46 sn_1 sn_46 27273782.32033327
Csub_1_46 sn_1 sn_46 3.863227834877452e-19
Rsub_1_213 sn_1 sn_213 685558158.0422864
Csub_1_213 sn_1 sn_213 1.536920446300063e-20
Rsub_1_80 sn_1 sn_80 720049718.8463572
Csub_1_80 sn_1 sn_80 1.463299439809691e-20
Rsub_1_38 sn_1 sn_38 10143737073.45471
Rsub_1_205 sn_1 sn_205 309629811.2203916
Csub_1_205 sn_1 sn_205 3.402929278902745e-20
Rsub_1_117 sn_1 sn_117 53418128.64983076
Csub_1_117 sn_1 sn_117 1.972454627023589e-19
Rsub_1_131 sn_1 sn_131 29552106.78283894
Csub_1_131 sn_1 sn_131 3.565391658759365e-19
Rsub_1_52 sn_1 sn_52 457861.7734333619
Csub_1_52 sn_1 sn_52 2.301236773539799e-17
Rsub_1_219 sn_1 sn_219 42760349.78140357
Csub_1_219 sn_1 sn_219 2.464077949804869e-19
Rsub_1_61 sn_1 sn_61 1743450.786786109
Csub_1_61 sn_1 sn_61 6.043464823950113e-18
Rsub_1_77 sn_1 sn_77 109746579.4029587
Csub_1_77 sn_1 sn_77 9.600739776629381e-20
Rsub_1_156 sn_1 sn_156 305700376.1839728
Csub_1_156 sn_1 sn_156 3.446670113316794e-20
Rsub_1_181 sn_1 sn_181 47132151.20530318
Csub_1_181 sn_1 sn_181 2.23551932869223e-19
Rsub_1_177 sn_1 sn_177 20855858.04122183
Csub_1_177 sn_1 sn_177 5.052049875581492e-19
Rsub_1_227 sn_1 sn_227 88195248.38452564
Csub_1_227 sn_1 sn_227 1.19467700303894e-19
Rsub_1_60 sn_1 sn_60 209434050.8016565
Csub_1_60 sn_1 sn_60 5.030931437318437e-20
Rsub_1_69 sn_1 sn_69 78915037.7093755
Csub_1_69 sn_1 sn_69 1.335168024760155e-19
Rsub_1_25 sn_1 sn_25 437722743.9893488
Csub_1_25 sn_1 sn_25 2.407113554621778e-20
Rsub_1_192 sn_1 sn_192 1965756116.294125
Rsub_1_200 sn_1 sn_200 239412984.2422868
Csub_1_200 sn_1 sn_200 4.400965777013599e-20
Rsub_1_145 sn_1 sn_145 181159035.7061941
Csub_1_145 sn_1 sn_145 5.816151240348946e-20
Rsub_1_18 sn_1 sn_18 963402542.9986017
Csub_1_18 sn_1 sn_18 1.093674038832726e-20
Rsub_1_66 sn_1 sn_66 140526282.7285186
Csub_1_66 sn_1 sn_66 7.497873919133928e-20
Rsub_1_151 sn_1 sn_151 209226183.8979737
Csub_1_151 sn_1 sn_151 5.035929684292276e-20
Rsub_1_175 sn_1 sn_175 146836350.7022939
Csub_1_175 sn_1 sn_175 7.175664235617232e-20
Rsub_1_199 sn_1 sn_199 165879122.8229684
Csub_1_199 sn_1 sn_199 6.35190452114633e-20
Rsub_1_198 sn_1 sn_198 90814540.84614243
Csub_1_198 sn_1 sn_198 1.160219872727305e-19
Rsub_1_30 sn_1 sn_30 520855684.3961861
Csub_1_30 sn_1 sn_30 2.022918020841927e-20
Rsub_1_197 sn_1 sn_197 448320258.2020512
Csub_1_197 sn_1 sn_197 2.350213560387754e-20
Rsub_1_49 sn_1 sn_49 146580542.349256
Csub_1_49 sn_1 sn_49 7.188187008562723e-20
Rsub_1_138 sn_1 sn_138 90283671.36821406
Csub_1_138 sn_1 sn_138 1.167041984730315e-19
Rsub_1_161 sn_1 sn_161 2786278893.583543
Rsub_1_101 sn_1 sn_101 6644772.482688397
Csub_1_101 sn_1 sn_101 1.585680101114172e-18
Rsub_1_190 sn_1 sn_190 197957355.1763641
Csub_1_190 sn_1 sn_190 5.322602685231292e-20
Rsub_1_23 sn_1 sn_23 582135885.6507566
Csub_1_23 sn_1 sn_23 1.809969761690864e-20
Rsub_1_110 sn_1 sn_110 116902186.8782792
Csub_1_110 sn_1 sn_110 9.013076473240651e-20
Rsub_1_134 sn_1 sn_134 173203088.9831106
Csub_1_134 sn_1 sn_134 6.083311541434136e-20
Rsub_1_87 sn_1 sn_87 1015696695.092755
Csub_1_87 sn_1 sn_87 1.037365145829069e-20
Rsub_1_85 sn_1 sn_85 257792244.6159649
Csub_1_85 sn_1 sn_85 4.087199565652676e-20
Rsub_1_152 sn_1 sn_152 117738644.231628
Csub_1_152 sn_1 sn_152 8.949044360916465e-20
Rsub_1_202 sn_1 sn_202 157910102.9573711
Csub_1_202 sn_1 sn_202 6.672456863050994e-20
Rsub_1_35 sn_1 sn_35 213883552.5145297
Csub_1_35 sn_1 sn_35 4.926271037841597e-20
Rsub_1_148 sn_1 sn_148 744299605.8759176
Csub_1_148 sn_1 sn_148 1.415623952914808e-20
Rsub_1_43 sn_1 sn_43 233343036.7660902
Csub_1_43 sn_1 sn_43 4.51544800661529e-20
Rsub_1_210 sn_1 sn_210 534256501.3486583
Csub_1_210 sn_1 sn_210 1.972176936664706e-20
Rsub_1_64 sn_1 sn_64 667482907.7019994
Csub_1_64 sn_1 sn_64 1.578539821866728e-20
Rsub_1_81 sn_1 sn_81 111583662.9649757
Csub_1_81 sn_1 sn_81 9.442675766556641e-20
Rsub_1_68 sn_1 sn_68 1420805616.233211
Rsub_1_224 sn_1 sn_224 241666198.0074244
Csub_1_224 sn_1 sn_224 4.359932662947882e-20
Rsub_1_57 sn_1 sn_57 999459954.9668995
Csub_1_57 sn_1 sn_57 1.054217675242322e-20
Rsub_1_7 sn_1 sn_7 292465376.8176031
Csub_1_7 sn_1 sn_7 3.602643026289265e-20
Rsub_1_165 sn_1 sn_165 872428758.8393687
Csub_1_165 sn_1 sn_165 1.207718497983395e-20
Rsub_1_78 sn_1 sn_78 140082453.5335868
Csub_1_78 sn_1 sn_78 7.52162975194015e-20
Rsub_1_96 sn_1 sn_96 691134369.7862121
Csub_1_96 sn_1 sn_96 1.524520261593884e-20
Rsub_1_160 sn_1 sn_160 190265838.9523762
Csub_1_160 sn_1 sn_160 5.537769449442419e-20
Rsub_1_137 sn_1 sn_137 247829975.2870859
Csub_1_137 sn_1 sn_137 4.251496813500689e-20
Rsub_1_176 sn_1 sn_176 586736183.9290509
Csub_1_176 sn_1 sn_176 1.795778714664049e-20
Rsub_1_119 sn_1 sn_119 1393139446.791772
Rsub_1_172 sn_1 sn_172 857944822.8220828
Csub_1_172 sn_1 sn_172 1.228107358649452e-20
Rsub_1_71 sn_1 sn_71 377938820.0728388
Csub_1_71 sn_1 sn_71 2.78788072106468e-20
Rsub_1_188 sn_1 sn_188 188306641.1095566
Csub_1_188 sn_1 sn_188 5.595386036385133e-20
Rsub_1_196 sn_1 sn_196 209171627.4544843
Csub_1_196 sn_1 sn_196 5.037243162685981e-20
Rsub_1_209 sn_1 sn_209 1393139446.791772
Rsub_1_179 sn_1 sn_179 298043730.7416649
Csub_1_179 sn_1 sn_179 3.535213935220364e-20
Rsub_1_133 sn_1 sn_133 119970343.0889458
Csub_1_133 sn_1 sn_133 8.782573451855739e-20
Rsub_1_230 sn_1 0 1041381.27029978
Csub_1_230 sn_1 0 1.011779624113739e-17
Rsub_1_182 sn_1 sn_182 1245313883.890301
Rsub_1_150 sn_1 sn_150 381589048.1302785
Csub_1_150 sn_1 sn_150 2.761212239674325e-20
Rsub_1_189 sn_1 sn_189 752664787.5926182
Csub_1_189 sn_1 sn_189 1.399890585546151e-20
Rsub_1_22 sn_1 sn_22 441486499.6039668
Csub_1_22 sn_1 sn_22 2.386592457907932e-20
Rsub_1_92 sn_1 sn_92 683516196.7717426
Csub_1_92 sn_1 sn_92 1.54151189861981e-20
Rsub_1_162 sn_1 sn_162 468835031.2932695
Csub_1_162 sn_1 sn_162 2.247375473024142e-20
Rsub_1_225 sn_1 sn_225 205979180.3115587
Csub_1_225 sn_1 sn_225 5.115314803317886e-20
Rsub_1_186 sn_1 sn_186 910168413.5067425
Csub_1_186 sn_1 sn_186 1.157641085525536e-20
Rsub_1_107 sn_1 sn_107 506674706.1099295
Csub_1_107 sn_1 sn_107 2.079536115612603e-20
Rsub_1_136 sn_1 sn_136 528788418.6047252
Csub_1_136 sn_1 sn_136 1.992570777179999e-20
Rsub_1_121 sn_1 sn_121 1393139446.791772
Rsub_1_88 sn_1 sn_88 481598410.9337127
Csub_1_88 sn_1 sn_88 2.187815254996812e-20
Rsub_1_142 sn_1 sn_142 1114048860.520889
Rsub_228_229 sn_228 sn_229 52415817.44854816
Csub_228_229 sn_228 sn_229 2.010172504239338e-19
Rsub_228_230 sn_228 0 141407.0507768982
Csub_228_230 sn_228 0 7.4511726567678e-17
Rsub_40_111 sn_40 sn_111 1799730561.854852
Rsub_40_145 sn_40 sn_145 1316420421.126359
Rsub_40_149 sn_40 sn_149 653274698.051337
Csub_40_149 sn_40 sn_149 1.612871818495258e-20
Rsub_40_122 sn_40 sn_122 1799730561.854852
Rsub_40_167 sn_40 sn_167 1921388353.119084
Rsub_40_109 sn_40 sn_109 1799730561.854852
Rsub_40_68 sn_40 sn_68 1799730561.854852
Rsub_40_135 sn_40 sn_135 2789780161.158905
Rsub_40_83 sn_40 sn_83 479479962.9170557
Csub_40_83 sn_40 sn_83 2.197481504363236e-20
Rsub_40_152 sn_40 sn_152 1417912534.887665
Rsub_40_86 sn_40 sn_86 445812740.6865895
Csub_40_86 sn_40 sn_86 2.363432567226078e-20
Rsub_40_137 sn_40 sn_137 2097041349.707288
Rsub_40_82 sn_40 sn_82 254891984.9601511
Csub_40_82 sn_40 sn_82 4.133705304180998e-20
Rsub_40_92 sn_40 sn_92 893485422.2770604
Csub_40_92 sn_40 sn_92 1.179256341460796e-20
Rsub_40_87 sn_40 sn_87 580336909.8426697
Csub_40_87 sn_40 sn_87 1.815580453961899e-20
Rsub_40_176 sn_40 sn_176 325039253.6848218
Csub_40_176 sn_40 sn_176 3.241603401060854e-20
Rsub_40_230 sn_40 0 1494103.953871939
Csub_40_230 sn_40 0 7.052041777230377e-18
Rsub_40_88 sn_40 sn_88 176634496.3682859
Csub_40_88 sn_40 sn_88 5.96513349253209e-20
Rsub_40_115 sn_40 sn_115 252101932.8248807
Csub_40_115 sn_40 sn_115 4.179453677393671e-20
Rsub_40_117 sn_40 sn_117 104354858.9650342
Csub_40_117 sn_40 sn_117 1.009678284914402e-19
Rsub_40_156 sn_40 sn_156 234553125.9348484
Csub_40_156 sn_40 sn_156 4.492152240664108e-20
Rsub_40_200 sn_40 sn_200 113937246.0172233
Csub_40_200 sn_40 sn_200 9.247619957952342e-20
Rsub_40_127 sn_40 sn_127 323451004.8335922
Csub_40_127 sn_40 sn_127 3.257520720224928e-20
Rsub_40_81 sn_40 sn_81 169600946.944316
Csub_40_81 sn_40 sn_81 6.212514547863566e-20
Rsub_40_159 sn_40 sn_159 476860345.9164008
Csub_40_159 sn_40 sn_159 2.209553298457148e-20
Rsub_40_224 sn_40 sn_224 182704769.1729827
Csub_40_224 sn_40 sn_224 5.766944973534974e-20
Rsub_40_185 sn_40 sn_185 857819619.0369761
Csub_40_185 sn_40 sn_185 1.228286608093517e-20
Rsub_40_150 sn_40 sn_150 200616335.8308901
Csub_40_150 sn_40 sn_150 5.252056597779629e-20
Rsub_40_157 sn_40 sn_157 106109062.9998837
Csub_40_157 sn_40 sn_157 9.929861978181402e-20
Rsub_40_85 sn_40 sn_85 239057373.9499781
Csub_40_85 sn_40 sn_85 4.407512442780671e-20
Rsub_40_96 sn_40 sn_96 672510189.2422097
Csub_40_96 sn_40 sn_96 1.566739607931086e-20
Rsub_40_103 sn_40 sn_103 101326621.4720998
Csub_40_103 sn_40 sn_103 1.03985343132468e-19
Rsub_40_67 sn_40 sn_67 303000238.6728259
Csub_40_67 sn_40 sn_67 3.477384555332678e-20
Rsub_40_154 sn_40 sn_154 225668339.131265
Csub_40_154 sn_40 sn_154 4.669012739133611e-20
Rsub_40_142 sn_40 sn_142 168679961.9969063
Csub_40_142 sn_40 sn_142 6.246434595724682e-20
Rsub_40_97 sn_40 sn_97 222705117.3935688
Csub_40_97 sn_40 sn_97 4.731136682238749e-20
Rsub_40_95 sn_40 sn_95 517269674.1951512
Csub_40_95 sn_40 sn_95 2.036942049352556e-20
Rsub_40_107 sn_40 sn_107 133551667.634525
Csub_40_107 sn_40 sn_107 7.889443605499518e-20
Rsub_40_179 sn_40 sn_179 176316676.3289328
Csub_40_179 sn_40 sn_179 5.975885957930238e-20
Rsub_40_183 sn_40 sn_183 1101892723.785964
Rsub_40_162 sn_40 sn_162 1799730561.854852
Rsub_40_180 sn_40 sn_180 252217242.635445
Csub_40_180 sn_40 sn_180 4.177542896010263e-20
Rsub_40_74 sn_40 sn_74 1054764415.965266
Rsub_40_56 sn_40 sn_56 1799730561.854852
Rsub_40_134 sn_40 sn_134 510324798.6710783
Csub_40_134 sn_40 sn_134 2.064662256207761e-20
Rsub_40_188 sn_40 sn_188 25987437.35337332
Csub_40_188 sn_40 sn_188 4.054452679945491e-19
Rsub_40_202 sn_40 sn_202 145241110.3775789
Csub_40_202 sn_40 sn_202 7.254477382360011e-20
Rsub_40_112 sn_40 sn_112 110311432.2635333
Csub_40_112 sn_40 sn_112 9.551578912563123e-20
Rsub_40_207 sn_40 sn_207 202307277.9561337
Csub_40_207 sn_40 sn_207 5.208158405707296e-20
Rsub_40_136 sn_40 sn_136 1799730561.854852
Rsub_40_190 sn_40 sn_190 216236232.1420026
Csub_40_190 sn_40 sn_190 4.872672538666268e-20
Rsub_40_191 sn_40 sn_191 863971370.556415
Csub_40_191 sn_40 sn_191 1.219540815969897e-20
Rsub_40_116 sn_40 sn_116 4033179277.355035
Rsub_40_72 sn_40 sn_72 200864767.2400487
Csub_40_72 sn_40 sn_72 5.245560805413973e-20
Rsub_40_129 sn_40 sn_129 290493505.9537832
Csub_40_129 sn_40 sn_129 3.627097778876452e-20
Rsub_40_123 sn_40 sn_123 1799730561.854852
Rsub_40_225 sn_40 sn_225 200894438.6557201
Csub_40_225 sn_40 sn_225 5.244786054175819e-20
Rsub_40_114 sn_40 sn_114 364553047.5488268
Csub_40_114 sn_40 sn_114 2.89024699507382e-20
Rsub_40_132 sn_40 sn_132 70002097.58787636
Csub_40_132 sn_40 sn_132 1.505166825751634e-19
Rsub_40_50 sn_40 sn_50 154508489.1446783
Csub_40_50 sn_40 sn_50 6.819355726379456e-20
Rsub_40_217 sn_40 sn_217 101169171.9632949
Csub_40_217 sn_40 sn_217 1.041471754464169e-19
Rsub_40_199 sn_40 sn_199 89904423.94565839
Csub_40_199 sn_40 sn_199 1.171964964549314e-19
Rsub_40_130 sn_40 sn_130 133996270.4819397
Csub_40_130 sn_40 sn_130 7.863266241913899e-20
Rsub_40_125 sn_40 sn_125 74767408.07182474
Csub_40_125 sn_40 sn_125 1.409234822224706e-19
Rsub_40_204 sn_40 sn_204 179889941.3648733
Csub_40_204 sn_40 sn_204 5.857183243424771e-20
Rsub_40_71 sn_40 sn_71 591043714.9672389
Csub_40_71 sn_40 sn_71 1.782691065890791e-20
Rsub_40_62 sn_40 sn_62 372919881.1123297
Csub_40_62 sn_40 sn_62 2.825401389382143e-20
Rsub_40_228 sn_40 sn_228 770351488.3707534
Csub_40_228 sn_40 sn_228 1.367750132412157e-20
Rsub_40_61 sn_40 sn_61 238378676.480577
Csub_40_61 sn_40 sn_61 4.420061247839218e-20
Rsub_40_66 sn_40 sn_66 121679038.6765329
Csub_40_66 sn_40 sn_66 8.659242887544339e-20
Rsub_40_53 sn_40 sn_53 119460275.9695638
Csub_40_53 sn_40 sn_53 8.820072962927438e-20
Rsub_40_220 sn_40 sn_220 949145491.3049709
Csub_40_220 sn_40 sn_220 1.110102044286539e-20
Rsub_40_141 sn_40 sn_141 44548509.30072811
Csub_40_141 sn_40 sn_141 2.365170836829279e-19
Rsub_40_222 sn_40 sn_222 1063750.855299382
Csub_40_222 sn_40 sn_222 9.905029405842043e-18
Rsub_40_181 sn_40 sn_181 60962292.8591951
Csub_40_181 sn_40 sn_181 1.728360763360093e-19
Rsub_40_195 sn_40 sn_195 29567077.30989675
Csub_40_195 sn_40 sn_195 3.563586414644781e-19
Rsub_40_153 sn_40 sn_153 77175604.64215747
Csub_40_153 sn_40 sn_153 1.365260894434821e-19
Rsub_40_79 sn_40 sn_79 1191850733.119335
Rsub_40_158 sn_40 sn_158 83088319.21613166
Csub_40_158 sn_40 sn_158 1.268106468109219e-19
Rsub_40_131 sn_40 sn_131 34263502.1478477
Csub_40_131 sn_40 sn_131 3.075133258930994e-19
Rsub_40_219 sn_40 sn_219 221353814.4757968
Csub_40_219 sn_40 sn_219 4.760018943961807e-20
Rsub_40_52 sn_40 sn_52 44172.58417533617
Csub_40_52 sn_40 sn_52 2.38529932059376e-16
Rsub_40_203 sn_40 sn_203 84750775.47584336
Csub_40_203 sn_40 sn_203 1.24323151535448e-19
Rsub_40_101 sn_40 sn_101 102783048.7151885
Csub_40_101 sn_40 sn_101 1.025118794775836e-19
Rsub_40_138 sn_40 sn_138 5174320.694437911
Csub_40_138 sn_40 sn_138 2.036302758264693e-18
Rsub_40_126 sn_40 sn_126 360290558.3651832
Csub_40_126 sn_40 sn_126 2.92444063758963e-20
Rsub_40_93 sn_40 sn_93 1522684.795494335
Csub_40_93 sn_40 sn_93 6.919674730717571e-18
Rsub_40_198 sn_40 sn_198 4303789.043206084
Csub_40_198 sn_40 sn_198 2.44818772399237e-18
Rsub_40_128 sn_40 sn_128 138995712.0552893
Csub_40_128 sn_40 sn_128 7.580437803749537e-20
Rsub_40_160 sn_40 sn_160 7428583.184859062
Csub_40_160 sn_40 sn_160 1.418370534465504e-18
Rsub_40_211 sn_40 sn_211 141840660.7326704
Csub_40_211 sn_40 sn_211 7.42839426142289e-20
Rsub_40_44 sn_40 sn_44 95232360.8435376
Csub_40_44 sn_40 sn_44 1.106397385185164e-19
Rsub_40_178 sn_40 sn_178 365351215.1452088
Csub_40_178 sn_40 sn_178 2.883932792735417e-20
Rsub_40_99 sn_40 sn_99 67438390.55174139
Csub_40_99 sn_40 sn_99 1.562386559944071e-19
Rsub_40_48 sn_40 sn_48 21231605.75378629
Csub_40_48 sn_40 sn_48 4.962640896980203e-19
Rsub_40_215 sn_40 sn_215 16160882.00737059
Csub_40_215 sn_40 sn_215 6.519745331612819e-19
Rsub_40_209 sn_40 sn_209 779914383.0063388
Csub_40_209 sn_40 sn_209 1.35097950900905e-20
Rsub_40_78 sn_40 sn_78 415906651.429495
Csub_40_78 sn_40 sn_78 2.533377012850241e-20
Rsub_40_41 sn_40 sn_41 5855325.022391361
Csub_40_41 sn_40 sn_41 1.799470304711935e-18
Rsub_40_59 sn_40 sn_59 311467935.1191972
Csub_40_59 sn_40 sn_59 3.382846936779461e-20
Rsub_40_226 sn_40 sn_226 27028396.50396716
Csub_40_226 sn_40 sn_226 3.898301366373504e-19
Rsub_40_170 sn_40 sn_170 32701300.28615997
Csub_40_170 sn_40 sn_170 3.22203808717946e-19
Rsub_40_133 sn_40 sn_133 40588669.60051171
Csub_40_133 sn_40 sn_133 2.595917433592641e-19
Rsub_40_45 sn_40 sn_45 39135639.35943183
Csub_40_45 sn_40 sn_45 2.692298803517739e-19
Rsub_40_212 sn_40 sn_212 62032331.23179455
Csub_40_212 sn_40 sn_212 1.698547079080199e-19
Rsub_40_139 sn_40 sn_139 108872481.3281584
Csub_40_139 sn_40 sn_139 9.677820670286208e-20
Rsub_40_51 sn_40 sn_51 295594280.6853494
Csub_40_51 sn_40 sn_51 3.564508581763037e-20
Rsub_40_218 sn_40 sn_218 207169993.9957377
Csub_40_218 sn_40 sn_218 5.085911960033546e-20
Rsub_40_80 sn_40 sn_80 180529452.616286
Csub_40_80 sn_40 sn_80 5.836434636859626e-20
Rsub_40_210 sn_40 sn_210 682293440.9327146
Csub_40_210 sn_40 sn_210 1.544274482226639e-20
Rsub_40_43 sn_40 sn_43 59933207.38143522
Csub_40_43 sn_40 sn_43 1.758037649340583e-19
Rsub_40_201 sn_40 sn_201 145451071.0741327
Csub_40_201 sn_40 sn_201 7.244005440743589e-20
Rsub_40_192 sn_40 sn_192 55131437.2548953
Csub_40_192 sn_40 sn_192 1.911157050652517e-19
Rsub_40_155 sn_40 sn_155 111010965.4359702
Csub_40_155 sn_40 sn_155 9.491389846805103e-20
Rsub_40_76 sn_40 sn_76 38376351.16973127
Csub_40_76 sn_40 sn_76 2.74556678294639e-19
Rsub_40_105 sn_40 sn_105 276218469.4437635
Csub_40_105 sn_40 sn_105 3.814547058872604e-20
Rsub_40_184 sn_40 sn_184 1799730561.854852
Rsub_40_148 sn_40 sn_148 42995785.51257883
Csub_40_148 sn_40 sn_148 2.450585185645103e-19
Rsub_40_60 sn_40 sn_60 73160497.65313543
Csub_40_60 sn_40 sn_60 1.440187511050704e-19
Rsub_40_227 sn_40 sn_227 27427763.68277827
Csub_40_227 sn_40 sn_227 3.841539406599817e-19
Rsub_40_69 sn_40 sn_69 1119047581.541623
Rsub_40_166 sn_40 sn_166 86101816.78991462
Csub_40_166 sn_40 sn_166 1.22372371397675e-19
Rsub_40_110 sn_40 sn_110 152753875.8525396
Csub_40_110 sn_40 sn_110 6.89768651919599e-20
Rsub_40_77 sn_40 sn_77 247374238.2691385
Csub_40_77 sn_40 sn_77 4.259329336778598e-20
Rsub_40_182 sn_40 sn_182 95551433.31792276
Csub_40_182 sn_40 sn_182 1.102702820498e-19
Rsub_40_47 sn_40 sn_47 5925363023.024691
Rsub_40_214 sn_40 sn_214 34621697.77205773
Csub_40_214 sn_40 sn_214 3.04331797117521e-19
Rsub_40_177 sn_40 sn_177 41662704.61983947
Csub_40_177 sn_40 sn_177 2.528996520598571e-19
Rsub_40_213 sn_40 sn_213 79059187.57301757
Csub_40_213 sn_40 sn_213 1.332733591842024e-19
Rsub_40_118 sn_40 sn_118 219682327.0562823
Csub_40_118 sn_40 sn_118 4.79623629420612e-20
Rsub_40_197 sn_40 sn_197 2414620188.399115
Rsub_40_49 sn_40 sn_49 14598407.5796788
Csub_40_49 sn_40 sn_49 7.21755674015907e-19
Rsub_40_216 sn_40 sn_216 49369424.76719087
Csub_40_216 sn_40 sn_216 2.134212329172643e-19
Rsub_40_144 sn_40 sn_144 285630131.0863293
Csub_40_144 sn_40 sn_144 3.688855745770546e-20
Rsub_40_100 sn_40 sn_100 368074676.0414686
Csub_40_100 sn_40 sn_100 2.862593975642847e-20
Rsub_40_221 sn_40 sn_221 57754941.58040579
Csub_40_221 sn_40 sn_221 1.824343201449044e-19
Rsub_40_168 sn_40 sn_168 182638668.5794536
Csub_40_168 sn_40 sn_168 5.769032146468094e-20
Rsub_11_24 sn_11 sn_24 147087460.2699105
Csub_11_24 sn_11 sn_24 7.163413851116333e-20
Rsub_11_86 sn_11 sn_86 25591678.50530775
Csub_11_86 sn_11 sn_86 4.1171521829038e-19
Rsub_11_207 sn_11 sn_207 1186141804.487898
Rsub_11_136 sn_11 sn_136 550768252.2041259
Csub_11_136 sn_11 sn_136 1.913052079538703e-20
Rsub_11_145 sn_11 sn_145 1767614092.795784
Rsub_11_33 sn_11 sn_33 1767614092.795784
Rsub_11_213 sn_11 sn_213 692484513.2823629
Csub_11_213 sn_11 sn_213 1.521547890260719e-20
Rsub_11_46 sn_11 sn_46 6164317.463981782
Csub_11_46 sn_11 sn_46 1.709270095804583e-18
Rsub_11_179 sn_11 sn_179 185601200.856002
Csub_11_179 sn_11 sn_179 5.6769479150109e-20
Rsub_11_12 sn_11 sn_12 107103892.7479385
Csub_11_12 sn_11 sn_12 9.8376288964836e-20
Rsub_11_216 sn_11 sn_216 136117475.5362597
Csub_11_216 sn_11 sn_216 7.740727970982125e-20
Rsub_11_118 sn_11 sn_118 608014272.4731389
Csub_11_118 sn_11 sn_118 1.73293358055102e-20
Rsub_11_228 sn_11 sn_228 1514566888.534334
Rsub_11_200 sn_11 sn_200 342203137.7579007
Csub_11_200 sn_11 sn_200 3.079014287029792e-20
Rsub_11_226 sn_11 sn_226 61805155.30275629
Csub_11_226 sn_11 sn_226 1.704790393392978e-19
Rsub_11_59 sn_11 sn_59 819239523.2354498
Csub_11_59 sn_11 sn_59 1.286129782974571e-20
Rsub_11_128 sn_11 sn_128 155180418.3554466
Csub_11_128 sn_11 sn_128 6.789828004004852e-20
Rsub_11_198 sn_11 sn_198 62564723.6654758
Csub_11_198 sn_11 sn_198 1.684093349243737e-19
Rsub_11_31 sn_11 sn_31 1767614092.795784
Rsub_11_160 sn_11 sn_160 144515427.1525978
Csub_11_160 sn_11 sn_160 7.290905690715109e-20
Rsub_11_84 sn_11 sn_84 208637582.751766
Csub_11_84 sn_11 sn_84 5.050136875275324e-20
Rsub_11_135 sn_11 sn_135 442676931.1862328
Csub_11_135 sn_11 sn_135 2.380174515531132e-20
Rsub_11_214 sn_11 sn_214 264214355.5815563
Csub_11_214 sn_11 sn_214 3.987854285600184e-20
Rsub_11_47 sn_11 sn_47 3978132.688673271
Csub_11_47 sn_11 sn_47 2.648600317488147e-18
Rsub_11_203 sn_11 sn_203 291043075.149139
Csub_11_203 sn_11 sn_203 3.620248822903894e-20
Rsub_11_36 sn_11 sn_36 1007408536.588663
Csub_11_36 sn_11 sn_36 1.045899763556617e-20
Rsub_11_45 sn_11 sn_45 269923846.3396698
Csub_11_45 sn_11 sn_45 3.903502282258894e-20
Rsub_11_212 sn_11 sn_212 102528321.6398552
Csub_11_212 sn_11 sn_212 1.027665657030927e-19
Rsub_11_38 sn_11 sn_38 354643665.2328621
Csub_11_38 sn_11 sn_38 2.97100569815949e-20
Rsub_11_205 sn_11 sn_205 692527347.1346803
Csub_11_205 sn_11 sn_205 1.521453780247743e-20
Rsub_11_117 sn_11 sn_117 200639482.2658035
Csub_11_117 sn_11 sn_117 5.251450703142993e-20
Rsub_11_153 sn_11 sn_153 17837506.62187343
Csub_11_153 sn_11 sn_153 5.906926189622e-19
Rsub_11_66 sn_11 sn_66 713121312.8162007
Csub_11_66 sn_11 sn_66 1.477516281293035e-20
Rsub_11_188 sn_11 sn_188 582821747.8443332
Csub_11_188 sn_11 sn_188 1.807839796850581e-20
Rsub_11_151 sn_11 sn_151 536678957.2504333
Csub_11_151 sn_11 sn_151 1.963274944896583e-20
Rsub_11_170 sn_11 sn_170 69524717.20134562
Csub_11_170 sn_11 sn_170 1.515501813796097e-19
Rsub_11_177 sn_11 sn_177 31771398.71758546
Csub_11_177 sn_11 sn_177 3.316342347999322e-19
Rsub_11_225 sn_11 sn_225 553829042.2917835
Csub_11_225 sn_11 sn_225 1.902479411088536e-20
Rsub_11_44 sn_11 sn_44 157423652.4301096
Csub_11_44 sn_11 sn_44 6.693075239699332e-20
Rsub_11_211 sn_11 sn_211 1512635783.775367
Rsub_11_155 sn_11 sn_155 145281847.8020793
Csub_11_155 sn_11 sn_155 7.252443207209263e-20
Rsub_11_34 sn_11 sn_34 1486164050.902058
Rsub_11_201 sn_11 sn_201 193998322.0545629
Csub_11_201 sn_11 sn_201 5.431224038765949e-20
Rsub_11_43 sn_11 sn_43 74208507.97239122
Csub_11_43 sn_11 sn_43 1.419848450011962e-19
Rsub_11_210 sn_11 sn_210 952879898.6209141
Csub_11_210 sn_11 sn_210 1.105751471668073e-20
Rsub_11_209 sn_11 sn_209 1559080483.20032
Rsub_11_51 sn_11 sn_51 5593372.151967727
Csub_11_51 sn_11 sn_51 1.883744406050884e-18
Rsub_11_218 sn_11 sn_218 286919281.4969658
Csub_11_218 sn_11 sn_218 3.672281433041797e-20
Rsub_11_130 sn_11 sn_130 80635680.62438913
Csub_11_130 sn_11 sn_130 1.306677567627938e-19
Rsub_11_167 sn_11 sn_167 434078687.3938116
Csub_11_167 sn_11 sn_167 2.427321084453734e-20
Rsub_11_181 sn_11 sn_181 127644328.026654
Csub_11_181 sn_11 sn_181 8.254564589842041e-20
Rsub_11_14 sn_11 sn_14 77288992.57178651
Csub_11_14 sn_11 sn_14 1.36325796877785e-19
Rsub_11_215 sn_11 sn_215 37792774.79040835
Csub_11_215 sn_11 sn_215 2.787962397750196e-19
Rsub_11_48 sn_11 sn_48 12881980.497703
Csub_11_48 sn_11 sn_48 8.179241929537756e-19
Rsub_11_220 sn_11 sn_220 533355012.428815
Csub_11_220 sn_11 sn_220 1.975510355522583e-20
Rsub_11_53 sn_11 sn_53 289280434.8672153
Csub_11_53 sn_11 sn_53 3.642307682186121e-20
Rsub_11_141 sn_11 sn_141 62869034.1234336
Csub_11_141 sn_11 sn_141 1.675941685622726e-19
Rsub_11_222 sn_11 sn_222 20013310.2646743
Csub_11_222 sn_11 sn_222 5.264737998305087e-19
Rsub_11_41 sn_11 sn_41 592570.3805687322
Csub_11_41 sn_11 sn_41 1.778098239084678e-17
Rsub_11_79 sn_11 sn_79 110531511.0576735
Csub_11_79 sn_11 sn_79 9.532560806784088e-20
Rsub_11_158 sn_11 sn_158 141851794.0223278
Csub_11_158 sn_11 sn_158 7.427811241196948e-20
Rsub_11_195 sn_11 sn_195 19782287.33594618
Csub_11_195 sn_11 sn_195 5.326221039709738e-19
Rsub_11_28 sn_11 sn_28 182188365.9220222
Csub_11_28 sn_11 sn_28 5.783291072899621e-20
Rsub_11_127 sn_11 sn_127 185210801.3657046
Csub_11_127 sn_11 sn_127 5.688914158643147e-20
Rsub_11_206 sn_11 sn_206 36659072.50666454
Csub_11_206 sn_11 sn_206 2.874181691398355e-19
Rsub_11_39 sn_11 sn_39 197911079.9582841
Csub_11_39 sn_11 sn_39 5.323847206761184e-20
Rsub_11_77 sn_11 sn_77 180437711.7860665
Csub_11_77 sn_11 sn_77 5.839402083929348e-20
Rsub_11_156 sn_11 sn_156 123586438.0260771
Csub_11_156 sn_11 sn_156 8.525598496500701e-20
Rsub_11_52 sn_11 sn_52 558531.5009154131
Csub_11_52 sn_11 sn_52 1.88646181727639e-17
Rsub_11_219 sn_11 sn_219 20727392.04157923
Csub_11_219 sn_11 sn_219 5.083361901532897e-19
Rsub_11_178 sn_11 sn_178 189414395.6236329
Csub_11_178 sn_11 sn_178 5.562662472162904e-20
Rsub_11_99 sn_11 sn_99 8085600.449785382
Csub_11_99 sn_11 sn_99 1.303117012479843e-18
Rsub_11_35 sn_11 sn_35 23014107.67162461
Csub_11_35 sn_11 sn_35 4.578271576968863e-19
Rsub_11_202 sn_11 sn_202 308839470.5279346
Csub_11_202 sn_11 sn_202 3.411637600666386e-20
Rsub_11_60 sn_11 sn_60 203180057.6586276
Csub_11_60 sn_11 sn_60 5.185786254639638e-20
Rsub_11_227 sn_11 sn_227 224506554.3843691
Csub_11_227 sn_11 sn_227 4.693174117398324e-20
Rsub_11_139 sn_11 sn_139 105684942.754813
Csub_11_139 sn_11 sn_139 9.969711131579484e-20
Rsub_11_217 sn_11 sn_217 281168524.957894
Csub_11_217 sn_11 sn_217 3.747390823282186e-20
Rsub_11_50 sn_11 sn_50 209863.3377780302
Csub_11_50 sn_11 sn_50 5.020640390926359e-17
Rsub_11_138 sn_11 sn_138 50076288.58311868
Csub_11_138 sn_11 sn_138 2.104086345125421e-19
Rsub_11_132 sn_11 sn_132 103631002.7618595
Csub_11_132 sn_11 sn_132 1.016730825855509e-19
Rsub_11_125 sn_11 sn_125 194987433.659722
Csub_11_125 sn_11 sn_125 5.403673100604787e-20
Rsub_11_204 sn_11 sn_204 39795796.47511769
Csub_11_204 sn_11 sn_204 2.647637297275338e-19
Rsub_11_37 sn_11 sn_37 589204697.5985945
Csub_11_37 sn_11 sn_37 1.788255176031905e-20
Rsub_11_223 sn_11 sn_223 1521674488.156445
Rsub_11_56 sn_11 sn_56 932274738.5880171
Csub_11_56 sn_11 sn_56 1.130190818876858e-20
Rsub_11_87 sn_11 sn_87 106212497.3220632
Csub_11_87 sn_11 sn_87 9.920191849251706e-20
Rsub_11_221 sn_11 sn_221 146529009.2854393
Csub_11_221 sn_11 sn_221 7.190715035617881e-20
Rsub_11_54 sn_11 sn_54 740029298.6481622
Csub_11_54 sn_11 sn_54 1.423792750027245e-20
Rsub_11_97 sn_11 sn_97 34537211.20995907
Csub_11_97 sn_11 sn_97 3.050762679759078e-19
Rsub_11_168 sn_11 sn_168 193462596.151412
Csub_11_168 sn_11 sn_168 5.446263883476319e-20
Rsub_11_107 sn_11 sn_107 1767614092.795784
Rsub_11_122 sn_11 sn_122 150263405.6117322
Csub_11_122 sn_11 sn_122 7.012008984712737e-20
Rsub_11_115 sn_11 sn_115 3833170509.90256
Rsub_11_196 sn_11 sn_196 1767614092.795784
Rsub_11_29 sn_11 sn_29 1767614092.795784
Rsub_11_133 sn_11 sn_133 25702945.87820765
Csub_11_133 sn_11 sn_133 4.099329139996907e-19
Rsub_11_137 sn_11 sn_137 883807046.3978918
Csub_11_137 sn_11 sn_137 1.192170117354603e-20
Rsub_11_110 sn_11 sn_110 8981733.328953596
Csub_11_110 sn_11 sn_110 1.173101350968025e-18
Rsub_11_165 sn_11 sn_165 294522882.0756054
Csub_11_165 sn_11 sn_165 3.577475348596255e-20
Rsub_11_18 sn_11 sn_18 861246288.2154562
Csub_11_18 sn_11 sn_18 1.223399583417898e-20
Rsub_11_101 sn_11 sn_101 21393265.03631894
Csub_11_101 sn_11 sn_101 4.925140451605874e-19
Rsub_11_32 sn_11 sn_32 638183624.0914736
Csub_11_32 sn_11 sn_32 1.651011261410832e-20
Rsub_11_199 sn_11 sn_199 102993211.8760585
Csub_11_199 sn_11 sn_199 1.023026985012328e-19
Rsub_11_121 sn_11 sn_121 337199295.4653195
Csub_11_121 sn_11 sn_121 3.124705076174652e-20
Rsub_11_129 sn_11 sn_129 347883.1843169514
Csub_11_129 sn_11 sn_129 3.028741824045844e-17
Rsub_11_142 sn_11 sn_142 2290291571.561503
Rsub_11_81 sn_11 sn_81 287004066.2201526
Csub_11_81 sn_11 sn_81 3.671196593482328e-20
Rsub_11_229 sn_11 sn_229 249858169.0485676
Csub_11_229 sn_11 sn_229 4.216985797323245e-20
Rsub_11_159 sn_11 sn_159 486605046.9287304
Csub_11_159 sn_11 sn_159 2.165305018666032e-20
Rsub_11_180 sn_11 sn_180 333168464.5725752
Csub_11_180 sn_11 sn_180 3.16250924761062e-20
Rsub_11_93 sn_11 sn_93 312503228.1270214
Csub_11_93 sn_11 sn_93 3.371639891651711e-20
Rsub_11_163 sn_11 sn_163 380351619.2283735
Csub_11_163 sn_11 sn_163 2.770195516350256e-20
Rsub_11_78 sn_11 sn_78 9267682.080396017
Csub_11_78 sn_11 sn_78 1.136906014991374e-18
Rsub_11_192 sn_11 sn_192 1767614092.795784
Rsub_11_25 sn_11 sn_25 181205033.2878708
Csub_11_25 sn_11 sn_25 5.814674852597086e-20
Rsub_11_166 sn_11 sn_166 10022772596.20037
Rsub_11_112 sn_11 sn_112 210946540.9229855
Csub_11_112 sn_11 sn_112 4.994859577278759e-20
Rsub_11_96 sn_11 sn_96 618843661.2637868
Csub_11_96 sn_11 sn_96 1.702608293783387e-20
Rsub_11_76 sn_11 sn_76 353688.2558026696
Csub_11_76 sn_11 sn_76 2.979031203147591e-17
Rsub_11_22 sn_11 sn_22 334222301.4489567
Csub_11_22 sn_11 sn_22 3.152537534614267e-20
Rsub_11_191 sn_11 sn_191 446343724.166302
Csub_11_191 sn_11 sn_191 2.360620959084941e-20
Rsub_11_148 sn_11 sn_148 301786136.4025121
Csub_11_148 sn_11 sn_148 3.491374265177244e-20
Rsub_11_230 sn_11 0 2831253.023423087
Csub_11_230 sn_11 0 3.721491302635684e-18
Rsub_11_92 sn_11 sn_92 543649287.4093429
Csub_11_92 sn_11 sn_92 1.938103065018186e-20
Rsub_11_150 sn_11 sn_150 451554933.4970725
Csub_11_150 sn_11 sn_150 2.33337800577885e-20
Rsub_11_80 sn_11 sn_80 244167757.2009965
Csub_11_80 sn_11 sn_80 4.315264072134009e-20
Rsub_11_161 sn_11 sn_161 1353281834.086271
Rsub_11_67 sn_11 sn_67 1124100.55741866
Csub_11_67 sn_11 sn_67 9.373257074460991e-18
Rsub_11_94 sn_11 sn_94 1767614092.795784
Rsub_11_27 sn_11 sn_27 2737369567.147788
Rsub_11_57 sn_11 sn_57 1046953397.392211
Csub_11_57 sn_11 sn_57 1.006394699943154e-20
Rsub_11_224 sn_11 sn_224 883807046.3978918
Csub_11_224 sn_11 sn_224 1.192170117354603e-20
Rsub_11_169 sn_11 sn_169 363921166.1879232
Csub_11_169 sn_11 sn_169 2.89526537095925e-20
Rsub_11_182 sn_11 sn_182 420973477.8834259
Csub_11_182 sn_11 sn_182 2.50288534926367e-20
Rsub_11_134 sn_11 sn_134 1058509026.637981
Rsub_11_71 sn_11 sn_71 739766770.2588325
Csub_11_71 sn_11 sn_71 1.424298025517348e-20
Rsub_11_114 sn_11 sn_114 173192312.2946662
Csub_11_114 sn_11 sn_114 6.083690068357895e-20
Rsub_11_83 sn_11 sn_83 1767614092.795784
Rsub_11_176 sn_11 sn_176 1767614092.795784
Rsub_11_152 sn_11 sn_152 789644373.7182633
Csub_11_152 sn_11 sn_152 1.334332751921728e-20
Rsub_11_162 sn_11 sn_162 1676368731.296175
Rsub_11_154 sn_11 sn_154 929307809.949522
Csub_11_154 sn_11 sn_154 1.133799091046305e-20
Rsub_11_175 sn_11 sn_175 6029702223.487877
Rsub_11_171 sn_11 sn_171 763546365.1327447
Csub_11_171 sn_11 sn_171 1.379940234591806e-20
Rsub_11_20 sn_11 sn_20 225418042.8695
Csub_11_20 sn_11 sn_20 4.674197046564648e-20
Rsub_11_17 sn_11 sn_17 1767614092.795784
Rsub_11_111 sn_11 sn_111 1767614092.795784
Rsub_11_98 sn_11 sn_98 1767614092.795784
Rsub_11_89 sn_11 sn_89 2455393978.40515
Rsub_11_102 sn_11 sn_102 1767614092.795784
Rsub_11_146 sn_11 sn_146 1767614092.795784
Rsub_11_144 sn_11 sn_144 347334839.8330793
Csub_11_144 sn_11 sn_144 3.03352335956093e-20
Rsub_11_91 sn_11 sn_91 1293117105.902416
Rsub_90_146 sn_90 sn_146 226748554.688671
Csub_90_146 sn_90 sn_146 4.646769862192394e-20
Rsub_90_98 sn_90 sn_98 99692586.44073668
Csub_90_98 sn_90 sn_98 1.056897396126193e-19
Rsub_90_128 sn_90 sn_128 83485599.58984722
Csub_90_128 sn_90 sn_128 1.262071968578322e-19
Rsub_90_171 sn_90 sn_171 226748554.688671
Csub_90_171 sn_90 sn_171 4.646769862192394e-20
Rsub_90_115 sn_90 sn_115 237112029.4513522
Csub_90_115 sn_90 sn_115 4.443673113764036e-20
Rsub_90_140 sn_90 sn_140 1018980.360364871
Csub_90_140 sn_90 sn_140 1.034022235566655e-17
Rsub_90_216 sn_90 sn_216 8530139.770741649
Csub_90_216 sn_90 sn_216 1.235206431009502e-18
Rsub_90_160 sn_90 sn_160 253089375.8131143
Csub_90_160 sn_90 sn_160 4.163147294657809e-20
Rsub_90_175 sn_90 sn_175 253089375.8131143
Csub_90_175 sn_90 sn_175 4.163147294657809e-20
Rsub_90_96 sn_90 sn_96 144888872.6573896
Csub_90_96 sn_90 sn_96 7.272113661305808e-20
Rsub_90_155 sn_90 sn_155 5361012.801943635
Csub_90_155 sn_90 sn_155 1.965390475920893e-18
Rsub_90_118 sn_90 sn_118 1577552.587806291
Csub_90_118 sn_90 sn_118 6.679006192041939e-18
Rsub_90_135 sn_90 sn_135 209882.2220797345
Csub_90_135 sn_90 sn_135 5.020188655248361e-17
Rsub_90_159 sn_90 sn_159 175351340.3244312
Csub_90_159 sn_90 sn_159 6.00878412604981e-20
Rsub_90_93 sn_90 sn_93 100735008.3851105
Csub_90_93 sn_90 sn_93 1.045960453187135e-19
Rsub_90_228 sn_90 sn_228 6082978.278276023
Csub_90_228 sn_90 sn_228 1.732125781191536e-18
Rsub_90_191 sn_90 sn_191 22549484.37536686
Csub_90_191 sn_90 sn_191 4.672605070180716e-19
Rsub_90_112 sn_90 sn_112 1552095.672740062
Csub_90_112 sn_90 sn_112 6.788552849727974e-18
Rsub_90_221 sn_90 sn_221 253089375.8131143
Csub_90_221 sn_90 sn_221 4.163147294657809e-20
Rsub_90_210 sn_90 sn_210 88010.93815297465
Csub_90_210 sn_90 sn_210 1.197178864735676e-16
Rsub_90_131 sn_90 sn_131 25543054.69117704
Csub_90_131 sn_90 sn_131 4.124989602699892e-19
Rsub_90_176 sn_90 sn_176 846574.3950431028
Csub_90_176 sn_90 sn_176 1.244602194907341e-17
Rsub_90_97 sn_90 sn_97 1155415713.251406
Rsub_90_126 sn_90 sn_126 2621855.578046103
Csub_90_126 sn_90 sn_126 4.018712392267674e-18
Rsub_90_220 sn_90 sn_220 191679740.0911141
Csub_90_220 sn_90 sn_220 5.496920799882937e-20
Rsub_90_141 sn_90 sn_141 2566335.73330547
Csub_90_141 sn_90 sn_141 4.105652805082868e-18
Rsub_90_169 sn_90 sn_169 12141066.89274847
Csub_90_169 sn_90 sn_169 8.678383535241998e-19
Rsub_90_185 sn_90 sn_185 746301609.9118696
Csub_90_185 sn_90 sn_185 1.411826446880404e-20
Rsub_90_111 sn_90 sn_111 156318063.4656215
Csub_90_111 sn_90 sn_111 6.740413275748684e-20
Rsub_90_190 sn_90 sn_190 31650313.97352666
Csub_90_190 sn_90 sn_190 3.329029693368305e-19
Rsub_90_222 sn_90 sn_222 4804987.654431654
Csub_90_222 sn_90 sn_222 2.192822179784826e-18
Rsub_90_180 sn_90 sn_180 2067822.104686138
Csub_90_180 sn_90 sn_180 5.095449689967054e-18
Rsub_90_101 sn_90 sn_101 229426624.7518291
Csub_90_101 sn_90 sn_101 4.592528662977683e-20
Rsub_90_181 sn_90 sn_181 4141476.604019752
Csub_90_181 sn_90 sn_181 2.544136912907633e-18
Rsub_90_107 sn_90 sn_107 6221374.448061674
Csub_90_107 sn_90 sn_107 1.693594171222525e-18
Rsub_90_158 sn_90 sn_158 10810500.09813848
Csub_90_158 sn_90 sn_158 9.746527363747346e-19
Rsub_90_177 sn_90 sn_177 11728760.39478251
Csub_90_177 sn_90 sn_177 8.983458735261665e-19
Rsub_90_168 sn_90 sn_168 2935460.335441619
Csub_90_168 sn_90 sn_168 3.589380300941747e-18
Rsub_90_150 sn_90 sn_150 23256252.82659176
Csub_90_150 sn_90 sn_150 4.530602406498751e-19
Rsub_90_229 sn_90 sn_229 78793467.02529603
Csub_90_229 sn_90 sn_229 1.337228059636892e-19
Rsub_90_165 sn_90 sn_165 61537996.18896953
Csub_90_165 sn_90 sn_165 1.712191516583478e-19
Rsub_90_203 sn_90 sn_203 118505490.7393616
Csub_90_203 sn_90 sn_203 8.891135285371475e-20
Rsub_90_195 sn_90 sn_195 25853533.94718052
Csub_90_195 sn_90 sn_195 4.075451937733669e-19
Rsub_90_134 sn_90 sn_134 253089375.8131143
Csub_90_134 sn_90 sn_134 4.163147294657809e-20
Rsub_90_148 sn_90 sn_148 236360155.9589445
Csub_90_148 sn_90 sn_148 4.457808660466521e-20
Rsub_90_227 sn_90 sn_227 55337739.1498943
Csub_90_227 sn_90 sn_227 1.904032160347145e-19
Rsub_90_230 sn_90 0 1319804.531324167
Csub_90_230 sn_90 0 7.983366666925057e-18
Rsub_90_151 sn_90 sn_151 220357408.1367995
Csub_90_151 sn_90 sn_151 4.781542672569861e-20
Rsub_90_202 sn_90 sn_202 177823080.9714787
Csub_90_202 sn_90 sn_202 5.925262032727889e-20
Rsub_90_206 sn_90 sn_206 228826821.3094986
Csub_90_206 sn_90 sn_206 4.604566650855553e-20
Rsub_90_125 sn_90 sn_125 119597986.1630968
Csub_90_125 sn_90 sn_125 8.809917156850201e-20
Rsub_90_204 sn_90 sn_204 219815009.2849005
Csub_90_204 sn_90 sn_204 4.793341244761749e-20
Rsub_90_226 sn_90 sn_226 253089375.8131143
Csub_90_226 sn_90 sn_226 4.163147294657809e-20
Rsub_90_130 sn_90 sn_130 23995232.02830965
Csub_90_130 sn_90 sn_130 4.391073814080657e-19
Rsub_90_153 sn_90 sn_153 54865064.08025502
Csub_90_153 sn_90 sn_153 1.920435832685357e-19
Rsub_90_217 sn_90 sn_217 100647112.8084073
Csub_90_217 sn_90 sn_217 1.04687389515955e-19
Rsub_90_138 sn_90 sn_138 75619674.45219928
Csub_90_138 sn_90 sn_138 1.39335213733171e-19
Rsub_90_162 sn_90 sn_162 91862467.40737152
Csub_90_162 sn_90 sn_162 1.146984595515502e-19
Rsub_90_156 sn_90 sn_156 82001528.2325501
Csub_90_156 sn_90 sn_156 1.28491306556499e-19
Rsub_90_154 sn_90 sn_154 57149300.57360154
Csub_90_154 sn_90 sn_154 1.843676719833213e-19
Rsub_90_139 sn_90 sn_139 189795685.5924042
Csub_90_139 sn_90 sn_139 5.551487363552419e-20
Rsub_90_224 sn_90 sn_224 228826821.3094986
Csub_90_224 sn_90 sn_224 4.604566650855553e-20
Rsub_90_179 sn_90 sn_179 228826821.3094986
Csub_90_179 sn_90 sn_179 4.604566650855553e-20
Rsub_90_184 sn_90 sn_184 130653606.1122401
Csub_90_184 sn_90 sn_184 8.064441400246132e-20
Rsub_90_167 sn_90 sn_167 228826821.3094986
Csub_90_167 sn_90 sn_167 4.604566650855553e-20
Rsub_90_212 sn_90 sn_212 23917468.132176
Csub_90_212 sn_90 sn_212 4.405350701839274e-19
Rsub_90_201 sn_90 sn_201 226748554.688671
Csub_90_201 sn_90 sn_201 4.646769862192394e-20
Rsub_90_114 sn_90 sn_114 226748554.688671
Csub_90_114 sn_90 sn_114 4.646769862192394e-20
Rsub_90_223 sn_90 sn_223 226748554.688671
Csub_90_223 sn_90 sn_223 4.646769862192394e-20
Rsub_90_157 sn_90 sn_157 50878959.44596697
Csub_90_157 sn_90 sn_157 2.070892097040557e-19
Rsub_90_170 sn_90 sn_170 153762938.8928116
Csub_90_170 sn_90 sn_170 6.85242073161401e-20
Rsub_20_113 sn_20 sn_113 281798454.2496635
Csub_20_113 sn_20 sn_113 3.739013945369285e-20
Rsub_20_28 sn_20 sn_28 214137939.4503985
Csub_20_28 sn_20 sn_28 4.920418833427041e-20
Rsub_20_146 sn_20 sn_146 160841067.4286433
Csub_20_146 sn_20 sn_146 6.550866436461868e-20
Rsub_20_140 sn_20 sn_140 61863959.68734558
Csub_20_140 sn_20 sn_140 1.703169915970521e-19
Rsub_20_100 sn_20 sn_100 79056791.06044027
Csub_20_100 sn_20 sn_100 1.332773992075479e-19
Rsub_20_59 sn_20 sn_59 281798454.2496635
Csub_20_59 sn_20 sn_59 3.739013945369285e-20
Rsub_20_210 sn_20 sn_210 242892402.4300666
Csub_20_210 sn_20 sn_210 4.337922222686096e-20
Rsub_20_84 sn_20 sn_84 91095652.27371933
Csub_20_84 sn_20 sn_84 1.156639558446822e-19
Rsub_20_73 sn_20 sn_73 155777813.5743031
Csub_20_73 sn_20 sn_73 6.763789566993953e-20
Rsub_20_58 sn_20 sn_58 146199285.2167388
Csub_20_58 sn_20 sn_58 7.206932295605812e-20
Rsub_20_37 sn_20 sn_37 39678776.77072503
Csub_20_37 sn_20 sn_37 2.6554456461984e-19
Rsub_20_109 sn_20 sn_109 32497992326.85069
Rsub_20_161 sn_20 sn_161 54189311.29444786
Csub_20_161 sn_20 sn_161 1.944384095412844e-19
Rsub_20_147 sn_20 sn_147 61883348.77675536
Csub_20_147 sn_20 sn_147 1.702636284316229e-19
Rsub_20_228 sn_20 sn_228 112754951.2103908
Csub_20_228 sn_20 sn_228 9.344586103868604e-20
Rsub_20_176 sn_20 sn_176 106400157.6651789
Csub_20_176 sn_20 sn_176 9.902695384518428e-20
Rsub_20_118 sn_20 sn_118 163009510.89895
Csub_20_118 sn_20 sn_118 6.463723155860271e-20
Rsub_20_23 sn_20 sn_23 284263375.1255288
Csub_20_23 sn_20 sn_23 3.706591993279879e-20
Rsub_20_94 sn_20 sn_94 34218768.27140485
Csub_20_94 sn_20 sn_94 3.079153351944256e-19
Rsub_20_200 sn_20 sn_200 477981971.2595101
Csub_20_200 sn_20 sn_200 2.204368393742081e-20
Rsub_20_192 sn_20 sn_192 41384816.62315979
Csub_20_192 sn_20 sn_192 2.545978057163499e-19
Rsub_20_142 sn_20 sn_142 240198011.1089855
Csub_20_142 sn_20 sn_142 4.386582325800051e-20
Rsub_20_115 sn_20 sn_115 34035747.21358381
Csub_20_115 sn_20 sn_115 3.095710940650319e-19
Rsub_20_89 sn_20 sn_89 27890648.13744216
Csub_20_89 sn_20 sn_89 3.777783667954693e-19
Rsub_20_45 sn_20 sn_45 13145940.2658816
Csub_20_45 sn_20 sn_45 8.01500941669112e-19
Rsub_20_212 sn_20 sn_212 49332135.57257389
Csub_20_212 sn_20 sn_212 2.135825538452412e-19
Rsub_20_226 sn_20 sn_226 89020343.02333319
Csub_20_226 sn_20 sn_226 1.183604010542655e-19
Rsub_20_162 sn_20 sn_162 70952955.51293641
Csub_20_162 sn_20 sn_162 1.484995716677221e-19
Rsub_20_83 sn_20 sn_83 85322409.22675428
Csub_20_83 sn_20 sn_83 1.234902248743125e-19
Rsub_20_155 sn_20 sn_155 12776311.90610529
Csub_20_155 sn_20 sn_155 8.246889696857693e-19
Rsub_20_76 sn_20 sn_76 2911859.761192528
Csub_20_76 sn_20 sn_76 3.618472167737526e-18
Rsub_20_121 sn_20 sn_121 58483191.8408405
Csub_20_121 sn_20 sn_121 1.80162593226864e-19
Rsub_20_77 sn_20 sn_77 37723868.68290564
Csub_20_77 sn_20 sn_77 2.793054866879163e-19
Rsub_20_214 sn_20 sn_214 55945419.59903971
Csub_20_214 sn_20 sn_214 1.883350518727874e-19
Rsub_20_47 sn_20 sn_47 153717680.4710632
Csub_20_47 sn_20 sn_47 6.854438259763785e-20
Rsub_20_31 sn_20 sn_31 141822903.0658229
Csub_20_31 sn_20 sn_31 7.4293243717764e-20
Rsub_20_198 sn_20 sn_198 18113845.07984287
Csub_20_198 sn_20 sn_198 5.816812198507222e-19
Rsub_20_110 sn_20 sn_110 3252098.602173164
Csub_20_110 sn_20 sn_110 3.239902841564877e-18
Rsub_20_163 sn_20 sn_163 67028933.69565295
Csub_20_163 sn_20 sn_163 1.571930645662849e-19
Rsub_20_215 sn_20 sn_215 2031824.958961352
Csub_20_215 sn_20 sn_215 5.185724023990798e-18
Rsub_20_48 sn_20 sn_48 63793.15512543528
Csub_20_48 sn_20 sn_48 1.651663643460229e-16
Rsub_20_222 sn_20 sn_222 3423562.404787908
Csub_20_222 sn_20 sn_222 3.077637342755767e-18
Rsub_20_55 sn_20 sn_55 72974570.46445738
Csub_20_55 sn_20 sn_55 1.443856871670364e-19
Rsub_20_44 sn_20 sn_44 15685002.86593347
Csub_20_44 sn_20 sn_44 6.717552806518366e-19
Rsub_20_211 sn_20 sn_211 17837340.47457037
Csub_20_211 sn_20 sn_211 5.906981210148021e-19
Rsub_20_152 sn_20 sn_152 70879230.21297225
Csub_20_152 sn_20 sn_152 1.486540340600598e-19
Rsub_20_54 sn_20 sn_54 284263375.1255288
Csub_20_54 sn_20 sn_54 3.706591993279879e-20
Rsub_20_181 sn_20 sn_181 9002974.18368382
Csub_20_181 sn_20 sn_181 1.170333635003128e-18
Rsub_20_144 sn_20 sn_144 125954441.4044818
Csub_20_144 sn_20 sn_144 8.365313191611746e-20
Rsub_20_65 sn_20 sn_65 80558947.27180272
Csub_20_65 sn_20 sn_65 1.307922193506367e-19
Rsub_20_225 sn_20 sn_225 22723161.56412582
Csub_20_225 sn_20 sn_225 4.636891513751533e-19
Rsub_20_51 sn_20 sn_51 514771.5471525946
Csub_20_51 sn_20 sn_51 2.046827094564854e-17
Rsub_20_218 sn_20 sn_218 28212671.59904573
Csub_20_218 sn_20 sn_218 3.734663505807932e-19
Rsub_20_209 sn_20 sn_209 43974704.35423823
Csub_20_209 sn_20 sn_209 2.396032823177925e-19
Rsub_20_42 sn_20 sn_42 51320410.51726704
Csub_20_42 sn_20 sn_42 2.053078569721289e-19
Rsub_20_130 sn_20 sn_130 5827342.972162464
Csub_20_130 sn_20 sn_130 1.808111098413696e-18
Rsub_20_217 sn_20 sn_217 10776440.06128928
Csub_20_217 sn_20 sn_217 9.777332256575861e-19
Rsub_20_50 sn_20 sn_50 1346244.231768095
Csub_20_50 sn_20 sn_50 7.826576525710995e-18
Rsub_20_138 sn_20 sn_138 3154386.825813942
Csub_20_138 sn_20 sn_138 3.34026360242334e-18
Rsub_20_71 sn_20 sn_71 29664203.75152975
Csub_20_71 sn_20 sn_71 3.551918531333121e-19
Rsub_20_229 sn_20 sn_229 13256567.54433099
Csub_20_229 sn_20 sn_229 7.948123424102948e-19
Rsub_20_99 sn_20 sn_99 13186638.00518971
Csub_20_99 sn_20 sn_99 7.990272803487348e-19
Rsub_20_178 sn_20 sn_178 14230997.43371443
Csub_20_178 sn_20 sn_178 7.403896705980836e-19
Rsub_20_175 sn_20 sn_175 35418326.12305028
Csub_20_175 sn_20 sn_175 2.974867718373864e-19
Rsub_20_105 sn_20 sn_105 20224033.74462138
Csub_20_105 sn_20 sn_105 5.209882279311464e-19
Rsub_20_179 sn_20 sn_179 15749063.52175006
Csub_20_179 sn_20 sn_179 6.690228588943537e-19
Rsub_20_43 sn_20 sn_43 8686357.72360146
Csub_20_43 sn_20 sn_43 1.212992123683971e-18
Rsub_20_49 sn_20 sn_49 11034593.98201854
Csub_20_49 sn_20 sn_49 9.54859192771366e-19
Rsub_20_216 sn_20 sn_216 18741426.73381391
Csub_20_216 sn_20 sn_216 5.622028489015581e-19
Rsub_20_34 sn_20 sn_34 1885708.351657393
Csub_20_34 sn_20 sn_34 5.587546713132622e-18
Rsub_20_197 sn_20 sn_197 34529471.34298623
Csub_20_197 sn_20 sn_197 3.05144651580952e-19
Rsub_20_30 sn_20 sn_30 45270530.11841644
Csub_20_30 sn_20 sn_30 2.327448667967701e-19
Rsub_20_39 sn_20 sn_39 1241095.903977825
Csub_20_39 sn_20 sn_39 8.489661007227253e-18
Rsub_20_206 sn_20 sn_206 1792030.023985352
Csub_20_206 sn_20 sn_206 5.879635587130166e-18
Rsub_20_188 sn_20 sn_188 10425721.96416226
Csub_20_188 sn_20 sn_188 1.010623872231437e-18
Rsub_20_21 sn_20 sn_21 133866850.6631094
Csub_20_21 sn_20 sn_21 7.870868291916581e-20
Rsub_20_40 sn_20 sn_40 104541140.5919908
Csub_20_40 sn_20 sn_40 1.007879141414039e-19
Rsub_20_207 sn_20 sn_207 7696797.177357135
Csub_20_207 sn_20 sn_207 1.368943894380745e-18
Rsub_20_72 sn_20 sn_72 2385812.546030033
Csub_20_72 sn_20 sn_72 4.416308196451812e-18
Rsub_20_151 sn_20 sn_151 14087276.59894629
Csub_20_151 sn_20 sn_151 7.479432541999011e-19
Rsub_20_133 sn_20 sn_133 287115977.2909141
Csub_20_133 sn_20 sn_133 3.669765647194943e-20
Rsub_20_170 sn_20 sn_170 6943137.894791718
Csub_20_170 sn_20 sn_170 1.517539138914953e-18
Rsub_20_196 sn_20 sn_196 7149783.640065948
Csub_20_196 sn_20 sn_196 1.473678649964409e-18
Rsub_20_29 sn_20 sn_29 262401281.9403578
Csub_20_29 sn_20 sn_29 4.015408546908272e-20
Rsub_20_97 sn_20 sn_97 778080.0504109163
Csub_20_97 sn_20 sn_97 1.354164458613933e-17
Rsub_20_139 sn_20 sn_139 8558432.517099639
Csub_20_139 sn_20 sn_139 1.231123045157889e-18
Rsub_20_60 sn_20 sn_60 23596382.63643851
Csub_20_60 sn_20 sn_60 4.465296085663202e-19
Rsub_20_227 sn_20 sn_227 10206272.22743525
Csub_20_227 sn_20 sn_227 1.032353759280212e-18
Rsub_20_204 sn_20 sn_204 1336147.00737337
Csub_20_204 sn_20 sn_204 7.885721738765012e-18
Rsub_20_185 sn_20 sn_185 38818839.22803184
Csub_20_185 sn_20 sn_185 2.714270625233276e-19
Rsub_20_27 sn_20 sn_27 3846218.29468217
Csub_20_27 sn_20 sn_27 2.739439806835165e-18
Rsub_20_194 sn_20 sn_194 29524392.99886546
Csub_20_194 sn_20 sn_194 3.568738399680187e-19
Rsub_20_219 sn_20 sn_219 3923059.710840718
Csub_20_219 sn_20 sn_219 2.685782088178315e-18
Rsub_20_52 sn_20 sn_52 1130142.561197261
Csub_20_52 sn_20 sn_52 9.323145472078992e-18
Rsub_20_61 sn_20 sn_61 3162917.588039143
Csub_20_61 sn_20 sn_61 3.3312545170556e-18
Rsub_20_24 sn_20 sn_24 3365685.001282711
Csub_20_24 sn_20 sn_24 3.130561385933145e-18
Rsub_20_191 sn_20 sn_191 52245265.66438904
Csub_20_191 sn_20 sn_191 2.016734601353896e-19
Rsub_20_129 sn_20 sn_129 1963957.849941677
Csub_20_129 sn_20 sn_129 5.364923438933733e-18
Rsub_20_101 sn_20 sn_101 3173147.61703117
Csub_20_101 sn_20 sn_101 3.320514761329649e-18
Rsub_20_180 sn_20 sn_180 4001051.808563876
Csub_20_180 sn_20 sn_180 2.633428409919023e-18
Rsub_20_53 sn_20 sn_53 6308200.515662346
Csub_20_53 sn_20 sn_53 1.670283542203429e-18
Rsub_20_220 sn_20 sn_220 86812274.84344116
Csub_20_220 sn_20 sn_220 1.213708950863422e-19
Rsub_20_213 sn_20 sn_213 7929412.311274025
Csub_20_213 sn_20 sn_213 1.328784919816724e-18
Rsub_20_46 sn_20 sn_46 3944828.095259128
Csub_20_46 sn_20 sn_46 2.670961382295135e-18
Rsub_20_199 sn_20 sn_199 25395143.4830138
Csub_20_199 sn_20 sn_199 4.149015149009733e-19
Rsub_20_131 sn_20 sn_131 754983.1757905151
Csub_20_131 sn_20 sn_131 1.395591827751345e-17
Rsub_20_177 sn_20 sn_177 2969312.185038497
Csub_20_177 sn_20 sn_177 3.548459321764915e-18
Rsub_20_195 sn_20 sn_195 556130.7976142248
Csub_20_195 sn_20 sn_195 1.894605288437724e-17
Rsub_20_25 sn_20 sn_25 690449602.793785
Csub_20_25 sn_20 sn_25 1.526032234589743e-20
Rsub_20_153 sn_20 sn_153 813027.1221164977
Csub_20_153 sn_20 sn_153 1.295957196950711e-17
Rsub_20_112 sn_20 sn_112 28115480.35392746
Csub_20_112 sn_20 sn_112 3.747573710138712e-19
Rsub_20_141 sn_20 sn_141 3885736.687261828
Csub_20_141 sn_20 sn_141 2.711579386418685e-18
Rsub_20_202 sn_20 sn_202 10629870.71281372
Csub_20_202 sn_20 sn_202 9.91214642858154e-19
Rsub_20_35 sn_20 sn_35 55876192.65515268
Csub_20_35 sn_20 sn_35 1.885683866697451e-19
Rsub_20_132 sn_20 sn_132 8056769.91946766
Csub_20_132 sn_20 sn_132 1.307780116293328e-18
Rsub_20_85 sn_20 sn_85 41624167.04407287
Csub_20_85 sn_20 sn_85 2.531337982348973e-19
Rsub_20_66 sn_20 sn_66 8345784.275210852
Csub_20_66 sn_20 sn_66 1.262491714951954e-18
Rsub_20_117 sn_20 sn_117 7787360.855444251
Csub_20_117 sn_20 sn_117 1.353023662036132e-18
Rsub_20_159 sn_20 sn_159 14513962.28044789
Csub_20_159 sn_20 sn_159 7.259550010284891e-19
Rsub_20_189 sn_20 sn_189 66934384.74027366
Csub_20_189 sn_20 sn_189 1.574151094854289e-19
Rsub_20_22 sn_20 sn_22 141206669.9256432
Csub_20_22 sn_20 sn_22 7.461746323865804e-20
Rsub_20_183 sn_20 sn_183 54038960.64893891
Csub_20_183 sn_20 sn_183 1.949793884948987e-19
Rsub_20_186 sn_20 sn_186 38211086.93001404
Csub_20_186 sn_20 sn_186 2.757441451882335e-19
Rsub_20_41 sn_20 sn_41 3872004.357902374
Csub_20_41 sn_20 sn_41 2.721196188926309e-18
Rsub_20_208 sn_20 sn_208 36406420.59600139
Csub_20_208 sn_20 sn_208 2.894127829580492e-19
Rsub_20_157 sn_20 sn_157 14399778.79729105
Csub_20_157 sn_20 sn_157 7.317114832494626e-19
Rsub_20_128 sn_20 sn_128 15283167.22565926
Csub_20_128 sn_20 sn_128 6.89417536735452e-19
Rsub_20_182 sn_20 sn_182 22251639.69827776
Csub_20_182 sn_20 sn_182 4.735149249718217e-19
Rsub_20_158 sn_20 sn_158 28485885.21498228
Csub_20_158 sn_20 sn_158 3.698843628243047e-19
Rsub_20_149 sn_20 sn_149 56394304.57020331
Csub_20_149 sn_20 sn_149 1.868359505898951e-19
Rsub_20_190 sn_20 sn_190 39254205.42184712
Csub_20_190 sn_20 sn_190 2.684166801747532e-19
Rsub_20_205 sn_20 sn_205 56225579.90786114
Csub_20_205 sn_20 sn_205 1.873966176871188e-19
Rsub_20_38 sn_20 sn_38 13473945.61008237
Csub_20_38 sn_20 sn_38 7.819894637503729e-19
Rsub_20_127 sn_20 sn_127 25969889.39579525
Csub_20_127 sn_20 sn_127 4.05719228975074e-19
Rsub_20_160 sn_20 sn_160 70551944.03293656
Csub_20_160 sn_20 sn_160 1.493436310884805e-19
Rsub_20_230 sn_20 0 144591.9769245439
Csub_20_230 sn_20 0 7.287045745095888e-17
Rsub_20_67 sn_20 sn_67 35034379.93323006
Csub_20_67 sn_20 sn_67 3.007469669025356e-19
Rsub_20_36 sn_20 sn_36 41279921.82770664
Csub_20_36 sn_20 sn_36 2.552447542465555e-19
Rsub_20_203 sn_20 sn_203 130892731.3006602
Csub_20_203 sn_20 sn_203 8.049708641213796e-20
Rsub_20_169 sn_20 sn_169 39349377.37358981
Csub_20_169 sn_20 sn_169 2.67767477035146e-19
Rsub_20_125 sn_20 sn_125 21468191.65490776
Csub_20_125 sn_20 sn_125 4.907951108132248e-19
Rsub_20_88 sn_20 sn_88 55486379.49707375
Csub_20_88 sn_20 sn_88 1.898931521164699e-19
Rsub_20_224 sn_20 sn_224 2479594837.837005
Rsub_20_57 sn_20 sn_57 283030914.6875961
Csub_20_57 sn_20 sn_57 3.722732378496519e-20
Rsub_20_111 sn_20 sn_111 50727340.8520192
Csub_20_111 sn_20 sn_111 2.077081771931792e-19
Rsub_20_172 sn_20 sn_172 95428270.35755765
Csub_20_172 sn_20 sn_172 1.104126006135407e-19
Rsub_20_145 sn_20 sn_145 25579147.21944017
Csub_20_145 sn_20 sn_145 4.119169185680384e-19
Rsub_20_82 sn_20 sn_82 283030914.6875961
Csub_20_82 sn_20 sn_82 3.722732378496519e-20
Rsub_20_79 sn_20 sn_79 15196824.51180766
Csub_20_79 sn_20 sn_79 6.933345511783297e-19
Rsub_20_78 sn_20 sn_78 13008837.00516814
Csub_20_78 sn_20 sn_78 8.099481527859928e-19
Rsub_20_122 sn_20 sn_122 16837213.50671063
Csub_20_122 sn_20 sn_122 6.257854661064071e-19
Rsub_20_184 sn_20 sn_184 15649316.43720506
Csub_20_184 sn_20 sn_184 6.732871396977002e-19
Rsub_20_137 sn_20 sn_137 14947108.16927863
Csub_20_137 sn_20 sn_137 7.049178598898508e-19
Rsub_20_119 sn_20 sn_119 283030914.6875961
Csub_20_119 sn_20 sn_119 3.722732378496519e-20
Rsub_20_107 sn_20 sn_107 113708144.2234336
Csub_20_107 sn_20 sn_107 9.266252276113202e-20
Rsub_20_134 sn_20 sn_134 71065843.7813822
Csub_20_134 sn_20 sn_134 1.482636797311952e-19
Rsub_20_168 sn_20 sn_168 4202286.909277193
Csub_20_168 sn_20 sn_168 2.507321306160485e-18
Rsub_20_154 sn_20 sn_154 34151290.3537973
Csub_20_154 sn_20 sn_154 3.08523730525996e-19
Rsub_20_68 sn_20 sn_68 422937.1072521155
Csub_20_68 sn_20 sn_68 2.491264852754842e-17
Rsub_20_136 sn_20 sn_136 55307859.96957734
Csub_20_136 sn_20 sn_136 1.905060783047058e-19
Rsub_20_165 sn_20 sn_165 24515624.89343802
Csub_20_165 sn_20 sn_165 4.297864544766408e-19
Rsub_20_80 sn_20 sn_80 225082642.1511601
Csub_20_80 sn_20 sn_80 4.681162172938218e-20
Rsub_20_74 sn_20 sn_74 226150470.162441
Csub_20_74 sn_20 sn_74 4.659058853453533e-20
Rsub_20_93 sn_20 sn_93 71078249.61311717
Csub_20_93 sn_20 sn_93 1.482378021346989e-19
Rsub_20_148 sn_20 sn_148 24759942.04804247
Csub_20_148 sn_20 sn_148 4.255455639510683e-19
Rsub_20_150 sn_20 sn_150 8061424.810474948
Csub_20_150 sn_20 sn_150 1.307024967663158e-18
Rsub_20_70 sn_20 sn_70 81786765.07920061
Csub_20_70 sn_20 sn_70 1.288287107581121e-19
Rsub_20_86 sn_20 sn_86 225261149.3700511
Csub_20_86 sn_20 sn_86 4.677452606317407e-20
Rsub_20_64 sn_20 sn_64 137212993.2880437
Csub_20_64 sn_20 sn_64 7.678925479099007e-20
Rsub_20_87 sn_20 sn_87 181774256.9838316
Csub_20_87 sn_20 sn_87 5.796466274741641e-20
Rsub_20_171 sn_20 sn_171 82861054.35223471
Csub_20_171 sn_20 sn_171 1.271584532033636e-19
Rsub_20_156 sn_20 sn_156 76729309.23702051
Csub_20_156 sn_20 sn_156 1.373201923359208e-19
Rsub_20_69 sn_20 sn_69 76352169.64819595
Csub_20_69 sn_20 sn_69 1.379984819131981e-19
Rsub_20_223 sn_20 sn_223 72130950.71734062
Csub_20_223 sn_20 sn_223 1.460743744182618e-19
Rsub_221_228 sn_221 sn_228 51231688.79249521
Csub_221_228 sn_221 sn_228 2.056634038535436e-19
Rsub_221_229 sn_221 sn_229 5338085.544674035
Csub_221_229 sn_221 sn_229 1.973831894234547e-18
Rsub_221_226 sn_221 sn_226 14215.3137111438
Csub_221_226 sn_221 sn_226 7.412065408004429e-16
Rsub_221_222 sn_221 sn_222 73729.37693557142
Csub_221_222 sn_221 sn_222 1.429075348274994e-16
Rsub_221_224 sn_221 sn_224 2121535.876272287
Csub_221_224 sn_221 sn_224 4.966441350378421e-18
Rsub_221_227 sn_221 sn_227 96570.41219854937
Csub_221_227 sn_221 sn_227 1.091067466976006e-16
Rsub_221_230 sn_221 0 37973.952909835
Csub_221_230 sn_221 0 2.774660706839693e-16
Rsub_173_203 sn_173 sn_203 26799973.05230056
Csub_173_203 sn_173 sn_203 3.931527648056919e-19
Rsub_173_230 sn_173 0 267194.3505016141
Csub_173_230 sn_173 0 3.943378100041959e-17
Rsub_173_175 sn_173 sn_175 792520.1921568426
Csub_173_175 sn_173 sn_175 1.32949085796224e-17
Rsub_173_209 sn_173 sn_209 10122804.61889677
Csub_173_209 sn_173 sn_209 1.040866034553407e-18
Rsub_173_205 sn_173 sn_205 6354778.502768279
Csub_173_205 sn_173 sn_205 1.658041031271205e-18
Rsub_173_222 sn_173 sn_222 4004742.794920295
Csub_173_222 sn_173 sn_222 2.631001300656489e-18
Rsub_173_215 sn_173 sn_215 16215236.77099013
Csub_173_215 sn_173 sn_215 6.497890626598989e-19
Rsub_173_181 sn_173 sn_181 22696916.41949299
Csub_173_181 sn_173 sn_181 4.642253294452307e-19
Rsub_173_220 sn_173 sn_220 2120416.904966833
Csub_173_220 sn_173 sn_220 4.969062205432103e-18
Rsub_173_217 sn_173 sn_217 19466890.9467061
Csub_173_217 sn_173 sn_217 5.412514782702284e-19
Rsub_173_214 sn_173 sn_214 13964600.98278186
Csub_173_214 sn_173 sn_214 7.545137533984198e-19
Rsub_173_177 sn_173 sn_177 23834255.38225808
Csub_173_177 sn_173 sn_177 4.420731142317636e-19
Rsub_173_225 sn_173 sn_225 9643533.771849137
Csub_173_225 sn_173 sn_225 1.092595696920512e-18
Rsub_16_122 sn_16 sn_122 1168381452.820675
Rsub_16_27 sn_16 sn_27 1260807028.005119
Rsub_16_193 sn_16 sn_193 857925132.1491276
Csub_16_193 sn_16 sn_193 1.228135545561628e-20
Rsub_16_78 sn_16 sn_78 1260807028.005119
Rsub_16_120 sn_16 sn_120 2521614056.010238
Rsub_16_68 sn_16 sn_68 193698092.3626395
Csub_16_68 sn_16 sn_68 5.439642370098156e-20
Rsub_16_26 sn_16 sn_26 255477365.5778835
Csub_16_26 sn_16 sn_26 4.124233658976691e-20
Rsub_16_140 sn_16 sn_140 159073966.3779194
Csub_16_140 sn_16 sn_140 6.623637885031414e-20
Rsub_16_64 sn_16 sn_64 647079602.6715349
Csub_16_64 sn_16 sn_64 1.628313341778824e-20
Rsub_16_172 sn_16 sn_172 238671476.9722048
Csub_16_172 sn_16 sn_172 4.4146387477449e-20
Rsub_16_33 sn_16 sn_33 195368054.4040199
Csub_16_33 sn_16 sn_33 5.393145534653592e-20
Rsub_16_87 sn_16 sn_87 102220854.1024339
Csub_16_87 sn_16 sn_87 1.030756746727194e-19
Rsub_16_199 sn_16 sn_199 94123700792.25206
Rsub_16_163 sn_16 sn_163 267523141.4621584
Csub_16_163 sn_16 sn_163 3.938531614365184e-20
Rsub_16_40 sn_16 sn_40 333341018.5955434
Csub_16_40 sn_16 sn_40 3.160872174274584e-20
Rsub_16_123 sn_16 sn_123 445491469.3656358
Csub_16_123 sn_16 sn_123 2.365136983932281e-20
Rsub_16_59 sn_16 sn_59 60474721.52651498
Csub_16_59 sn_16 sn_59 1.742295497402218e-19
Rsub_16_72 sn_16 sn_72 613069448.4309251
Csub_16_72 sn_16 sn_72 1.718644360634316e-20
Rsub_16_92 sn_16 sn_92 1252904781.667786
Rsub_16_223 sn_16 sn_223 731694431.3678522
Csub_16_223 sn_16 sn_223 1.440011437907594e-20
Rsub_16_228 sn_16 sn_228 289474655.8807001
Csub_16_228 sn_16 sn_228 3.639863901098255e-20
Rsub_16_61 sn_16 sn_61 1252904781.667786
Rsub_16_153 sn_16 sn_153 35877628.35318559
Csub_16_153 sn_16 sn_153 2.936783724528006e-19
Rsub_16_39 sn_16 sn_39 270304064.3259673
Csub_16_39 sn_16 sn_39 3.898011496239937e-20
Rsub_16_206 sn_16 sn_206 26511146.22515038
Csub_16_206 sn_16 sn_206 3.974359845759643e-19
Rsub_16_126 sn_16 sn_126 106048136.0398512
Csub_16_126 sn_16 sn_126 9.935566899799688e-20
Rsub_16_218 sn_16 sn_218 13082348.10765714
Csub_16_218 sn_16 sn_218 8.053969681530611e-19
Rsub_16_51 sn_16 sn_51 81029065.90908359
Csub_16_51 sn_16 sn_51 1.300333822686809e-19
Rsub_16_170 sn_16 sn_170 10129486.58597669
Csub_16_170 sn_16 sn_170 1.040179422007109e-18
Rsub_16_200 sn_16 sn_200 1862899.025819619
Csub_16_200 sn_16 sn_200 5.655960605591206e-18
Rsub_16_169 sn_16 sn_169 93629780.34799033
Csub_16_169 sn_16 sn_169 1.12533463851666e-19
Rsub_16_30 sn_16 sn_30 1054228231.574044
Rsub_16_197 sn_16 sn_197 52702866.24074398
Csub_16_197 sn_16 sn_197 1.999223999336182e-19
Rsub_16_151 sn_16 sn_151 187822348.4698985
Csub_16_151 sn_16 sn_151 5.609813522227703e-20
Rsub_16_25 sn_16 sn_25 47535507.50803323
Csub_16_25 sn_16 sn_25 2.216550123178846e-19
Rsub_16_192 sn_16 sn_192 84420.72794900884
Csub_16_192 sn_16 sn_192 1.248091998045097e-16
Rsub_16_88 sn_16 sn_88 12453042.83706304
Csub_16_88 sn_16 sn_88 8.460971057508187e-19
Rsub_16_190 sn_16 sn_190 47760166.23519126
Csub_16_190 sn_16 sn_190 2.206123707849738e-19
Rsub_16_23 sn_16 sn_23 18168824.4744005
Csub_16_23 sn_16 sn_23 5.799210354569549e-19
Rsub_16_93 sn_16 sn_93 51377134.12929268
Csub_16_93 sn_16 sn_93 2.050811840869618e-19
Rsub_16_132 sn_16 sn_132 44180797.76358355
Csub_16_132 sn_16 sn_132 2.384855873045099e-19
Rsub_16_152 sn_16 sn_152 304001842.9533046
Csub_16_152 sn_16 sn_152 3.46592750881725e-20
Rsub_16_198 sn_16 sn_198 1646584.773121957
Csub_16_198 sn_16 sn_198 6.398992432228448e-18
Rsub_16_31 sn_16 sn_31 418509278.1573537
Csub_16_31 sn_16 sn_31 2.517622440444063e-20
Rsub_16_138 sn_16 sn_138 235745.0230883872
Csub_16_138 sn_16 sn_138 4.469440484552493e-17
Rsub_16_182 sn_16 sn_182 3064578.97572641
Csub_16_182 sn_16 sn_182 3.438150423169464e-18
Rsub_16_76 sn_16 sn_76 63574683.58753256
Csub_16_76 sn_16 sn_76 1.657339511210132e-19
Rsub_16_155 sn_16 sn_155 56222215.82127809
Csub_16_155 sn_16 sn_155 1.874078306647302e-19
Rsub_16_220 sn_16 sn_220 83232637.56370179
Csub_16_220 sn_16 sn_220 1.265907678843644e-19
Rsub_16_53 sn_16 sn_53 287862296.6811357
Csub_16_53 sn_16 sn_53 3.660251315892626e-20
Rsub_16_141 sn_16 sn_141 17064872.73287049
Csub_16_141 sn_16 sn_141 6.174369810525775e-19
Rsub_16_191 sn_16 sn_191 55711844.97018909
Csub_16_191 sn_16 sn_191 1.891246557687684e-19
Rsub_16_28 sn_16 sn_28 755511211.8700575
Csub_16_28 sn_16 sn_28 1.394616431455712e-20
Rsub_16_195 sn_16 sn_195 31657214.36035134
Csub_16_195 sn_16 sn_195 3.32830405805581e-19
Rsub_16_179 sn_16 sn_179 128799678.6246265
Csub_16_179 sn_16 sn_179 8.180520025160552e-20
Rsub_16_84 sn_16 sn_84 90543211.91893055
Csub_16_84 sn_16 sn_84 1.163696679068998e-19
Rsub_16_46 sn_16 sn_46 10610161.11263841
Csub_16_46 sn_16 sn_46 9.930559385831898e-19
Rsub_16_213 sn_16 sn_213 2024225.252034879
Csub_16_213 sn_16 sn_213 5.205193192624221e-18
Rsub_16_125 sn_16 sn_125 1502260423.388498
Rsub_16_97 sn_16 sn_97 189069714.9433135
Csub_16_97 sn_16 sn_97 5.572803399734868e-20
Rsub_16_81 sn_16 sn_81 356253827.5977927
Csub_16_81 sn_16 sn_81 2.957577627523933e-20
Rsub_16_160 sn_16 sn_160 3064854.002328475
Csub_16_160 sn_16 sn_160 3.437841898578227e-18
Rsub_16_49 sn_16 sn_49 1948191.3068317
Csub_16_49 sn_16 sn_49 5.408341298558226e-18
Rsub_16_216 sn_16 sn_216 43343847.44503587
Csub_16_216 sn_16 sn_216 2.430906373872616e-19
Rsub_16_77 sn_16 sn_77 76888503.73559225
Csub_16_77 sn_16 sn_77 1.37035876500645e-19
Rsub_16_156 sn_16 sn_156 516457800.6405177
Csub_16_156 sn_16 sn_156 2.04014412971641e-20
Rsub_16_45 sn_16 sn_45 20705425.04175282
Csub_16_45 sn_16 sn_45 5.088754991014679e-19
Rsub_16_17 sn_16 sn_17 284683211.6918285
Csub_16_17 sn_16 sn_17 3.70112569673965e-20
Rsub_16_184 sn_16 sn_184 126616953.2821585
Csub_16_184 sn_16 sn_184 8.321542438910267e-20
Rsub_16_175 sn_16 sn_175 173551293.7143059
Csub_16_175 sn_16 sn_175 6.071106286061337e-20
Rsub_16_150 sn_16 sn_150 221307782.9008057
Csub_16_150 sn_16 sn_150 4.761009018355513e-20
Rsub_16_229 sn_16 sn_229 59782111.71474158
Csub_16_229 sn_16 sn_229 1.762480983024864e-19
Rsub_16_62 sn_16 sn_62 436433382.2414907
Csub_16_62 sn_16 sn_62 2.414224926634936e-20
Rsub_16_44 sn_16 sn_44 25790658.23129288
Csub_16_44 sn_16 sn_44 4.085387587915708e-19
Rsub_16_211 sn_16 sn_211 23773753.37938517
Csub_16_211 sn_16 sn_211 4.431981494081812e-19
Rsub_16_95 sn_16 sn_95 202126.696398519
Csub_16_95 sn_16 sn_95 5.21281141480488e-17
Rsub_16_48 sn_16 sn_48 14387677.80465417
Csub_16_48 sn_16 sn_48 7.323269012058103e-19
Rsub_16_215 sn_16 sn_215 13664872.71825765
Csub_16_215 sn_16 sn_215 7.710634207483097e-19
Rsub_16_114 sn_16 sn_114 572724375.7322817
Csub_16_114 sn_16 sn_114 1.839712774361686e-20
Rsub_16_35 sn_16 sn_35 18971942.32724877
Csub_16_35 sn_16 sn_35 5.553718918435038e-19
Rsub_16_202 sn_16 sn_202 142903517.3450766
Csub_16_202 sn_16 sn_202 7.373144970803625e-20
Rsub_16_222 sn_16 sn_222 76769.91212480438
Csub_16_222 sn_16 sn_222 1.3724756497182e-16
Rsub_16_168 sn_16 sn_168 4019669.523759861
Csub_16_168 sn_16 sn_168 2.621231282808179e-18
Rsub_16_52 sn_16 sn_52 1004320.739871809
Csub_16_52 sn_16 sn_52 1.049115395503519e-17
Rsub_16_219 sn_16 sn_219 201289153.4333894
Csub_16_219 sn_16 sn_219 5.234501374022985e-20
Rsub_16_131 sn_16 sn_131 77509504.81828649
Csub_16_131 sn_16 sn_131 1.359379540216618e-19
Rsub_16_203 sn_16 sn_203 2294422.384865838
Csub_16_203 sn_16 sn_203 4.592216137590595e-18
Rsub_16_36 sn_16 sn_36 104967574.7990832
Csub_16_36 sn_16 sn_36 1.003784599424891e-19
Rsub_16_166 sn_16 sn_166 9786187.786947871
Csub_16_166 sn_16 sn_166 1.076668845071911e-18
Rsub_16_214 sn_16 sn_214 9071261.153353792
Csub_16_214 sn_16 sn_214 1.161523554895616e-18
Rsub_16_47 sn_16 sn_47 110905028.8948492
Csub_16_47 sn_16 sn_47 9.500456027309465e-20
Rsub_16_148 sn_16 sn_148 649454.412889843
Csub_16_148 sn_16 sn_148 1.622359213073381e-17
Rsub_16_227 sn_16 sn_227 7283581.417870357
Csub_16_227 sn_16 sn_227 1.446607499489003e-18
Rsub_16_60 sn_16 sn_60 285411816.5447528
Csub_16_60 sn_16 sn_60 3.691677390861592e-20
Rsub_16_181 sn_16 sn_181 88719160.92681488
Csub_16_181 sn_16 sn_181 1.187622086611215e-19
Rsub_16_101 sn_16 sn_101 134333765.4201865
Csub_16_101 sn_16 sn_101 7.84351087701043e-20
Rsub_16_22 sn_16 sn_22 3451123.894682786
Csub_16_22 sn_16 sn_22 3.05305860460813e-18
Rsub_16_158 sn_16 sn_158 47773586.85461078
Csub_16_158 sn_16 sn_158 2.205503960649983e-19
Rsub_16_226 sn_16 sn_226 8884631.643837182
Csub_16_226 sn_16 sn_226 1.18592237974645e-18
Rsub_16_177 sn_16 sn_177 20315610.61718332
Csub_16_177 sn_16 sn_177 5.186397643060775e-19
Rsub_16_186 sn_16 sn_186 406438933.9704299
Csub_16_186 sn_16 sn_186 2.592390300629166e-20
Rsub_16_98 sn_16 sn_98 373951659.0695865
Csub_16_98 sn_16 sn_98 2.817605764457734e-20
Rsub_16_137 sn_16 sn_137 61516637.63722626
Csub_16_137 sn_16 sn_137 1.712785988786543e-19
Rsub_16_43 sn_16 sn_43 5321307.772296832
Csub_16_43 sn_16 sn_43 1.980055270827184e-18
Rsub_16_210 sn_16 sn_210 224439717.9796695
Csub_16_210 sn_16 sn_210 4.694571708196689e-20
Rsub_16_201 sn_16 sn_201 181227404.3646504
Csub_16_201 sn_16 sn_201 5.813957077390671e-20
Rsub_16_34 sn_16 sn_34 292741564.0683153
Csub_16_34 sn_16 sn_34 3.599244109992925e-20
Rsub_16_142 sn_16 sn_142 3681662.981054883
Csub_16_142 sn_16 sn_142 2.861881588958218e-18
Rsub_16_105 sn_16 sn_105 311244061.6456494
Csub_16_105 sn_16 sn_105 3.385280170975844e-20
Rsub_16_196 sn_16 sn_196 5581583.791085881
Csub_16_196 sn_16 sn_196 1.887722893107398e-18
Rsub_16_29 sn_16 sn_29 186427065.8708766
Csub_16_29 sn_16 sn_29 5.651799245463531e-20
Rsub_16_117 sn_16 sn_117 180682225.9078366
Csub_16_117 sn_16 sn_117 5.831499722393562e-20
Rsub_16_57 sn_16 sn_57 274210113.9838895
Csub_16_57 sn_16 sn_57 3.842485366112006e-20
Rsub_16_224 sn_16 sn_224 88431226.39867513
Csub_16_224 sn_16 sn_224 1.19148901709542e-19
Rsub_16_118 sn_16 sn_118 620284983.895348
Csub_16_118 sn_16 sn_118 1.698652035079359e-20
Rsub_16_221 sn_16 sn_221 3589532.4126015
Csub_16_221 sn_16 sn_221 2.935335941037993e-18
Rsub_16_54 sn_16 sn_54 2765418.01119845
Csub_16_54 sn_16 sn_54 3.810087104214601e-18
Rsub_16_178 sn_16 sn_178 180096164.4811983
Csub_16_178 sn_16 sn_178 5.85047634555815e-20
Rsub_16_207 sn_16 sn_207 60930966.97838371
Csub_16_207 sn_16 sn_207 1.72924934967272e-19
Rsub_16_217 sn_16 sn_217 162193692.8096356
Csub_16_217 sn_16 sn_217 6.496235038310965e-20
Rsub_16_50 sn_16 sn_50 157212763.2761518
Csub_16_50 sn_16 sn_50 6.702053499131085e-20
Rsub_16_133 sn_16 sn_133 52241446.46206482
Csub_16_133 sn_16 sn_133 2.016882038264595e-19
Rsub_16_86 sn_16 sn_86 218205684.488952
Csub_16_86 sn_16 sn_86 4.828693407739097e-20
Rsub_16_209 sn_16 sn_209 513319317.6126318
Csub_16_209 sn_16 sn_209 2.052617764559017e-20
Rsub_16_42 sn_16 sn_42 1252904781.667786
Rsub_16_159 sn_16 sn_159 536011839.5770707
Csub_16_159 sn_16 sn_159 1.965718427142132e-20
Rsub_16_165 sn_16 sn_165 624544268.1965549
Csub_16_165 sn_16 sn_165 1.687067520874915e-20
Rsub_16_185 sn_16 sn_185 106669811.8171563
Csub_16_185 sn_16 sn_185 9.877662032713327e-20
Rsub_16_208 sn_16 sn_208 349097618.5786133
Csub_16_208 sn_16 sn_208 3.018205493675486e-20
Rsub_16_41 sn_16 sn_41 54953042.51811455
Csub_16_41 sn_16 sn_41 1.917361263256131e-19
Rsub_16_107 sn_16 sn_107 59467233.40199084
Csub_16_107 sn_16 sn_107 1.771813299435797e-19
Rsub_16_100 sn_16 sn_100 857264604.893737
Csub_16_100 sn_16 sn_100 1.229081830986835e-20
Rsub_16_154 sn_16 sn_154 186795411.9864649
Csub_16_154 sn_16 sn_154 5.640654334161842e-20
Rsub_16_188 sn_16 sn_188 99761117.85174136
Csub_16_188 sn_16 sn_188 1.056171355045225e-19
Rsub_16_21 sn_16 sn_21 51009196.30096953
Csub_16_21 sn_16 sn_21 2.065604688233391e-19
Rsub_16_174 sn_16 sn_174 9317277.60044039
Csub_16_174 sn_16 sn_174 1.130854306812967e-18
Rsub_16_144 sn_16 sn_144 369507.3225408256
Csub_16_144 sn_16 sn_144 2.851495182768905e-17
Rsub_16_128 sn_16 sn_128 103757959.0421645
Csub_16_128 sn_16 sn_128 1.015486773207273e-19
Rsub_16_139 sn_16 sn_139 44936027.40713517
Csub_16_139 sn_16 sn_139 2.344774140082745e-19
Rsub_16_204 sn_16 sn_204 125703948.2904921
Csub_16_204 sn_16 sn_204 8.381982941284391e-20
Rsub_16_37 sn_16 sn_37 161343829.251785
Csub_16_37 sn_16 sn_37 6.530453349899918e-20
Rsub_16_183 sn_16 sn_183 184583328.3067944
Csub_16_183 sn_16 sn_183 5.708253068618093e-20
Rsub_16_162 sn_16 sn_162 3206106.749273866
Csub_16_162 sn_16 sn_162 3.286379502060046e-18
Rsub_16_67 sn_16 sn_67 154267905.5927515
Csub_16_67 sn_16 sn_67 6.829990633336938e-20
Rsub_16_79 sn_16 sn_79 117578974.5026322
Csub_16_79 sn_16 sn_79 8.961196971482451e-20
Rsub_16_225 sn_16 sn_225 672291116.0788676
Csub_16_225 sn_16 sn_225 1.567250146585895e-20
Rsub_16_58 sn_16 sn_58 5093687.005046736
Csub_16_58 sn_16 sn_58 2.068537680424933e-18
Rsub_16_111 sn_16 sn_111 1116134509.341092
Rsub_16_99 sn_16 sn_99 142090979.6567342
Csub_16_99 sn_16 sn_99 7.415307803270989e-20
Rsub_16_83 sn_16 sn_83 613677435.7750179
Csub_16_83 sn_16 sn_83 1.716941651752829e-20
Rsub_16_110 sn_16 sn_110 221183800.4602307
Csub_16_110 sn_16 sn_110 4.763677755923397e-20
Rsub_16_80 sn_16 sn_80 1252904781.667786
Rsub_16_96 sn_16 sn_96 1268809588.18986
Rsub_16_127 sn_16 sn_127 357293571.3876992
Csub_16_127 sn_16 sn_127 2.948970915235657e-20
Rsub_16_38 sn_16 sn_38 396567848.5922065
Csub_16_38 sn_16 sn_38 2.656918239749875e-20
Rsub_16_134 sn_16 sn_134 845240417.4048622
Csub_16_134 sn_16 sn_134 1.24656645437994e-20
Rsub_16_130 sn_16 sn_130 252820275.7200611
Csub_16_130 sn_16 sn_130 4.167578518859252e-20
Rsub_16_157 sn_16 sn_157 332225514.6209828
Csub_16_157 sn_16 sn_157 3.171485343096082e-20
Rsub_16_103 sn_16 sn_103 660661.9203837964
Csub_16_103 sn_16 sn_103 1.594837416406423e-17
Rsub_16_71 sn_16 sn_71 303982007.4605051
Csub_16_71 sn_16 sn_71 3.466153668190034e-20
Rsub_16_66 sn_16 sn_66 147776989.5869134
Csub_16_66 sn_16 sn_66 7.129989270780943e-20
Rsub_16_115 sn_16 sn_115 205577963.0356779
Csub_16_115 sn_16 sn_115 5.125298133439237e-20
Rsub_16_56 sn_16 sn_56 119061080.8153633
Csub_16_56 sn_16 sn_56 8.849645434152992e-20
Rsub_16_32 sn_16 sn_32 260962433.7808394
Csub_16_32 sn_16 sn_32 4.037547990941377e-20
Rsub_16_73 sn_16 sn_73 2505809563.335572
Rsub_16_121 sn_16 sn_121 1104238370.205767
Rsub_16_161 sn_16 sn_161 96448063.51294152
Csub_16_161 sn_16 sn_161 1.092451534894343e-19
Rsub_16_74 sn_16 sn_74 188335510.6038074
Csub_16_74 sn_16 sn_74 5.594528333212267e-20
Rsub_16_167 sn_16 sn_167 1135317163.511693
Rsub_16_230 sn_16 0 670838.2406851688
Csub_16_230 sn_16 0 1.570644436051892e-17
Rsub_16_109 sn_16 sn_109 1127587542.513067
Rsub_16_171 sn_16 sn_171 201049429.1433617
Csub_16_171 sn_16 sn_171 5.240742809926997e-20
Rsub_16_69 sn_16 sn_69 477535695.3207832
Csub_16_69 sn_16 sn_69 2.206428462934514e-20
Rsub_16_75 sn_16 sn_75 659839000.3025938
Csub_16_75 sn_16 sn_75 1.596826422414877e-20
Rsub_16_176 sn_16 sn_176 515119317.9040379
Csub_16_176 sn_16 sn_176 2.045445227156643e-20
Rsub_129_189 sn_129 sn_189 11165903.75277113
Csub_129_189 sn_129 sn_189 9.436301561900062e-19
Rsub_129_175 sn_129 sn_175 12646944.17244204
Csub_129_175 sn_129 sn_175 8.331248528153723e-19
Rsub_129_162 sn_129 sn_162 7906110.858004286
Csub_129_162 sn_129 sn_162 1.332701209414826e-18
Rsub_129_169 sn_129 sn_169 25459043.62857598
Csub_129_169 sn_129 sn_169 4.138601455713577e-19
Rsub_129_160 sn_129 sn_160 14052852.70984822
Csub_129_160 sn_129 sn_160 7.497754171184082e-19
Rsub_129_203 sn_129 sn_203 29674442.31220691
Csub_129_203 sn_129 sn_203 3.550693014337022e-19
Rsub_129_183 sn_129 sn_183 11285188.46723311
Csub_129_183 sn_129 sn_183 9.336559626649573e-19
Rsub_129_134 sn_129 sn_134 5642594.233616554
Csub_129_134 sn_129 sn_134 1.867311925329915e-18
Rsub_129_137 sn_129 sn_137 3730026.785715316
Csub_129_137 sn_129 sn_137 2.824774219472367e-18
Rsub_129_216 sn_129 sn_216 1084994.466780933
Csub_129_216 sn_129 sn_216 9.71109422658225e-18
Rsub_129_202 sn_129 sn_202 30822958.08126622
Csub_129_202 sn_129 sn_202 3.418388161983043e-19
Rsub_129_190 sn_129 sn_190 13179200.36426213
Csub_129_190 sn_129 sn_190 7.99478208920903e-19
Rsub_129_159 sn_129 sn_159 9537257.913920881
Csub_129_159 sn_129 sn_159 1.104770742002334e-18
Rsub_129_200 sn_129 sn_200 24216804.73371444
Csub_129_200 sn_129 sn_200 4.350897493739624e-19
Rsub_129_227 sn_129 sn_227 6111042.001595451
Csub_129_227 sn_129 sn_227 1.724171344179793e-18
Rsub_129_185 sn_129 sn_185 61647414.422158
Csub_129_185 sn_129 sn_185 1.709152541269089e-19
Rsub_129_157 sn_129 sn_157 14452778.12434255
Csub_129_157 sn_129 sn_157 7.290282471356559e-19
Rsub_129_166 sn_129 sn_166 30609280.04080186
Csub_129_166 sn_129 sn_166 3.442251332989531e-19
Rsub_129_201 sn_129 sn_201 3938628.963925186
Csub_129_201 sn_129 sn_201 2.675165291967355e-18
Rsub_129_135 sn_129 sn_135 5605908.774222142
Csub_129_135 sn_129 sn_135 1.879531745268547e-18
Rsub_129_214 sn_129 sn_214 2133257.90236751
Csub_129_214 sn_129 sn_214 4.939151281491331e-18
Rsub_129_177 sn_129 sn_177 772175.5950160094
Csub_129_177 sn_129 sn_177 1.364519102939474e-17
Rsub_129_147 sn_129 sn_147 20211816.66535804
Csub_129_147 sn_129 sn_147 5.213031404687618e-19
Rsub_129_226 sn_129 sn_226 1167315.599311336
Csub_129_226 sn_129 sn_226 9.026250920013455e-18
Rsub_129_155 sn_129 sn_155 2326748.491540946
Csub_129_155 sn_129 sn_155 4.52841531456284e-18
Rsub_129_209 sn_129 sn_209 21263025.82671082
Csub_129_209 sn_129 sn_209 4.955307672623887e-19
Rsub_129_130 sn_129 sn_130 7494775.025160691
Csub_129_130 sn_129 sn_130 1.405843866808276e-18
Rsub_129_204 sn_129 sn_204 415145.6915540566
Csub_129_204 sn_129 sn_204 2.538020679628813e-17
Rsub_129_181 sn_129 sn_181 1739550.407803454
Csub_129_181 sn_129 sn_181 6.057015338540559e-18
Rsub_129_223 sn_129 sn_223 7604231.5291196
Csub_129_223 sn_129 sn_223 1.385607929201215e-18
Rsub_129_144 sn_129 sn_144 7835631.656334168
Csub_129_144 sn_129 sn_144 1.344688464740749e-18
Rsub_129_198 sn_129 sn_198 6390607.70646099
Csub_129_198 sn_129 sn_198 1.648745156360869e-18
Rsub_129_168 sn_129 sn_168 2044373.154091107
Csub_129_168 sn_129 sn_168 5.153894474276806e-18
Rsub_129_210 sn_129 sn_210 7595535.345733901
Csub_129_210 sn_129 sn_210 1.387194321746907e-18
Rsub_129_131 sn_129 sn_131 24668.77355378396
Csub_129_131 sn_129 sn_131 4.271182545519698e-16
Rsub_129_206 sn_129 sn_206 1071122.02373677
Csub_129_206 sn_129 sn_206 9.836865705992954e-18
Rsub_129_211 sn_129 sn_211 7495851.060736061
Csub_129_211 sn_129 sn_211 1.405642056766715e-18
Rsub_129_132 sn_129 sn_132 2706306.497232925
Csub_129_132 sn_129 sn_132 3.893307544065343e-18
Rsub_129_153 sn_129 sn_153 290169.1797972022
Csub_129_153 sn_129 sn_153 3.631151836867684e-17
Rsub_129_221 sn_129 sn_221 15097677.90263475
Csub_129_221 sn_129 sn_221 6.978876864495327e-19
Rsub_129_222 sn_129 sn_222 564019.7240240537
Csub_129_222 sn_129 sn_222 1.86810550295235e-17
Rsub_129_188 sn_129 sn_188 3075500.623187192
Csub_129_188 sn_129 sn_188 3.425940942034624e-18
Rsub_129_219 sn_129 sn_219 256163.5962598564
Csub_129_219 sn_129 sn_219 4.11318534564202e-17
Rsub_129_212 sn_129 sn_212 1504701.541630662
Csub_129_212 sn_129 sn_212 7.002374365092692e-18
Rsub_129_133 sn_129 sn_133 2618453.201173947
Csub_129_133 sn_129 sn_133 4.023934243891056e-18
Rsub_129_165 sn_129 sn_165 618987958.344743
Csub_129_165 sn_129 sn_165 1.702211385566526e-20
Rsub_129_230 sn_129 0 112922.0933278034
Csub_129_230 sn_129 0 9.330754674945204e-17
Rsub_129_229 sn_129 sn_229 3636684.357250038
Csub_129_229 sn_129 sn_229 2.897277428332385e-18
Rsub_129_150 sn_129 sn_150 3043980.233934698
Csub_129_150 sn_129 sn_150 3.461416531148224e-18
Rsub_129_145 sn_129 sn_145 19871993.77163091
Csub_129_145 sn_129 sn_145 5.302177337269398e-19
Rsub_129_224 sn_129 sn_224 6633778.647863572
Csub_129_224 sn_129 sn_224 1.5883079706953e-18
Rsub_129_195 sn_129 sn_195 214513.4463939416
Csub_129_195 sn_129 sn_195 4.911805613751762e-17
Rsub_129_218 sn_129 sn_218 14777732.70825968
Csub_129_218 sn_129 sn_218 7.129972987223456e-19
Rsub_129_139 sn_129 sn_139 31694361.23169893
Csub_129_139 sn_129 sn_139 3.324403172287946e-19
Rsub_129_215 sn_129 sn_215 1793857.402291895
Csub_129_215 sn_129 sn_215 5.873646081772286e-18
Rsub_129_217 sn_129 sn_217 137425093.7174295
Csub_129_217 sn_129 sn_217 7.667073907109638e-20
Rsub_129_149 sn_129 sn_149 15417264.48513179
Csub_129_149 sn_129 sn_149 6.83421077221011e-19
Rsub_129_141 sn_129 sn_141 3391820.979996207
Csub_129_141 sn_129 sn_141 3.106438566295378e-18
Rsub_129_220 sn_129 sn_220 8211651.602209125
Csub_129_220 sn_129 sn_220 1.283113801296129e-18
Rsub_129_225 sn_129 sn_225 31090054.77174512
Csub_129_225 sn_129 sn_225 3.389020566089718e-19
Rsub_129_146 sn_129 sn_146 22533177.12504719
Csub_129_146 sn_129 sn_146 4.675986632403457e-19
Rsub_129_199 sn_129 sn_199 3533608.101425386
Csub_129_199 sn_129 sn_199 2.981791754999599e-18
Rsub_210_220 sn_210 sn_220 60167363.18390028
Csub_210_220 sn_210 sn_220 1.75119582189857e-19
Rsub_210_221 sn_210 sn_221 1850152.771822274
Csub_210_221 sn_210 sn_221 5.694926204311378e-18
Rsub_210_217 sn_210 sn_217 32478957.42316677
Csub_210_217 sn_210 sn_217 3.244095358404109e-19
Rsub_210_214 sn_210 sn_214 8201912.61131814
Csub_210_214 sn_210 sn_214 1.284637376858941e-18
Rsub_210_226 sn_210 sn_226 1523242.703548927
Csub_210_226 sn_210 sn_226 6.917140307110335e-18
Rsub_210_216 sn_210 sn_216 212955.8165579184
Csub_210_216 sn_210 sn_216 4.947732197474098e-17
Rsub_210_230 sn_210 0 51460.14805363022
Csub_210_230 sn_210 0 2.047503534433907e-16
Rsub_210_213 sn_210 sn_213 4979200.081504332
Csub_210_213 sn_210 sn_213 2.11609964045604e-18
Rsub_210_228 sn_210 sn_228 45653.75023693169
Csub_210_228 sn_210 sn_228 2.307911934408073e-16
Rsub_210_211 sn_210 sn_211 4590812.786726387
Csub_210_211 sn_210 sn_211 2.295123759499534e-18
Rsub_210_222 sn_210 sn_222 55560.53580697624
Csub_210_222 sn_210 sn_222 1.896397028789457e-16
Rsub_210_227 sn_210 sn_227 4763807.867033552
Csub_210_227 sn_210 sn_227 2.211777593958911e-18
Rsub_210_215 sn_210 sn_215 447703.5752732551
Csub_210_215 sn_210 sn_215 2.35345082866472e-17
Rsub_210_229 sn_210 sn_229 825025.3936202927
Csub_210_229 sn_210 sn_229 1.27711020578347e-17
Rsub_210_212 sn_210 sn_212 919474.2762934074
Csub_210_212 sn_210 sn_212 1.145924771784238e-17
Rsub_210_224 sn_210 sn_224 1516370.983833789
Csub_210_224 sn_210 sn_224 6.948486626663726e-18
Rsub_210_219 sn_210 sn_219 267890.5619676317
Csub_210_219 sn_210 sn_219 3.933129791822635e-17
Rsub_210_225 sn_210 sn_225 9056496.741173595
Csub_210_225 sn_210 sn_225 1.163417136156847e-18
Rsub_210_218 sn_210 sn_218 14059657.47292426
Csub_210_218 sn_210 sn_218 7.49412531743458e-19
Rsub_174_225 sn_174 sn_225 58143133.60129409
Csub_174_225 sn_174 sn_225 1.812162993223243e-19
Rsub_174_217 sn_174 sn_217 27615832.10852436
Csub_174_217 sn_174 sn_217 3.815377882087296e-19
Rsub_174_202 sn_174 sn_202 56354857.67174473
Csub_174_202 sn_174 sn_202 1.869667307759487e-19
Rsub_174_203 sn_174 sn_203 318640.1011157106
Csub_174_203 sn_174 sn_203 3.306703539616251e-17
Rsub_174_211 sn_174 sn_211 323628.6220899356
Csub_174_211 sn_174 sn_211 3.255732893520751e-17
Rsub_174_222 sn_174 sn_222 242866.4715147794
Csub_174_222 sn_174 sn_222 4.338385383751422e-17
Rsub_174_177 sn_174 sn_177 5277029.546462469
Csub_174_177 sn_174 sn_177 1.996669415901467e-18
Rsub_174_214 sn_174 sn_214 244713.2776442242
Csub_174_214 sn_174 sn_214 4.305644386631297e-17
Rsub_174_182 sn_174 sn_182 33898.74474629769
Csub_174_182 sn_174 sn_182 3.108222319465313e-16
Rsub_174_219 sn_174 sn_219 20118476.6334223
Csub_174_219 sn_174 sn_219 5.237217357066694e-19
Rsub_174_200 sn_174 sn_200 109629.1934577471
Csub_174_200 sn_174 sn_200 9.611019811334229e-17
Rsub_174_196 sn_174 sn_196 377914.5169833123
Csub_174_196 sn_174 sn_196 2.788060005298834e-17
Rsub_174_213 sn_174 sn_213 26361.95705491526
Csub_174_213 sn_174 sn_213 3.996851781634113e-16
Rsub_174_227 sn_174 sn_227 336968.6921534967
Csub_174_227 sn_174 sn_227 3.126843456848627e-17
Rsub_174_190 sn_174 sn_190 50352428.44821271
Csub_174_190 sn_174 sn_190 2.092547236935501e-19
Rsub_174_192 sn_174 sn_192 488620.1621681092
Csub_174_192 sn_174 sn_192 2.156375098292595e-17
Rsub_174_229 sn_174 sn_229 22992930.46152189
Csub_174_229 sn_174 sn_229 4.58248830868364e-19
Rsub_174_226 sn_174 sn_226 1096404.824210795
Csub_174_226 sn_174 sn_226 9.610030227488538e-18
Rsub_174_198 sn_174 sn_198 754451.9844661024
Csub_174_198 sn_174 sn_198 1.396574430072747e-17
Rsub_174_181 sn_174 sn_181 56524018.90832371
Csub_174_181 sn_174 sn_181 1.864071894696504e-19
Rsub_174_218 sn_174 sn_218 5616393.080701603
Csub_174_218 sn_174 sn_218 1.876023161276628e-18
Rsub_174_215 sn_174 sn_215 1771466.41802663
Csub_174_215 sn_174 sn_215 5.947887803578792e-18
Rsub_174_230 sn_174 0 193404.6215547874
Csub_174_230 sn_174 0 5.447896445041901e-17
Rsub_174_207 sn_174 sn_207 20807662.58382898
Csub_174_207 sn_174 sn_207 5.063751615435461e-19
Rsub_174_221 sn_174 sn_221 431395.2896648694
Csub_174_221 sn_174 sn_221 2.442419691326555e-17
Rsub_174_184 sn_174 sn_184 57273161.52745926
Csub_174_184 sn_174 sn_184 1.839689519702583e-19
Rsub_174_197 sn_174 sn_197 9885993.570511281
Csub_174_197 sn_174 sn_197 1.065799145738781e-18
Rsub_174_206 sn_174 sn_206 1969127.025431711
Csub_174_206 sn_174 sn_206 5.350839923554441e-18
Rsub_174_195 sn_174 sn_195 13565762.77354135
Csub_174_195 sn_174 sn_195 7.766967238127109e-19
Rsub_174_188 sn_174 sn_188 37709335.5189583
Csub_174_188 sn_174 sn_188 2.794131309190745e-19
Rsub_174_179 sn_174 sn_179 36909693.82160082
Csub_174_179 sn_174 sn_179 2.85466564777183e-19
Rsub_174_216 sn_174 sn_216 19068727.78027968
Csub_174_216 sn_174 sn_216 5.525530399110593e-19
Rsub_174_186 sn_174 sn_186 57780645.23719624
Csub_174_186 sn_174 sn_186 1.823531644372699e-19
Rsub_174_191 sn_174 sn_191 123531623.4563461
Csub_174_191 sn_174 sn_191 8.529381552209103e-20
Rsub_193_225 sn_193 sn_225 8589618.71958269
Csub_193_225 sn_193 sn_225 1.22665322480599e-18
Rsub_193_215 sn_193 sn_215 16725040.00811007
Csub_193_215 sn_193 sn_215 6.299825589129116e-19
Rsub_193_229 sn_193 sn_229 123962.0025108491
Csub_193_229 sn_193 sn_229 8.499768710422254e-17
Rsub_193_195 sn_193 sn_195 8263791.408151685
Csub_193_195 sn_193 sn_195 1.275018085746508e-18
Rsub_193_220 sn_193 sn_220 107745.6365913793
Csub_193_220 sn_193 sn_220 9.779034989777971e-17
Rsub_193_205 sn_193 sn_205 61453.22958068502
Csub_193_205 sn_193 sn_205 1.71455325849004e-16
Rsub_193_222 sn_193 sn_222 47268482.67835878
Csub_193_222 sn_193 sn_222 2.229071657308345e-19
Rsub_193_230 sn_193 0 174418.6517463883
Csub_193_230 sn_193 0 6.040915576821723e-17
Rsub_193_209 sn_193 sn_209 106337.726973658
Csub_193_209 sn_193 sn_209 9.908509239472557e-17
Rsub_193_226 sn_193 sn_226 9266013.376773657
Csub_193_226 sn_193 sn_226 1.137110758834099e-18
Rsub_193_194 sn_193 sn_194 42897229.76772374
Csub_193_194 sn_193 sn_194 2.45621536851728e-19
Rsub_193_223 sn_193 sn_223 5699329.209053667
Csub_193_223 sn_193 sn_223 1.848723440206309e-18
Rsub_193_206 sn_193 sn_206 6508460.305201673
Csub_193_206 sn_193 sn_206 1.618890337828298e-18
Rsub_193_202 sn_193 sn_202 16787094.83101702
Csub_193_202 sn_193 sn_202 6.276537785896137e-19
Rsub_193_217 sn_193 sn_217 110598.8063431762
Csub_193_217 sn_193 sn_217 9.526760595893253e-17
Rsub_28_57 sn_28 sn_57 8797753.829464288
Csub_28_57 sn_28 sn_57 1.197633362613828e-18
Rsub_28_182 sn_28 sn_182 16469054.67551202
Csub_28_182 sn_28 sn_182 6.397746385466065e-19
Rsub_28_94 sn_28 sn_94 121216224.8176
Csub_28_94 sn_28 sn_94 8.692304613581858e-20
Rsub_28_111 sn_28 sn_111 130996145.3982783
Csub_28_111 sn_28 sn_111 8.043353848462542e-20
Rsub_28_186 sn_28 sn_186 30990993.81909833
Csub_28_186 sn_28 sn_186 3.399853377963261e-19
Rsub_28_108 sn_28 sn_108 89630568.28105994
Csub_28_108 sn_28 sn_108 1.175545765724716e-19
Rsub_28_152 sn_28 sn_152 110100152.7564088
Csub_28_152 sn_28 sn_152 9.569908159474995e-20
Rsub_28_175 sn_28 sn_175 35220648.05141167
Csub_28_175 sn_28 sn_175 2.991564347950064e-19
Rsub_28_70 sn_28 sn_70 17174313.89943828
Csub_28_70 sn_28 sn_70 6.135024411411637e-19
Rsub_28_164 sn_28 sn_164 147895252.5519201
Csub_28_164 sn_28 sn_164 7.124287845907064e-20
Rsub_28_33 sn_28 sn_33 60102049.08895942
Csub_28_33 sn_28 sn_33 1.753098881310109e-19
Rsub_28_154 sn_28 sn_154 64113910.09325083
Csub_28_154 sn_28 sn_154 1.643400548633699e-19
Rsub_28_133 sn_28 sn_133 147895252.5519201
Csub_28_133 sn_28 sn_133 7.124287845907064e-20
Rsub_28_202 sn_28 sn_202 147895252.5519201
Csub_28_202 sn_28 sn_202 7.124287845907064e-20
Rsub_28_223 sn_28 sn_223 46189103.14880607
Csub_28_223 sn_28 sn_223 2.281162175477822e-19
Rsub_28_199 sn_28 sn_199 104585631.893751
Csub_28_199 sn_28 sn_199 1.007450384096169e-19
Rsub_28_90 sn_28 sn_90 37602936.20195939
Csub_28_90 sn_28 sn_90 2.802037438151165e-19
Rsub_28_75 sn_28 sn_75 41551700.30108368
Csub_28_75 sn_28 sn_75 2.535752670981603e-19
Rsub_28_185 sn_28 sn_185 87680631.5372688
Csub_28_185 sn_28 sn_185 1.201688824258919e-19
Rsub_28_84 sn_28 sn_84 115230628.4400849
Csub_28_84 sn_28 sn_84 9.143821955035616e-20
Rsub_28_137 sn_28 sn_137 52577983.68229985
Csub_28_137 sn_28 sn_137 2.003972530764253e-19
Rsub_28_114 sn_28 sn_114 75832565.76926884
Csub_28_114 sn_28 sn_114 1.389440459431206e-19
Rsub_28_171 sn_28 sn_171 37452087.81136794
Csub_28_171 sn_28 sn_171 2.813323400099428e-19
Rsub_28_196 sn_28 sn_196 17584569.28611754
Csub_28_196 sn_28 sn_196 5.991891715282571e-19
Rsub_28_121 sn_28 sn_121 139339992.483497
Csub_28_121 sn_28 sn_121 7.561708102918056e-20
Rsub_28_97 sn_28 sn_97 6295558.88810524
Csub_28_97 sn_28 sn_97 1.673637510108518e-18
Rsub_28_165 sn_28 sn_165 43635823.37968028
Csub_28_165 sn_28 sn_165 2.414640697976719e-19
Rsub_28_184 sn_28 sn_184 69044487.88881385
Csub_28_184 sn_28 sn_184 1.526042675441011e-19
Rsub_28_99 sn_28 sn_99 644022715.2151136
Csub_28_99 sn_28 sn_99 1.636042216105786e-20
Rsub_28_160 sn_28 sn_160 6792307.100086293
Csub_28_160 sn_28 sn_160 1.551237796962411e-18
Rsub_28_96 sn_28 sn_96 58871239.88600516
Csub_28_96 sn_28 sn_96 1.789750567956822e-19
Rsub_28_198 sn_28 sn_198 18200074.36556206
Csub_28_198 sn_28 sn_198 5.78925299457402e-19
Rsub_28_30 sn_28 sn_30 96462897.96380323
Csub_28_30 sn_28 sn_30 1.092283533321144e-19
Rsub_28_170 sn_28 sn_170 39881172.99441003
Csub_28_170 sn_28 sn_170 2.641969308101056e-19
Rsub_28_148 sn_28 sn_148 75733229.75212224
Csub_28_148 sn_28 sn_148 1.391262928666361e-19
Rsub_28_130 sn_28 sn_130 35461423.17094627
Csub_28_130 sn_28 sn_130 2.97125229617479e-19
Rsub_28_176 sn_28 sn_176 152390108.2667334
Csub_28_176 sn_28 sn_176 6.914151858063945e-20
Rsub_28_169 sn_28 sn_169 50362609.14257616
Csub_28_169 sn_28 sn_169 2.092124232960468e-19
Rsub_28_189 sn_28 sn_189 152390108.2667334
Csub_28_189 sn_28 sn_189 6.914151858063945e-20
Rsub_28_101 sn_28 sn_101 15250555.14945466
Csub_28_101 sn_28 sn_101 6.908918002638595e-19
Rsub_28_221 sn_28 sn_221 152390108.2667334
Csub_28_221 sn_28 sn_221 6.914151858063945e-20
Rsub_28_91 sn_28 sn_91 83916136.34838612
Csub_28_91 sn_28 sn_91 1.255596832829237e-19
Rsub_28_69 sn_28 sn_69 152390108.2667334
Csub_28_69 sn_28 sn_69 6.914151858063945e-20
Rsub_28_140 sn_28 sn_140 76195054.13336669
Csub_28_140 sn_28 sn_140 1.382830371612789e-19
Rsub_28_229 sn_28 sn_229 27473581.62229998
Csub_28_229 sn_28 sn_229 3.835132836731292e-19
Rsub_28_138 sn_28 sn_138 1122250.107594595
Csub_28_138 sn_28 sn_138 9.388712401029447e-18
Rsub_28_179 sn_28 sn_179 19791993.02900165
Csub_28_179 sn_28 sn_179 5.323609141732546e-19
Rsub_28_100 sn_28 sn_100 75812541.94507323
Csub_28_100 sn_28 sn_100 1.389807442397033e-19
Rsub_28_177 sn_28 sn_177 5080658.476418768
Csub_28_177 sn_28 sn_177 2.073842111437672e-18
Rsub_28_134 sn_28 sn_134 67234376.09685422
Csub_28_134 sn_28 sn_134 1.5671274300295e-19
Rsub_28_50 sn_28 sn_50 9893199.402130272
Csub_28_50 sn_28 sn_50 1.065022858021159e-18
Rsub_28_217 sn_28 sn_217 60669328.29805897
Csub_28_217 sn_28 sn_217 1.736706800257603e-19
Rsub_28_132 sn_28 sn_132 11243450.53815995
Csub_28_132 sn_28 sn_132 9.371218796640302e-19
Rsub_28_53 sn_28 sn_53 19990924.90955833
Csub_28_53 sn_28 sn_53 5.270633324820381e-19
Rsub_28_155 sn_28 sn_155 53909126.29333253
Csub_28_155 sn_28 sn_155 1.954489754647192e-19
Rsub_28_34 sn_28 sn_34 1530140.627969696
Csub_28_34 sn_28 sn_34 6.885957610452179e-18
Rsub_28_211 sn_28 sn_211 47965940.61726369
Csub_28_211 sn_28 sn_211 2.196659414292348e-19
Rsub_28_44 sn_28 sn_44 19336212.80011144
Csub_28_44 sn_28 sn_44 5.449093683003571e-19
Rsub_28_139 sn_28 sn_139 57049657.23087569
Csub_28_139 sn_28 sn_139 1.846896898887515e-19
Rsub_28_227 sn_28 sn_227 38718817.97855405
Csub_28_227 sn_28 sn_227 2.721282325319448e-19
Rsub_28_60 sn_28 sn_60 50137315.27810962
Csub_28_60 sn_28 sn_60 2.101525269908164e-19
Rsub_28_128 sn_28 sn_128 21221373.35301284
Csub_28_128 sn_28 sn_128 4.965033754864934e-19
Rsub_28_216 sn_28 sn_216 4189250.666323149
Csub_28_216 sn_28 sn_216 2.515123668041984e-18
Rsub_28_49 sn_28 sn_49 19106127.63744009
Csub_28_49 sn_28 sn_49 5.514714285475023e-19
Rsub_28_207 sn_28 sn_207 29117158.98449782
Csub_28_207 sn_28 sn_207 3.618650950059962e-19
Rsub_28_156 sn_28 sn_156 19522318.46084894
Csub_28_156 sn_28 sn_156 5.397147640717165e-19
Rsub_28_77 sn_28 sn_77 37527259.88219895
Csub_28_77 sn_28 sn_77 2.807687940794202e-19
Rsub_28_45 sn_28 sn_45 28676426.26878618
Csub_28_45 sn_28 sn_45 3.674266592172537e-19
Rsub_28_203 sn_28 sn_203 76195054.13336669
Csub_28_203 sn_28 sn_203 1.382830371612789e-19
Rsub_28_126 sn_28 sn_126 1704085.968809404
Csub_28_126 sn_28 sn_126 6.183070393796824e-18
Rsub_28_214 sn_28 sn_214 147798588.9881607
Csub_28_214 sn_28 sn_214 7.128947288579338e-20
Rsub_28_47 sn_28 sn_47 1291103.440107899
Csub_28_47 sn_28 sn_47 8.160836053034957e-18
Rsub_28_131 sn_28 sn_131 68268.87501422479
Csub_28_131 sn_28 sn_131 1.543380273958605e-16
Rsub_28_43 sn_28 sn_43 50795711.53165954
Csub_28_43 sn_28 sn_43 2.074286034100125e-19
Rsub_28_210 sn_28 sn_210 19405053.22822003
Csub_28_210 sn_28 sn_210 5.429762741854885e-19
Rsub_28_80 sn_28 sn_80 3509148.239772532
Csub_28_80 sn_28 sn_80 3.002575776882253e-18
Rsub_28_159 sn_28 sn_159 19693296.47340203
Csub_28_159 sn_28 sn_159 5.35028938220713e-19
Rsub_28_110 sn_28 sn_110 3396984.557616868
Csub_28_110 sn_28 sn_110 3.101716632359907e-18
Rsub_28_151 sn_28 sn_151 50385305.61073863
Csub_28_151 sn_28 sn_151 2.091181818689686e-19
Rsub_28_72 sn_28 sn_72 61369595.82888073
Csub_28_72 sn_28 sn_72 1.71688983118111e-19
Rsub_28_230 sn_28 0 497190.8012325754
Csub_28_230 sn_28 0 2.119203226630344e-17
Rsub_28_188 sn_28 sn_188 12346419.26502925
Csub_28_188 sn_28 sn_188 8.534039931783444e-19
Rsub_28_86 sn_28 sn_86 8423133.839245848
Csub_28_86 sn_28 sn_86 1.250898264626574e-18
Rsub_28_195 sn_28 sn_195 331906.6205153024
Csub_28_195 sn_28 sn_195 3.174532489250006e-17
Rsub_28_204 sn_28 sn_204 26199056.26385607
Csub_28_204 sn_28 sn_204 4.02170345225985e-19
Rsub_28_79 sn_28 sn_79 18995653.15600619
Csub_28_79 sn_28 sn_79 5.54678663360333e-19
Rsub_28_158 sn_28 sn_158 11305525.54644439
Csub_28_158 sn_28 sn_158 9.319764445221871e-19
Rsub_28_153 sn_28 sn_153 67552.70120390088
Csub_28_153 sn_28 sn_153 1.559742736330663e-16
Rsub_28_52 sn_28 sn_52 202027.1205333503
Csub_28_52 sn_28 sn_52 5.215380724337283e-17
Rsub_28_219 sn_28 sn_219 30784.94530221281
Csub_28_219 sn_28 sn_219 3.422609135340138e-16
Rsub_28_55 sn_28 sn_55 99736187.74962687
Csub_28_55 sn_28 sn_55 1.05643535610969e-19
Rsub_28_222 sn_28 sn_222 172597.3526644855
Csub_28_222 sn_28 sn_222 6.104661131571367e-17
Rsub_28_150 sn_28 sn_150 2229286.748547649
Csub_28_150 sn_28 sn_150 4.726392201045638e-18
Rsub_28_183 sn_28 sn_183 14233626.29138293
Csub_28_183 sn_28 sn_183 7.402529254690924e-19
Rsub_28_174 sn_28 sn_174 55573713.59876577
Csub_28_174 sn_28 sn_174 1.895947349911129e-19
Rsub_28_208 sn_28 sn_208 147895252.5519201
Csub_28_208 sn_28 sn_208 7.124287845907064e-20
Rsub_28_41 sn_28 sn_41 3588670.537091766
Csub_28_41 sn_28 sn_41 2.936040907998397e-18
Rsub_28_78 sn_28 sn_78 37854947.40169781
Csub_28_78 sn_28 sn_78 2.783383474403516e-19
Rsub_28_215 sn_28 sn_215 16246535.59535921
Csub_28_215 sn_28 sn_215 6.485372490883364e-19
Rsub_28_48 sn_28 sn_48 7837288.653152916
Csub_28_48 sn_28 sn_48 1.344404164314046e-18
Rsub_28_127 sn_28 sn_127 39475743.12395371
Csub_28_127 sn_28 sn_127 2.669103269100084e-19
Rsub_28_191 sn_28 sn_191 75620486.70983607
Csub_28_191 sn_28 sn_191 1.393337171004945e-19
Rsub_28_112 sn_28 sn_112 5883862.297461607
Csub_28_112 sn_28 sn_112 1.790742707689745e-18
Rsub_28_226 sn_28 sn_226 41497587.10743648
Csub_28_226 sn_28 sn_226 2.539059313244224e-19
Rsub_28_82 sn_28 sn_82 39511003.57717099
Csub_28_82 sn_28 sn_82 2.666721305028522e-19
Rsub_28_141 sn_28 sn_141 60671345.79920074
Csub_28_141 sn_28 sn_141 1.736649049635686e-19
Rsub_28_181 sn_28 sn_181 20045009.20571477
Csub_28_181 sn_28 sn_181 5.256412403754887e-19
Rsub_28_225 sn_28 sn_225 923030542.3755115
Csub_28_225 sn_28 sn_225 1.141509735432298e-20
Rsub_28_168 sn_28 sn_168 18618074.30259315
Csub_28_168 sn_28 sn_168 5.659276749562907e-19
Rsub_28_38 sn_28 sn_38 42640582.01277822
Csub_28_38 sn_28 sn_38 2.470998988492349e-19
Rsub_28_117 sn_28 sn_117 16813185.58865711
Csub_28_117 sn_28 sn_117 6.266797833563651e-19
Rsub_28_213 sn_28 sn_213 72369218.6670354
Csub_28_213 sn_28 sn_213 1.455934400882157e-19
Rsub_28_46 sn_28 sn_46 5366711.074084486
Csub_28_46 sn_28 sn_46 1.963303661549813e-18
Rsub_28_125 sn_28 sn_125 42381538.22571181
Csub_28_125 sn_28 sn_125 2.48610219056131e-19
Rsub_28_83 sn_28 sn_83 89457841.87697881
Csub_28_83 sn_28 sn_83 1.177815525297338e-19
Rsub_28_166 sn_28 sn_166 19797936.94641801
Csub_28_166 sn_28 sn_166 5.322010839183089e-19
Rsub_28_87 sn_28 sn_87 532637660.608559
Csub_28_87 sn_28 sn_87 1.978170955878648e-20
Rsub_28_218 sn_28 sn_218 151665131.5385377
Csub_28_218 sn_28 sn_218 6.947202297156028e-20
Rsub_28_51 sn_28 sn_51 37657708.51768082
Csub_28_51 sn_28 sn_51 2.797961935810028e-19
Rsub_28_61 sn_28 sn_61 18576890.94395296
Csub_28_61 sn_28 sn_61 5.671822876076998e-19
Rsub_28_228 sn_28 sn_228 9845950.113395032
Csub_28_228 sn_28 sn_228 1.070133748483605e-18
Rsub_28_115 sn_28 sn_115 46659383.61313962
Csub_28_115 sn_28 sn_115 2.258170315662475e-19
Rsub_28_93 sn_28 sn_93 33628721.43611122
Csub_28_93 sn_28 sn_93 3.133179928427403e-19
Rsub_28_193 sn_28 sn_193 304780216.5334668
Csub_28_193 sn_28 sn_193 3.457075929031972e-20
Rsub_28_135 sn_28 sn_135 29173764.70256774
Csub_28_135 sn_28 sn_135 3.611629698686995e-19
Rsub_28_107 sn_28 sn_107 86665528.08254796
Csub_28_107 sn_28 sn_107 1.215764068522621e-19
Rsub_28_206 sn_28 sn_206 59628297.52795517
Csub_28_206 sn_28 sn_206 1.76702739119631e-19
Rsub_28_39 sn_28 sn_39 258600678.2386412
Csub_28_39 sn_28 sn_39 4.074422222708461e-20
Rsub_103_155 sn_103 sn_155 14214948.54075621
Csub_103_155 sn_103 sn_155 7.412255817895126e-19
Rsub_103_199 sn_103 sn_199 23682573.1210591
Csub_103_199 sn_103 sn_199 4.449045062954207e-19
Rsub_103_150 sn_103 sn_150 2830816.511776967
Csub_103_150 sn_103 sn_150 3.722065156252749e-18
Rsub_103_110 sn_103 sn_110 23672821.78452092
Csub_103_110 sn_103 sn_110 4.450877718819119e-19
Rsub_103_216 sn_103 sn_216 5137630.396652744
Csub_103_216 sn_103 sn_216 2.050844978863155e-18
Rsub_103_186 sn_103 sn_186 48911763.262269
Csub_103_186 sn_103 sn_186 2.154181898070713e-19
Rsub_103_140 sn_103 sn_140 5636793.624328371
Csub_103_140 sn_103 sn_140 1.869233504798649e-18
Rsub_103_219 sn_103 sn_219 3797614.523593554
Csub_103_219 sn_103 sn_219 2.77450052836318e-18
Rsub_103_206 sn_103 sn_206 4143309.291272598
Csub_103_206 sn_103 sn_206 2.543011578793764e-18
Rsub_103_105 sn_103 sn_105 15717207.42735321
Csub_103_105 sn_103 sn_105 6.70378853936418e-19
Rsub_103_197 sn_103 sn_197 8027991.328368196
Csub_103_197 sn_103 sn_197 1.312468221658093e-18
Rsub_103_181 sn_103 sn_181 10738690.59124569
Csub_103_181 sn_103 sn_181 9.811702285956047e-19
Rsub_103_168 sn_103 sn_168 24359218.06737508
Csub_103_168 sn_103 sn_168 4.325460477872146e-19
Rsub_103_225 sn_103 sn_225 24359218.06737508
Csub_103_225 sn_103 sn_225 4.325460477872146e-19
Rsub_103_207 sn_103 sn_207 6717643.373808936
Csub_103_207 sn_103 sn_207 1.568479140067205e-18
Rsub_103_195 sn_103 sn_195 11044674.19736846
Csub_103_195 sn_103 sn_195 9.539877151596246e-19
Rsub_103_177 sn_103 sn_177 17797462.80519206
Csub_103_177 sn_103 sn_177 5.920216616020228e-19
Rsub_103_156 sn_103 sn_156 20416605.13845177
Csub_103_156 sn_103 sn_156 5.160742165888309e-19
Rsub_103_112 sn_103 sn_112 24431715.74019465
Csub_103_112 sn_103 sn_112 4.312625283575789e-19
Rsub_103_171 sn_103 sn_171 16698630.63944065
Csub_103_171 sn_103 sn_171 6.309788946013203e-19
Rsub_103_208 sn_103 sn_208 2884075.371722784
Csub_103_208 sn_103 sn_208 3.653331534097911e-18
Rsub_103_174 sn_103 sn_174 1924319.71205748
Csub_103_174 sn_103 sn_174 5.475432921156541e-18
Rsub_103_160 sn_103 sn_160 1046108.466401163
Csub_103_160 sn_103 sn_160 1.007207554535693e-17
Rsub_103_202 sn_103 sn_202 16940131.90492146
Csub_103_202 sn_103 sn_202 6.219835572336325e-19
Rsub_103_123 sn_103 sn_123 44342213.08362492
Csub_103_123 sn_103 sn_123 2.376174477886176e-19
Rsub_103_117 sn_103 sn_117 14611569.32098008
Csub_103_117 sn_103 sn_117 7.211055343043233e-19
Rsub_103_196 sn_103 sn_196 776645.0023757117
Csub_103_196 sn_103 sn_196 1.356666619884183e-17
Rsub_103_230 sn_103 0 336849.0166388801
Csub_103_230 sn_103 0 3.127954359898183e-17
Rsub_103_218 sn_103 sn_218 2948360.795415574
Csub_103_218 sn_103 sn_218 3.573675080272824e-18
Rsub_103_139 sn_103 sn_139 2661431.074729046
Csub_103_139 sn_103 sn_139 3.958954113926356e-18
Rsub_103_203 sn_103 sn_203 44286.48627715394
Csub_103_203 sn_103 sn_203 2.379164478367175e-16
Rsub_103_166 sn_103 sn_166 610721.693627678
Csub_103_166 sn_103 sn_166 1.72525122525834e-17
Rsub_103_125 sn_103 sn_125 22269760.46116192
Csub_103_125 sn_103 sn_125 4.73129628879729e-19
Rsub_103_221 sn_103 sn_221 239596.5754336347
Csub_103_221 sn_103 sn_221 4.397593531193219e-17
Rsub_103_142 sn_103 sn_142 77164.5805093869
Csub_103_142 sn_103 sn_142 1.365455942697474e-16
Rsub_103_200 sn_103 sn_200 2008157.459920394
Csub_103_200 sn_103 sn_200 5.246841302298914e-18
Rsub_103_226 sn_103 sn_226 299010.8495369596
Csub_103_226 sn_103 sn_226 3.523779661690044e-17
Rsub_103_192 sn_103 sn_192 56689.52767433325
Csub_103_192 sn_103 sn_192 1.858629615466086e-16
Rsub_103_154 sn_103 sn_154 19952814.61176465
Csub_103_154 sn_103 sn_154 5.280700345913825e-19
Rsub_103_222 sn_103 sn_222 196376.3102530239
Csub_103_222 sn_103 sn_222 5.36545548119023e-17
Rsub_103_213 sn_103 sn_213 550791.9638159432
Csub_103_213 sn_103 sn_213 1.912969722584942e-17
Rsub_103_134 sn_103 sn_134 23511929.42644929
Csub_103_134 sn_103 sn_134 4.48133511764338e-19
Rsub_103_182 sn_103 sn_182 3023900.523035851
Csub_103_182 sn_103 sn_182 3.484401494680082e-18
Rsub_103_148 sn_103 sn_148 677417.2091945716
Csub_103_148 sn_103 sn_148 1.555390586365168e-17
Rsub_103_227 sn_103 sn_227 1296833.213360995
Csub_103_227 sn_103 sn_227 8.124779188005726e-18
Rsub_103_133 sn_103 sn_133 23310544.44072675
Csub_103_133 sn_103 sn_133 4.520050369918133e-19
Rsub_103_212 sn_103 sn_212 633491.4040607981
Csub_103_212 sn_103 sn_212 1.663240169430741e-17
Rsub_103_138 sn_103 sn_138 1046354.231938858
Csub_103_138 sn_103 sn_138 1.006970983689364e-17
Rsub_103_158 sn_103 sn_158 11744307.41909394
Csub_103_158 sn_103 sn_158 8.971566501315986e-19
Rsub_103_169 sn_103 sn_169 23755070.79387867
Csub_103_169 sn_103 sn_169 4.435467102436544e-19
Rsub_103_211 sn_103 sn_211 618062.3118865561
Csub_103_211 sn_103 sn_211 1.704760717421636e-17
Rsub_103_132 sn_103 sn_132 2139890.099389568
Csub_103_132 sn_103 sn_132 4.92384328766962e-18
Rsub_103_224 sn_103 sn_224 5511504.525828686
Csub_103_224 sn_103 sn_224 1.911725455880993e-18
Rsub_103_198 sn_103 sn_198 1670837.226174331
Csub_103_198 sn_103 sn_198 6.306110096885436e-18
Rsub_103_223 sn_103 sn_223 5257818.952706012
Csub_103_223 sn_103 sn_223 2.003964685168029e-18
Rsub_103_144 sn_103 sn_144 356496.3274563332
Csub_103_144 sn_103 sn_144 2.955565791493492e-17
Rsub_103_215 sn_103 sn_215 1143707.634840608
Csub_103_215 sn_103 sn_215 9.212567251680899e-18
Rsub_103_214 sn_103 sn_214 3411283.246076602
Csub_103_214 sn_103 sn_214 3.088715519108025e-18
Rsub_103_135 sn_103 sn_135 6944608.756288803
Csub_103_135 sn_103 sn_135 1.51721772557576e-18
Rsub_103_188 sn_103 sn_188 5153477.756655933
Csub_103_188 sn_103 sn_188 2.044538465043667e-18
Rsub_176_207 sn_176 sn_207 3600861.10701873
Csub_176_207 sn_176 sn_207 2.926101060019363e-18
Rsub_176_184 sn_176 sn_184 16206747.12690937
Csub_176_184 sn_176 sn_184 6.501294442198972e-19
Rsub_176_194 sn_176 sn_194 1767328.341073162
Csub_176_194 sn_176 sn_194 5.961814371081722e-18
Rsub_176_220 sn_176 sn_220 4876475.409238487
Csub_176_220 sn_176 sn_220 2.160676024792132e-18
Rsub_176_190 sn_176 sn_190 1241706.665092106
Csub_176_190 sn_176 sn_190 8.485485178134588e-18
Rsub_176_225 sn_176 sn_225 18817792.46821271
Csub_176_225 sn_176 sn_225 5.599213361518566e-19
Rsub_176_219 sn_176 sn_219 276018.1449628181
Csub_176_219 sn_176 sn_219 3.817315525995349e-17
Rsub_176_210 sn_176 sn_210 8631.633380277177
Csub_176_210 sn_176 sn_210 1.220682463912949e-15
Rsub_176_192 sn_176 sn_192 7538343.854450217
Csub_176_192 sn_176 sn_192 1.397718611099154e-18
Rsub_176_226 sn_176 sn_226 1742233.722415189
Csub_176_226 sn_176 sn_226 6.047686579974869e-18
Rsub_176_195 sn_176 sn_195 452284.5762106383
Csub_176_195 sn_176 sn_195 2.329613711461817e-17
Rsub_176_185 sn_176 sn_185 9752950.818476975
Csub_176_185 sn_176 sn_185 1.080338012396066e-18
Rsub_176_222 sn_176 sn_222 227589.6087884285
Csub_176_222 sn_176 sn_222 4.62959779153402e-17
Rsub_176_217 sn_176 sn_217 846935.4324131634
Csub_176_217 sn_176 sn_217 1.244071637457477e-17
Rsub_176_180 sn_176 sn_180 9508.235073769694
Csub_176_180 sn_176 sn_180 1.108142932992573e-15
Rsub_176_214 sn_176 sn_214 2992197.879272795
Csub_176_214 sn_176 sn_214 3.52131908628674e-18
Rsub_176_177 sn_176 sn_177 558172.6468698649
Csub_176_177 sn_176 sn_177 1.887674639973271e-17
Rsub_176_198 sn_176 sn_198 2227466.391161793
Csub_176_198 sn_176 sn_198 4.730254761210751e-18
Rsub_176_230 sn_176 0 99383.03047725116
Csub_176_230 sn_176 0 1.060189395677747e-16
Rsub_176_181 sn_176 sn_181 41852.32028226176
Csub_176_181 sn_176 sn_181 2.517538676749463e-16
Rsub_176_218 sn_176 sn_218 1709212.521573077
Csub_176_218 sn_176 sn_218 6.164525106879469e-18
Rsub_176_228 sn_176 sn_228 41168.5819729818
Csub_176_228 sn_176 sn_228 2.559350601180508e-16
Rsub_176_191 sn_176 sn_191 1221329.717709891
Csub_176_191 sn_176 sn_191 8.627058974694328e-18
Rsub_176_208 sn_176 sn_208 8750895.584304798
Csub_176_208 sn_176 sn_208 1.204046305972128e-18
Rsub_180_209 sn_180 sn_209 270380.5688762261
Csub_180_209 sn_180 sn_209 3.896908548577452e-17
Rsub_180_201 sn_180 sn_201 26993300.17981941
Csub_180_201 sn_180 sn_201 3.903369885134398e-19
Rsub_180_197 sn_180 sn_197 37800540.98592248
Csub_180_197 sn_180 sn_197 2.787389605390557e-19
Rsub_180_203 sn_180 sn_203 9969235.505369598
Csub_180_203 sn_180 sn_203 1.056899849196548e-18
Rsub_180_220 sn_180 sn_220 18295190.43293102
Csub_180_220 sn_180 sn_220 5.759154866879394e-19
Rsub_180_226 sn_180 sn_226 1645197.356258895
Csub_180_226 sn_180 sn_226 6.404388787853084e-18
Rsub_180_206 sn_180 sn_206 3753044.772953134
Csub_180_206 sn_180 sn_206 2.807449454949941e-18
Rsub_180_213 sn_180 sn_213 2968983.679986671
Csub_180_213 sn_180 sn_213 3.5488519432607e-18
Rsub_180_190 sn_180 sn_190 3100744.178413973
Csub_180_190 sn_180 sn_190 3.398049918332637e-18
Rsub_180_208 sn_180 sn_208 2404811.387737359
Csub_180_208 sn_180 sn_208 4.38141783424586e-18
Rsub_180_224 sn_180 sn_224 4480895.024717475
Csub_180_224 sn_180 sn_224 2.351423866015325e-18
Rsub_180_219 sn_180 sn_219 2017449.169592462
Csub_180_219 sn_180 sn_219 5.222676070871436e-18
Rsub_180_221 sn_180 sn_221 19938471.0107392
Csub_180_221 sn_180 sn_221 5.28449924598274e-19
Rsub_180_184 sn_180 sn_184 6252495.483753262
Csub_180_184 sn_180 sn_184 1.685164512250897e-18
Rsub_180_198 sn_180 sn_198 5617755.351486336
Csub_180_198 sn_180 sn_198 1.875568237310704e-18
Rsub_180_212 sn_180 sn_212 3989140.236180519
Csub_180_212 sn_180 sn_212 2.641291826912148e-18
Rsub_180_229 sn_180 sn_229 3275186.293512695
Csub_180_229 sn_180 sn_229 3.217063873007797e-18
Rsub_180_192 sn_180 sn_192 1786181.782655664
Csub_180_192 sn_180 sn_192 5.898886442881835e-18
Rsub_180_216 sn_180 sn_216 1025753.556002336
Csub_180_216 sn_180 sn_216 1.027194440669919e-17
Rsub_180_215 sn_180 sn_215 2372998.005581276
Csub_180_215 sn_180 sn_215 4.44015691435402e-18
Rsub_180_181 sn_180 sn_181 10476.88648129136
Csub_180_181 sn_180 sn_181 1.00568842862286e-15
Rsub_180_230 sn_180 0 48894.21964635569
Csub_180_230 sn_180 0 2.154954834832983e-16
Rsub_180_185 sn_180 sn_185 835642.6154781573
Csub_180_185 sn_180 sn_185 1.26088393615505e-17
Rsub_180_222 sn_180 sn_222 354635.6216460151
Csub_180_222 sn_180 sn_222 2.9710730843466e-17
Rsub_180_188 sn_180 sn_188 54012991.76986454
Csub_180_188 sn_180 sn_188 1.950731325367653e-19
Rsub_180_186 sn_180 sn_186 22679687.09255132
Csub_180_186 sn_180 sn_186 4.645779925989586e-19
Rsub_180_210 sn_180 sn_210 174422.314006785
Csub_180_210 sn_180 sn_210 6.040788738658824e-17
Rsub_180_228 sn_180 sn_228 145320.0039759812
Csub_180_228 sn_180 sn_228 7.250538958126848e-17
Rsub_180_191 sn_180 sn_191 1569464.162887049
Csub_180_191 sn_180 sn_191 6.713427264785716e-18
Rsub_180_217 sn_180 sn_217 4525758.126314036
Csub_180_217 sn_180 sn_217 2.328114585038894e-18
Rsub_180_195 sn_180 sn_195 617983.2252083056
Csub_180_195 sn_180 sn_195 1.704978884933071e-17
Rsub_214_228 sn_214 sn_228 26175157.37421764
Csub_214_228 sn_214 sn_228 4.025375416695057e-19
Rsub_214_223 sn_214 sn_223 2485030.350961768
Csub_214_223 sn_214 sn_223 4.239981816782287e-18
Rsub_214_217 sn_214 sn_217 2371222.116837083
Csub_214_217 sn_214 sn_217 4.443482298606579e-18
Rsub_214_219 sn_214 sn_219 9910910.444122924
Csub_214_219 sn_214 sn_219 1.063119635843147e-18
Rsub_214_224 sn_214 sn_224 6022464.068560404
Csub_214_224 sn_214 sn_224 1.749530322187313e-18
Rsub_214_218 sn_214 sn_218 770302.9964970618
Csub_214_218 sn_214 sn_218 1.367836234591383e-17
Rsub_214_229 sn_214 sn_229 11528734.53982876
Csub_214_229 sn_214 sn_229 9.139323544860198e-19
Rsub_214_226 sn_214 sn_226 253633.8087792656
Csub_214_226 sn_214 sn_226 4.154210967749877e-17
Rsub_214_221 sn_214 sn_221 240026.6772416451
Csub_214_221 sn_214 sn_221 4.389713519894487e-17
Rsub_214_215 sn_214 sn_215 14578.57735250292
Csub_214_215 sn_214 sn_215 7.227374281771771e-16
Rsub_214_222 sn_214 sn_222 74137.15108972028
Csub_214_222 sn_214 sn_222 1.421215051746299e-16
Rsub_214_227 sn_214 sn_227 11781.15519127423
Csub_214_227 sn_214 sn_227 8.943506244645596e-16
Rsub_214_230 sn_214 0 28361.64186730558
Csub_214_230 sn_214 0 3.715047087727362e-16
Rsub_214_216 sn_214 sn_216 5506672.697226749
Csub_214_216 sn_214 sn_216 1.913402898911415e-18
Rsub_63_198 sn_63 sn_198 77934141.88739806
Csub_63_198 sn_63 sn_198 1.351972735832965e-19
Rsub_63_175 sn_63 sn_175 89051308.1133702
Csub_63_175 sn_63 sn_175 1.183192445507496e-19
Rsub_63_194 sn_63 sn_194 89051308.1133702
Csub_63_194 sn_63 sn_194 1.183192445507496e-19
Rsub_63_99 sn_63 sn_99 65744524.76882925
Csub_63_99 sn_63 sn_99 1.60264045398128e-19
Rsub_63_154 sn_63 sn_154 75213848.05617516
Csub_63_154 sn_63 sn_154 1.40087015550123e-19
Rsub_63_129 sn_63 sn_129 89292967.02276875
Csub_63_129 sn_63 sn_129 1.179990300864715e-19
Rsub_63_171 sn_63 sn_171 89292967.02276875
Csub_63_171 sn_63 sn_171 1.179990300864715e-19
Rsub_63_159 sn_63 sn_159 178585934.0455375
Csub_63_159 sn_63 sn_159 5.899951504323577e-20
Rsub_63_214 sn_63 sn_214 79243531.66532902
Csub_63_214 sn_63 sn_214 1.329633255964533e-19
Rsub_63_199 sn_63 sn_199 22070039.60468615
Csub_63_199 sn_63 sn_199 4.774111732900009e-19
Rsub_63_225 sn_63 sn_225 69288386.26234806
Csub_63_225 sn_63 sn_225 1.520670933558114e-19
Rsub_63_81 sn_63 sn_81 89292967.02276875
Csub_63_81 sn_63 sn_81 1.179990300864715e-19
Rsub_63_224 sn_63 sn_224 89292967.02276875
Csub_63_224 sn_63 sn_224 1.179990300864715e-19
Rsub_63_218 sn_63 sn_218 24374964.29581327
Csub_63_218 sn_63 sn_218 4.322666230136707e-19
Rsub_63_79 sn_63 sn_79 1589374735.138597
Rsub_63_215 sn_63 sn_215 16776001.68860746
Csub_63_215 sn_63 sn_215 6.280688150732188e-19
Rsub_63_212 sn_63 sn_212 4125063.585744504
Csub_63_212 sn_63 sn_212 2.554259657631034e-18
Rsub_63_77 sn_63 sn_77 7891870.665011006
Csub_63_77 sn_63 sn_77 1.335105952628445e-18
Rsub_63_156 sn_63 sn_156 180857527.793884
Csub_63_156 sn_63 sn_156 5.825847356620956e-20
Rsub_63_127 sn_63 sn_127 34922581.24530194
Csub_63_127 sn_63 sn_127 3.01709757025691e-19
Rsub_63_206 sn_63 sn_206 7835100.209538163
Csub_63_206 sn_63 sn_206 1.344779673577534e-18
Rsub_63_180 sn_63 sn_180 4427787.364961364
Csub_63_180 sn_63 sn_180 2.379627257083051e-18
Rsub_63_135 sn_63 sn_135 865930.3143164999
Csub_63_135 sn_63 sn_135 1.216781919749132e-17
Rsub_63_152 sn_63 sn_152 52693100.82696673
Csub_63_152 sn_63 sn_152 1.999594507984952e-19
Rsub_63_125 sn_63 sn_125 8051873.132410999
Csub_63_125 sn_63 sn_125 1.30857544933461e-18
Rsub_63_83 sn_63 sn_83 24217981.34507584
Csub_63_83 sn_63 sn_83 4.350686108845462e-19
Rsub_63_86 sn_63 sn_86 1023001.718791375
Csub_63_86 sn_63 sn_86 1.0299575561494e-17
Rsub_63_158 sn_63 sn_158 7379468.507533353
Csub_63_158 sn_63 sn_158 1.427810619623053e-18
Rsub_63_195 sn_63 sn_195 7516621.246604408
Csub_63_195 sn_63 sn_195 1.401757938380865e-18
Rsub_63_138 sn_63 sn_138 63941161.50661318
Csub_63_138 sn_63 sn_138 1.647840491784037e-19
Rsub_63_217 sn_63 sn_217 90162939.09660357
Csub_63_217 sn_63 sn_217 1.168604706967334e-19
Rsub_63_222 sn_63 sn_222 809397.0639924182
Csub_63_222 sn_63 sn_222 1.301769424546455e-17
Rsub_63_148 sn_63 sn_148 63283545.26285356
Csub_63_148 sn_63 sn_148 1.664964163822654e-19
Rsub_63_69 sn_63 sn_69 13476198.51896601
Csub_63_69 sn_63 sn_69 7.818587331880915e-19
Rsub_63_227 sn_63 sn_227 91347067.75265653
Csub_63_227 sn_63 sn_227 1.153456127432572e-19
Rsub_63_140 sn_63 sn_140 1976125.03398813
Csub_63_140 sn_63 sn_140 5.331891110637734e-18
Rsub_63_219 sn_63 sn_219 8217721.54940554
Csub_63_219 sn_63 sn_219 1.282166040657851e-18
Rsub_63_177 sn_63 sn_177 2915305.213094675
Csub_63_177 sn_63 sn_177 3.614195678347256e-18
Rsub_63_118 sn_63 sn_118 1733329.724577403
Csub_63_118 sn_63 sn_118 6.078753137865251e-18
Rsub_63_139 sn_63 sn_139 12391333.51623562
Csub_63_139 sn_63 sn_139 8.503107021068134e-19
Rsub_63_176 sn_63 sn_176 1843337.91165791
Csub_63_176 sn_63 sn_176 5.715980469773673e-18
Rsub_63_97 sn_63 sn_97 87214700.40194112
Csub_63_97 sn_63 sn_97 1.208108662148829e-19
Rsub_63_210 sn_63 sn_210 26094.28288661471
Csub_63_210 sn_63 sn_210 4.037851336253729e-16
Rsub_63_131 sn_63 sn_131 1441441.463949111
Csub_63_131 sn_63 sn_131 7.309685315533552e-18
Rsub_63_228 sn_63 sn_228 1400262.52207382
Csub_63_228 sn_63 sn_228 7.524648654186097e-18
Rsub_63_70 sn_63 sn_70 1904995.772112712
Csub_63_70 sn_63 sn_70 5.530974743605149e-18
Rsub_63_80 sn_63 sn_80 403111.820533209
Csub_63_80 sn_63 sn_80 2.613786787073883e-17
Rsub_63_216 sn_63 sn_216 8748588.633851789
Csub_63_216 sn_63 sn_216 1.204363805775498e-18
Rsub_63_137 sn_63 sn_137 179057479.0625672
Csub_63_137 sn_63 sn_137 5.884414076079051e-20
Rsub_63_126 sn_63 sn_126 175704.4437557284
Csub_63_126 sn_63 sn_126 5.996708607369233e-17
Rsub_63_168 sn_63 sn_168 609579.3357853675
Csub_63_168 sn_63 sn_168 1.728484363508656e-17
Rsub_63_191 sn_63 sn_191 295350546.2586333
Csub_63_191 sn_63 sn_191 3.567450148882876e-20
Rsub_63_230 sn_63 0 1118349.087899713
Csub_63_230 sn_63 0 9.421462060668171e-18
Rsub_63_151 sn_63 sn_151 16329564.96642524
Csub_63_151 sn_63 sn_151 6.452396940086139e-19
Rsub_63_72 sn_63 sn_72 89099639.89524992
Csub_63_72 sn_63 sn_72 1.182550626985387e-19
Rsub_63_82 sn_63 sn_82 59694.27347835262
Csub_63_82 sn_63 sn_82 1.765074418076455e-16
Rsub_63_150 sn_63 sn_150 286290.164721888
Csub_63_150 sn_63 sn_150 3.680351196299566e-17
Rsub_63_229 sn_63 sn_229 23420266.04229435
Csub_63_229 sn_63 sn_229 4.498874386483187e-19
Rsub_63_71 sn_63 sn_71 10013440.3363019
Csub_63_71 sn_63 sn_71 1.052234112189384e-18
Rsub_63_107 sn_63 sn_107 2408148.65600529
Csub_63_107 sn_63 sn_107 4.375345963777933e-18
Rsub_63_181 sn_63 sn_181 1983139.613134456
Csub_63_181 sn_63 sn_181 5.313031635516843e-18
Rsub_63_132 sn_63 sn_132 11176469.7462353
Csub_63_132 sn_63 sn_132 9.427380685908563e-19
Rsub_63_190 sn_63 sn_190 21177709.20551414
Csub_63_190 sn_63 sn_190 4.975270648955066e-19
Rsub_63_141 sn_63 sn_141 3977450.958334709
Csub_63_141 sn_63 sn_141 2.649054284415728e-18
Rsub_63_220 sn_63 sn_220 90162939.09660357
Csub_63_220 sn_63 sn_220 1.168604706967334e-19
Rsub_63_153 sn_63 sn_153 11004604.29953538
Csub_63_153 sn_63 sn_153 9.574613693901617e-19
Rsub_63_226 sn_63 sn_226 1094173.927316284
Csub_63_226 sn_63 sn_226 9.629623992296342e-18
Rsub_63_185 sn_63 sn_185 34512099.72307818
Csub_63_185 sn_63 sn_185 3.052982457391391e-19
Rsub_63_169 sn_63 sn_169 59570408.06194066
Csub_63_169 sn_63 sn_169 1.768744557075097e-19
Rsub_63_90 sn_63 sn_90 4112703.219885386
Csub_63_90 sn_63 sn_90 2.561936259170103e-18
Rsub_63_87 sn_63 sn_87 59975012.00890902
Csub_63_87 sn_63 sn_87 1.75681223718052e-19
Rsub_63_166 sn_63 sn_166 21610089.58932632
Csub_63_166 sn_63 sn_166 4.875724118901476e-19
Rsub_63_109 sn_63 sn_109 20026880.6726038
Csub_63_109 sn_63 sn_109 5.261170560946922e-19
Rsub_63_78 sn_63 sn_78 90162939.09660357
Csub_63_78 sn_63 sn_78 1.168604706967334e-19
Rsub_63_157 sn_63 sn_157 43067091.57098743
Csub_63_157 sn_63 sn_157 2.446527758871929e-19
Rsub_63_134 sn_63 sn_134 17823769.49501049
Csub_63_134 sn_63 sn_134 5.911478772870992e-19
Rsub_63_183 sn_63 sn_183 41210969.01015058
Csub_63_183 sn_63 sn_183 2.556718212482406e-19
Rsub_63_201 sn_63 sn_201 18546288.18721116
Csub_63_201 sn_63 sn_201 5.681181806230948e-19
Rsub_63_66 sn_63 sn_66 25276750.03233592
Csub_63_66 sn_63 sn_66 4.168448668737452e-19
Rsub_63_130 sn_63 sn_130 13424598.28337678
Csub_63_130 sn_63 sn_130 7.848639698423575e-19
Rsub_63_196 sn_63 sn_196 90428763.89694199
Csub_63_196 sn_63 sn_196 1.165169471324191e-19
Rsub_63_202 sn_63 sn_202 31404272.41974693
Csub_63_202 sn_63 sn_202 3.355111483367686e-19
Rsub_63_155 sn_63 sn_155 2444585.280734317
Csub_63_155 sn_63 sn_155 4.310131286998913e-18
Rsub_63_160 sn_63 sn_160 42948069.31505605
Csub_63_160 sn_63 sn_160 2.453307836712532e-19
Rsub_63_164 sn_63 sn_164 161042370.243894
Csub_63_164 sn_63 sn_164 6.54267785941849e-20
Rsub_63_170 sn_63 sn_170 10991025.02767057
Csub_63_170 sn_63 sn_170 9.586443007548219e-19
Rsub_63_128 sn_63 sn_128 27096412.67280948
Csub_63_128 sn_63 sn_128 3.888516029578733e-19
Rsub_207_213 sn_207 sn_213 17290694.96151975
Csub_207_213 sn_207 sn_213 6.093730486645465e-19
Rsub_207_217 sn_207 sn_217 2662555.068313658
Csub_207_217 sn_207 sn_217 3.957282847450488e-18
Rsub_207_211 sn_207 sn_211 6414792.171716022
Csub_207_211 sn_207 sn_211 1.642529207522461e-18
Rsub_207_229 sn_207 sn_229 4816645.816115282
Csub_207_229 sn_207 sn_229 2.187514694764889e-18
Rsub_207_216 sn_207 sn_216 1141316.177030319
Csub_207_216 sn_207 sn_216 9.231870812210609e-18
Rsub_207_230 sn_207 0 43006.61790359308
Csub_207_230 sn_207 0 2.449967938852896e-16
Rsub_207_224 sn_207 sn_224 40059.97591617479
Csub_207_224 sn_207 sn_224 2.630177193385617e-16
Rsub_207_222 sn_207 sn_222 170892.196022986
Csub_207_222 sn_207 sn_222 6.165573237067411e-17
Rsub_207_215 sn_207 sn_215 1079836.856748209
Csub_207_215 sn_207 sn_215 9.757477193322772e-18
Rsub_207_208 sn_207 sn_208 207943.4114925239
Csub_207_208 sn_207 sn_208 5.066995595870955e-17
Rsub_207_225 sn_207 sn_225 3125330.906822653
Csub_207_225 sn_207 sn_225 3.371317731261247e-18
Rsub_207_218 sn_207 sn_218 69253.15280662275
Csub_207_218 sn_207 sn_218 1.521444594970467e-16
Rsub_207_226 sn_207 sn_226 23414.1224658549
Csub_207_226 sn_207 sn_226 4.500054835535896e-16
Rsub_207_227 sn_207 sn_227 1137811.562920675
Csub_207_227 sn_207 sn_227 9.260306227846426e-18
Rsub_207_210 sn_207 sn_210 1597639.005483139
Csub_207_210 sn_207 sn_210 6.595033963284894e-18
Rsub_207_212 sn_207 sn_212 952962.9031170325
Csub_207_212 sn_207 sn_212 1.105655159058802e-17
Rsub_207_214 sn_207 sn_214 2724948.447313108
Csub_207_214 sn_207 sn_214 3.86667260168512e-18
Rsub_207_220 sn_207 sn_220 2642050.85851063
Csub_207_220 sn_207 sn_220 3.987994200902551e-18
Rsub_207_219 sn_207 sn_219 5912938.677070451
Csub_207_219 sn_207 sn_219 1.781936880740707e-18
Rsub_219_223 sn_219 sn_223 205823089.934378
Csub_219_223 sn_219 sn_223 5.119194112569837e-20
Rsub_219_221 sn_219 sn_221 1856223.873958142
Csub_219_221 sn_219 sn_221 5.676299960393461e-18
Rsub_219_225 sn_219 sn_225 6851882.495386336
Csub_219_225 sn_219 sn_225 1.537750174397279e-18
Rsub_219_228 sn_219 sn_228 610607.6331361299
Csub_219_228 sn_219 sn_228 1.725573499321287e-17
Rsub_219_220 sn_219 sn_220 4337257.766745598
Csub_219_220 sn_219 sn_220 2.429296128769378e-18
Rsub_219_222 sn_219 sn_222 66416.18747335133
Csub_219_222 sn_219 sn_222 1.58643305240272e-16
Rsub_219_226 sn_219 sn_226 259688.9089219954
Csub_219_226 sn_219 sn_226 4.057348288753802e-17
Rsub_219_230 sn_219 0 17573.27135531366
Csub_219_230 sn_219 0 5.995743927919299e-16
Rsub_219_227 sn_219 sn_227 539399.616063162
Csub_219_227 sn_219 sn_227 1.953372451232188e-17
Rsub_95_197 sn_95 sn_197 6093611.517679828
Csub_95_197 sn_95 sn_197 1.72910325373709e-18
Rsub_95_179 sn_95 sn_179 52340903.18663461
Csub_95_179 sn_95 sn_179 2.013049615261611e-19
Rsub_95_155 sn_95 sn_155 52340903.18663461
Csub_95_155 sn_95 sn_155 2.013049615261611e-19
Rsub_95_201 sn_95 sn_201 45600967.95501003
Csub_95_201 sn_95 sn_201 2.310583300035497e-19
Rsub_95_97 sn_95 sn_97 16487031.74072338
Csub_95_97 sn_95 sn_97 6.390770435775062e-19
Rsub_95_126 sn_95 sn_126 51955457.2261439
Csub_95_126 sn_95 sn_126 2.027983981811262e-19
Rsub_95_158 sn_95 sn_158 51955457.2261439
Csub_95_158 sn_95 sn_158 2.027983981811262e-19
Rsub_95_190 sn_95 sn_190 14758001.84501551
Csub_95_190 sn_95 sn_190 7.139505478371163e-19
Rsub_95_141 sn_95 sn_141 10710038.63045838
Csub_95_141 sn_95 sn_141 9.837950978314114e-19
Rsub_95_188 sn_95 sn_188 11240177.99775425
Csub_95_188 sn_95 sn_188 9.373947195796324e-19
Rsub_95_131 sn_95 sn_131 53377619.90795444
Csub_95_131 sn_95 sn_131 1.973951540064796e-19
Rsub_95_99 sn_95 sn_99 52340903.18663461
Csub_95_99 sn_95 sn_99 2.013049615261611e-19
Rsub_95_178 sn_95 sn_178 202976681.4195881
Csub_95_178 sn_95 sn_178 5.190982249063997e-20
Rsub_95_209 sn_95 sn_209 17704013.71838615
Csub_95_209 sn_95 sn_209 5.951465961239934e-19
Rsub_95_202 sn_95 sn_202 127512371.3823396
Csub_95_202 sn_95 sn_202 8.263106856225635e-20
Rsub_95_153 sn_95 sn_153 51623176.22572087
Csub_95_153 sn_95 sn_153 2.041037431745681e-19
Rsub_95_207 sn_95 sn_207 3251931.747095335
Csub_95_207 sn_95 sn_207 3.24006907944526e-18
Rsub_95_216 sn_95 sn_216 25811588.11286043
Csub_95_216 sn_95 sn_216 4.082074863491362e-19
Rsub_95_137 sn_95 sn_137 71627508.66466457
Csub_95_137 sn_95 sn_137 1.471010746940565e-19
Rsub_95_125 sn_95 sn_125 8897024.986578234
Csub_95_125 sn_95 sn_125 1.184270418271838e-18
Rsub_95_213 sn_95 sn_213 312913.0646593745
Csub_95_213 sn_95 sn_213 3.367223900893888e-17
Rsub_95_135 sn_95 sn_135 23622898.92602184
Csub_95_135 sn_95 sn_135 4.460283869150167e-19
Rsub_95_214 sn_95 sn_214 948567.0586680123
Csub_95_214 sn_95 sn_214 1.110778980352263e-17
Rsub_95_203 sn_95 sn_203 111087.9454831402
Csub_95_203 sn_95 sn_203 9.484812646777339e-17
Rsub_95_166 sn_95 sn_166 1801444.007912025
Csub_95_166 sn_95 sn_166 5.848909794561075e-18
Rsub_95_174 sn_95 sn_174 908869.6842474433
Csub_95_174 sn_95 sn_174 1.159295296657887e-17
Rsub_95_132 sn_95 sn_132 44727049.5016358
Csub_95_132 sn_95 sn_132 2.355729613205237e-19
Rsub_95_211 sn_95 sn_211 999141.6908315634
Csub_95_211 sn_95 sn_211 1.054553483146191e-17
Rsub_95_192 sn_95 sn_192 38956.21570462673
Csub_95_192 sn_95 sn_192 2.704698932288387e-16
Rsub_95_222 sn_95 sn_222 119627.9300100506
Csub_95_222 sn_95 sn_222 8.80771196270367e-17
Rsub_95_199 sn_95 sn_199 6955991.81627341
Csub_95_199 sn_95 sn_199 1.51473489051268e-18
Rsub_95_133 sn_95 sn_133 34407373.52980261
Csub_95_133 sn_95 sn_133 3.06227486184135e-19
Rsub_95_212 sn_95 sn_212 296015.0301888266
Csub_95_212 sn_95 sn_212 3.559442064650849e-17
Rsub_95_217 sn_95 sn_217 21639392.55118576
Csub_95_217 sn_95 sn_217 4.869121661944547e-19
Rsub_95_138 sn_95 sn_138 1087356.795860348
Csub_95_138 sn_95 sn_138 9.689996459619527e-18
Rsub_95_142 sn_95 sn_142 898784.8423249424
Csub_95_142 sn_95 sn_142 1.172303203842938e-17
Rsub_95_221 sn_95 sn_221 282646.0366999839
Csub_95_221 sn_95 sn_221 3.727801608417388e-17
Rsub_95_230 sn_95 0 332117.9968462085
Csub_95_230 sn_95 0 3.172512059654826e-17
Rsub_95_156 sn_95 sn_156 8634178.596672066
Csub_95_156 sn_95 sn_156 1.220322626438508e-18
Rsub_95_200 sn_95 sn_200 434491.3740696948
Csub_95_200 sn_95 sn_200 2.425015577073318e-17
Rsub_95_160 sn_95 sn_160 628862.6306329274
Csub_95_160 sn_95 sn_160 1.675482528135821e-17
Rsub_95_181 sn_95 sn_181 14714864.16933685
Csub_95_181 sn_95 sn_181 7.160435448793441e-19
Rsub_95_223 sn_95 sn_223 19957396.03375679
Csub_95_223 sn_95 sn_223 5.279488107771248e-19
Rsub_95_144 sn_95 sn_144 85391.09426167094
Csub_95_144 sn_95 sn_144 1.233908944876873e-16
Rsub_95_139 sn_95 sn_139 35204998.97801
Csub_95_139 sn_95 sn_139 2.992894136656949e-19
Rsub_95_218 sn_95 sn_218 6567028.04403075
Csub_95_218 sn_95 sn_218 1.604452338498444e-18
Rsub_95_170 sn_95 sn_170 2395019.363635927
Csub_95_170 sn_95 sn_170 4.399331238071643e-18
Rsub_95_117 sn_95 sn_117 38752438.19566692
Csub_95_117 sn_95 sn_117 2.718921438963324e-19
Rsub_95_196 sn_95 sn_196 960631.1287282393
Csub_95_196 sn_95 sn_196 1.096829280993532e-17
Rsub_95_103 sn_95 sn_103 26461.41432538378
Csub_95_103 sn_95 sn_103 3.981829305368087e-16
Rsub_95_182 sn_95 sn_182 1645816.788622986
Csub_95_182 sn_95 sn_182 6.40197838244536e-18
Rsub_95_226 sn_95 sn_226 897090.7533986054
Csub_95_226 sn_95 sn_226 1.174517010939284e-17
Rsub_95_107 sn_95 sn_107 51955457.2261439
Csub_95_107 sn_95 sn_107 2.027983981811262e-19
Rsub_95_186 sn_95 sn_186 23354405.68244942
Csub_95_186 sn_95 sn_186 4.511561392524776e-19
Rsub_95_195 sn_95 sn_195 25631770.40490727
Csub_95_195 sn_95 sn_195 4.110712344790963e-19
Rsub_95_148 sn_95 sn_148 438092.2993308526
Csub_95_148 sn_95 sn_148 2.405083019793672e-17
Rsub_140_214 sn_140 sn_214 2294680.032657166
Csub_140_214 sn_140 sn_214 4.591700521326753e-18
Rsub_140_178 sn_140 sn_178 6233574.796806876
Csub_140_178 sn_140 sn_178 1.690279469755825e-18
Rsub_140_166 sn_140 sn_166 19050455.16087358
Csub_140_166 sn_140 sn_166 5.530830320458778e-19
Rsub_140_182 sn_140 sn_182 7131011.453993654
Csub_140_182 sn_140 sn_182 1.477558067352303e-18
Rsub_140_218 sn_140 sn_218 2849097.076687923
Csub_140_218 sn_140 sn_218 3.69818339587034e-18
Rsub_140_186 sn_140 sn_186 14652168.09836955
Csub_140_186 sn_140 sn_186 7.1910746802055e-19
Rsub_140_207 sn_140 sn_207 10737710.87427612
Csub_140_207 sn_140 sn_207 9.812597513192325e-19
Rsub_140_221 sn_140 sn_221 4039133.863355095
Csub_140_221 sn_140 sn_221 2.608599729219646e-18
Rsub_140_224 sn_140 sn_224 1265266.406354885
Csub_140_224 sn_140 sn_224 8.327482219799568e-18
Rsub_140_198 sn_140 sn_198 4810433.820027851
Csub_140_198 sn_140 sn_198 2.190339561135257e-18
Rsub_140_185 sn_140 sn_185 140993.4610418841
Csub_140_185 sn_140 sn_185 7.473029901081718e-17
Rsub_140_201 sn_140 sn_201 26727475.37948099
Csub_140_201 sn_140 sn_201 3.942191827934107e-19
Rsub_140_144 sn_140 sn_144 20275474.41377424
Csub_140_144 sn_140 sn_144 5.19666434787439e-19
Rsub_140_192 sn_140 sn_192 3125779.115074552
Csub_140_192 sn_140 sn_192 3.370834315008436e-18
Rsub_140_153 sn_140 sn_153 1771021.18757152
Csub_140_153 sn_140 sn_153 5.949383088227172e-18
Rsub_140_160 sn_140 sn_160 2146734.162032676
Csub_140_160 sn_140 sn_160 4.90814544650155e-18
Rsub_140_206 sn_140 sn_206 11682115.73772209
Csub_140_206 sn_140 sn_206 9.019328124106161e-19
Rsub_140_152 sn_140 sn_152 505441.0834939996
Csub_140_152 sn_140 sn_152 2.084611608813767e-17
Rsub_140_195 sn_140 sn_195 419059.3154501891
Csub_140_195 sn_140 sn_195 2.514317929172107e-17
Rsub_140_157 sn_140 sn_157 2522482.558903601
Csub_140_157 sn_140 sn_157 4.177029278176534e-18
Rsub_140_227 sn_140 sn_227 457875.2782749321
Csub_140_227 sn_140 sn_227 2.301168899514891e-17
Rsub_140_203 sn_140 sn_203 4560688.132307961
Csub_140_203 sn_140 sn_203 2.310283710826321e-18
Rsub_140_216 sn_140 sn_216 126357.3382645892
Csub_140_216 sn_140 sn_216 8.33863996103405e-17
Rsub_140_179 sn_140 sn_179 927254.225051025
Csub_140_179 sn_140 sn_179 1.136310109738265e-17
Rsub_140_177 sn_140 sn_177 412969.4260192452
Csub_140_177 sn_140 sn_177 2.551395536418955e-17
Rsub_140_168 sn_140 sn_168 767658.0215948996
Csub_140_168 sn_140 sn_168 1.372549130710472e-17
Rsub_140_210 sn_140 sn_210 81517.8426656824
Csub_140_210 sn_140 sn_210 1.292537088529414e-16
Rsub_140_228 sn_140 sn_228 1465064.817723244
Csub_140_228 sn_140 sn_228 7.191820713164095e-18
Rsub_140_154 sn_140 sn_154 5022114.35382632
Csub_140_154 sn_140 sn_154 2.098017440443649e-18
Rsub_140_191 sn_140 sn_191 1505438.251348274
Csub_140_191 sn_140 sn_191 6.998947643846236e-18
Rsub_140_146 sn_140 sn_146 23738039.46943664
Csub_140_146 sn_140 sn_146 4.438649415759884e-19
Rsub_140_141 sn_140 sn_141 240335.3808654002
Csub_140_141 sn_140 sn_141 4.384075063892052e-17
Rsub_140_215 sn_140 sn_215 19149209.06126687
Csub_140_215 sn_140 sn_215 5.502307415684422e-19
Rsub_140_158 sn_140 sn_158 23184.62569181663
Csub_140_158 sn_140 sn_158 4.544599357473784e-16
Rsub_140_181 sn_140 sn_181 307882.0449097001
Csub_140_181 sn_140 sn_181 3.422246823558771e-17
Rsub_140_164 sn_140 sn_164 7685151.813034679
Csub_140_164 sn_140 sn_164 1.371018264643675e-18
Rsub_140_155 sn_140 sn_155 28371.0756070759
Csub_140_155 sn_140 sn_155 3.713811787806221e-16
Rsub_140_190 sn_140 sn_190 50900.75555572528
Csub_140_190 sn_140 sn_190 2.070005324517205e-16
Rsub_140_162 sn_140 sn_162 5842960.397994106
Csub_140_162 sn_140 sn_162 1.803278267271362e-18
Rsub_140_184 sn_140 sn_184 23097504.18251522
Csub_140_184 sn_140 sn_184 4.56174113833741e-19
Rsub_140_229 sn_140 sn_229 4068666.153404931
Csub_140_229 sn_140 sn_229 2.589665287089817e-18
Rsub_140_150 sn_140 sn_150 633536.8169877288
Csub_140_150 sn_140 sn_150 1.66312094572936e-17
Rsub_140_222 sn_140 sn_222 148181.3984323221
Csub_140_222 sn_140 sn_222 7.110530480681258e-17
Rsub_140_188 sn_140 sn_188 44368575.76557603
Csub_140_188 sn_140 sn_188 2.374762615302355e-19
Rsub_140_151 sn_140 sn_151 2086579.76364033
Csub_140_151 sn_140 sn_151 5.049643289862849e-18
Rsub_140_230 sn_140 0 70046.50665345414
Csub_140_230 sn_140 0 1.504212559001388e-16
Rsub_140_219 sn_140 sn_219 916307.5832922328
Csub_140_219 sn_140 sn_219 1.14988500524825e-17
Rsub_140_176 sn_140 sn_176 312801.0779661767
Csub_140_176 sn_140 sn_176 3.368429409111344e-17
Rsub_140_180 sn_140 sn_180 502491.3818713661
Csub_140_180 sn_140 sn_180 2.096848599271551e-17
Rsub_140_208 sn_140 sn_208 800899.8177520646
Csub_140_208 sn_140 sn_208 1.315580709183254e-17
Rsub_140_171 sn_140 sn_171 47313340.63103003
Csub_140_171 sn_140 sn_171 2.226958266252657e-19
Rsub_140_189 sn_140 sn_189 3814929.697022843
Csub_140_189 sn_140 sn_189 2.761907646804772e-18
Rsub_140_226 sn_140 sn_226 987534.4907107927
Csub_140_226 sn_140 sn_226 1.066948405482649e-17
Rsub_140_212 sn_140 sn_212 1820241.784709888
Csub_140_212 sn_140 sn_212 5.788507653618837e-18
Rsub_140_169 sn_140 sn_169 1100364.765252835
Csub_140_169 sn_140 sn_169 9.575446102010535e-18
Rsub_140_159 sn_140 sn_159 9424697.474046959
Csub_140_159 sn_140 sn_159 1.117965168775401e-18
Rsub_140_165 sn_140 sn_165 177448.0547405918
Csub_140_165 sn_140 sn_165 5.937784732344968e-17
Rsub_201_211 sn_201 sn_211 26763425.66875044
Csub_201_211 sn_201 sn_211 3.936896431958869e-19
Rsub_201_205 sn_201 sn_205 4153300.069282529
Csub_201_205 sn_201 sn_205 2.536894355444477e-18
Rsub_201_224 sn_201 sn_224 26554877.3020125
Csub_201_224 sn_201 sn_224 3.967814794396162e-19
Rsub_201_230 sn_201 0 285524.6714601506
Csub_201_230 sn_201 0 3.690218238706749e-17
Rsub_201_213 sn_201 sn_213 7857614.564281575
Csub_201_213 sn_201 sn_213 1.340926488062393e-18
Rsub_201_204 sn_201 sn_204 562156.3157515477
Csub_201_204 sn_201 sn_204 1.874297807744766e-17
Rsub_201_221 sn_201 sn_221 4221518.47698881
Csub_201_221 sn_201 sn_221 2.495898942445379e-18
Rsub_201_218 sn_201 sn_218 4264482.575825831
Csub_201_218 sn_201 sn_218 2.470753090177553e-18
Rsub_201_206 sn_201 sn_206 227450.0751769806
Csub_201_206 sn_201 sn_206 4.632437907101805e-17
Rsub_201_222 sn_201 sn_222 473452.5760011539
Csub_201_222 sn_201 sn_222 2.225457001675352e-17
Rsub_201_227 sn_201 sn_227 3216613.338331508
Csub_201_227 sn_201 sn_227 3.275645032205018e-18
Rsub_201_229 sn_201 sn_229 14571698.31698118
Csub_201_229 sn_201 sn_229 7.230786194599757e-19
Rsub_201_212 sn_201 sn_212 2372112.730962686
Csub_201_212 sn_201 sn_212 4.441813984933984e-18
Rsub_201_215 sn_201 sn_215 342629.5338342746
Csub_201_215 sn_201 sn_215 3.075182511069334e-17
Rsub_201_219 sn_201 sn_219 2720658.899724321
Csub_201_219 sn_201 sn_219 3.87276902051104e-18
Rsub_201_214 sn_201 sn_214 1385904.451714751
Csub_201_214 sn_201 sn_214 7.602604558484118e-18
Rsub_201_207 sn_201 sn_207 7663773.45432421
Csub_201_207 sn_201 sn_207 1.374842767081651e-18
Rsub_201_226 sn_201 sn_226 15925483.57400738
Csub_201_226 sn_201 sn_226 6.616115267876083e-19
Rsub_186_219 sn_186 sn_219 2788463.206607579
Csub_186_219 sn_186 sn_219 3.778598719632596e-18
Rsub_186_200 sn_186 sn_200 4834648.936744024
Csub_186_200 sn_186 sn_200 2.179368893189166e-18
Rsub_186_217 sn_186 sn_217 11924789.86052575
Csub_186_217 sn_186 sn_217 8.835781280396884e-19
Rsub_186_198 sn_186 sn_198 45212960.3556627
Csub_186_198 sn_186 sn_198 2.330412213521506e-19
Rsub_186_191 sn_186 sn_191 30442891.77580395
Csub_186_191 sn_186 sn_191 3.461065256160852e-19
Rsub_186_228 sn_186 sn_228 52053329.0844503
Csub_186_228 sn_186 sn_228 2.024170920007021e-19
Rsub_186_221 sn_186 sn_221 1665399.648697221
Csub_186_221 sn_186 sn_221 6.326699726682596e-18
Rsub_186_211 sn_186 sn_211 4763274.683918597
Csub_186_211 sn_186 sn_211 2.212025172052846e-18
Rsub_186_194 sn_186 sn_194 9476914.823396439
Csub_186_194 sn_186 sn_194 1.111805233937285e-18
Rsub_186_195 sn_186 sn_195 10353362.47072088
Csub_186_195 sn_186 sn_195 1.017687107162236e-18
Rsub_186_197 sn_186 sn_197 331514.3140265313
Csub_186_197 sn_186 sn_197 3.178289158695802e-17
Rsub_186_207 sn_186 sn_207 417927.9251032488
Csub_186_207 sn_186 sn_207 2.521124545488787e-17
Rsub_186_224 sn_186 sn_224 307462.67883454
Csub_186_224 sn_186 sn_224 3.426914623319267e-17
Rsub_186_208 sn_186 sn_208 549933.5400192417
Csub_186_208 sn_186 sn_208 1.915955790196273e-17
Rsub_186_192 sn_186 sn_192 3001147.825751454
Csub_186_192 sn_186 sn_192 3.510817898345873e-18
Rsub_186_226 sn_186 sn_226 316916.9920478111
Csub_186_226 sn_186 sn_226 3.324682414201519e-17
Rsub_186_213 sn_186 sn_213 7493706.413830454
Csub_186_213 sn_186 sn_213 1.406044341793771e-18
Rsub_186_230 sn_186 0 136055.2908764858
Csub_186_230 sn_186 0 7.744265904216303e-17
Rsub_186_218 sn_186 sn_218 281835.2679191604
Csub_186_218 sn_186 sn_218 3.738525550766845e-17
Rsub_186_222 sn_186 sn_222 1002913.815854848
Csub_186_222 sn_186 sn_222 1.05058713277861e-17
Rsub_186_216 sn_186 sn_216 1780176.996534972
Csub_186_216 sn_186 sn_216 5.918784212322006e-18
Rsub_186_190 sn_186 sn_190 609790.9097823248
Csub_186_190 sn_186 sn_190 1.727884645901196e-17
Rsub_186_227 sn_186 sn_227 3786495.564638458
Csub_186_227 sn_186 sn_227 2.782647786684004e-18
Rsub_9_158 sn_9 sn_158 72433065.96537496
Csub_9_158 sn_9 sn_158 1.454651043939896e-19
Rsub_9_66 sn_9 sn_66 112081402.1790532
Csub_9_66 sn_9 sn_66 9.400742047639335e-20
Rsub_9_145 sn_9 sn_145 112081402.1790532
Csub_9_145 sn_9 sn_145 9.400742047639335e-20
Rsub_9_21 sn_9 sn_21 78974131.59145015
Csub_9_21 sn_9 sn_21 1.334168960127027e-19
Rsub_9_186 sn_9 sn_186 9026177.546576187
Csub_9_186 sn_9 sn_186 1.167325088373284e-18
Rsub_9_30 sn_9 sn_30 79006496.38396673
Csub_9_30 sn_9 sn_30 1.333622421506117e-19
Rsub_9_197 sn_9 sn_197 4415337.904610973
Csub_9_197 sn_9 sn_197 2.386336839866019e-18
Rsub_9_118 sn_9 sn_118 115537124.5834526
Csub_9_118 sn_9 sn_118 9.119565282775828e-20
Rsub_9_120 sn_9 sn_120 1263554.251059317
Csub_9_120 sn_9 sn_120 8.338766217118582e-18
Rsub_9_166 sn_9 sn_166 33182193.32568555
Csub_9_166 sn_9 sn_166 3.175342690223542e-19
Rsub_9_116 sn_9 sn_116 16845169.20201739
Csub_9_116 sn_9 sn_116 6.254899179622455e-19
Rsub_9_37 sn_9 sn_37 115537124.5834526
Csub_9_37 sn_9 sn_37 9.119565282775828e-20
Rsub_9_207 sn_9 sn_207 6798664.13536118
Csub_9_207 sn_9 sn_207 1.549787324752181e-18
Rsub_9_128 sn_9 sn_128 18222701.0692832
Csub_9_128 sn_9 sn_128 5.782064613895606e-19
Rsub_9_170 sn_9 sn_170 13500550.77058583
Csub_9_170 sn_9 sn_170 7.804484188294187e-19
Rsub_9_74 sn_9 sn_74 15194207.83521176
Csub_9_74 sn_9 sn_74 6.93453954066119e-19
Rsub_9_164 sn_9 sn_164 50950222.13802361
Csub_9_164 sn_9 sn_164 2.067995596503344e-19
Rsub_9_191 sn_9 sn_191 33284150.74181935
Csub_9_191 sn_9 sn_191 3.165615846400912e-19
Rsub_9_183 sn_9 sn_183 172363899.154079
Csub_9_183 sn_9 sn_183 6.112929420801311e-20
Rsub_9_184 sn_9 sn_184 10816602.29377628
Csub_9_184 sn_9 sn_184 9.741028851816563e-19
Rsub_9_141 sn_9 sn_141 11226923.268633
Csub_9_141 sn_9 sn_141 9.385014264476158e-19
Rsub_9_68 sn_9 sn_68 40662530.11066353
Csub_9_68 sn_9 sn_68 2.591202139550796e-19
Rsub_9_52 sn_9 sn_52 1167107.431883939
Csub_9_52 sn_9 sn_52 9.027860858723227e-18
Rsub_9_56 sn_9 sn_56 41894308.84411897
Csub_9_56 sn_9 sn_56 2.515015474162451e-19
Rsub_9_93 sn_9 sn_93 348611.9857928534
Csub_9_93 sn_9 sn_93 3.022409994959503e-17
Rsub_9_171 sn_9 sn_171 26763226.79330018
Csub_9_171 sn_9 sn_171 3.936925686729102e-19
Rsub_9_41 sn_9 sn_41 22847465.70031226
Csub_9_41 sn_9 sn_41 4.611663998290189e-19
Rsub_9_208 sn_9 sn_208 73841.78908517917
Csub_9_208 sn_9 sn_208 1.426899812797843e-16
Rsub_9_117 sn_9 sn_117 42279788.32580566
Csub_9_117 sn_9 sn_117 2.492085206538041e-19
Rsub_9_151 sn_9 sn_151 86181949.57703952
Csub_9_151 sn_9 sn_151 1.222585884160262e-19
Rsub_9_230 sn_9 0 1286217.828102558
Csub_9_230 sn_9 0 8.191834440495612e-18
Rsub_9_224 sn_9 sn_224 472441.316467196
Csub_9_224 sn_9 sn_224 2.230220587187278e-17
Rsub_9_57 sn_9 sn_57 18732072.08587211
Csub_9_57 sn_9 sn_57 5.624836085366502e-19
Rsub_9_136 sn_9 sn_136 115537124.5834526
Csub_9_136 sn_9 sn_136 9.119565282775828e-20
Rsub_9_44 sn_9 sn_44 2824741.420595225
Csub_9_44 sn_9 sn_44 3.730070096118663e-18
Rsub_9_142 sn_9 sn_142 112661383.5616097
Csub_9_142 sn_9 sn_142 9.352346979183018e-20
Rsub_9_216 sn_9 sn_216 4077124.606594475
Csub_9_216 sn_9 sn_216 2.584292735421416e-18
Rsub_9_137 sn_9 sn_137 28379203.70172807
Csub_9_137 sn_9 sn_137 3.712748114066503e-19
Rsub_9_179 sn_9 sn_179 106852703.0025509
Csub_9_179 sn_9 sn_179 9.860755232348654e-20
Rsub_9_146 sn_9 sn_146 6483219.155468472
Csub_9_146 sn_9 sn_146 1.625193171719743e-18
Rsub_9_35 sn_9 sn_35 14301935.90258633
Csub_9_35 sn_9 sn_35 7.367172929592425e-19
Rsub_9_47 sn_9 sn_47 108674957.7515004
Csub_9_47 sn_9 sn_47 9.695410718560444e-20
Rsub_9_84 sn_9 sn_84 41557.97737417823
Csub_9_84 sn_9 sn_84 2.535369661367777e-16
Rsub_9_125 sn_9 sn_125 112661383.5616097
Csub_9_125 sn_9 sn_125 9.352346979183018e-20
Rsub_9_53 sn_9 sn_53 57040567.06640434
Csub_9_53 sn_9 sn_53 1.847191226195885e-19
Rsub_9_132 sn_9 sn_132 13666537.28662805
Csub_9_132 sn_9 sn_132 7.70969506119108e-19
Rsub_9_62 sn_9 sn_62 115537124.5834526
Csub_9_62 sn_9 sn_62 9.119565282775828e-20
Rsub_9_96 sn_9 sn_96 93182812.15954661
Csub_9_96 sn_9 sn_96 1.130732509359081e-19
Rsub_9_29 sn_9 sn_29 15525352.04113726
Csub_9_29 sn_9 sn_29 6.786630972561308e-19
Rsub_9_160 sn_9 sn_160 156735289.5897265
Csub_9_160 sn_9 sn_160 6.722470433946633e-20
Rsub_9_177 sn_9 sn_177 53936045.13746616
Csub_9_177 sn_9 sn_177 1.953514291857289e-19
Rsub_9_10 sn_9 sn_10 19746323.22479154
Csub_9_10 sn_9 sn_10 5.335921721873482e-19
Rsub_9_217 sn_9 sn_217 31862559.60293576
Csub_9_217 sn_9 sn_217 3.306854073725824e-19
Rsub_9_138 sn_9 sn_138 31365917.86277192
Csub_9_138 sn_9 sn_138 3.359214147128693e-19
Rsub_9_226 sn_9 sn_226 1137872.601750216
Csub_9_226 sn_9 sn_226 9.259809477812666e-18
Rsub_9_59 sn_9 sn_59 6824614.808981102
Csub_9_59 sn_9 sn_59 1.543894241234557e-18
Rsub_9_190 sn_9 sn_190 4075461.884233556
Csub_9_190 sn_9 sn_190 2.585347084950477e-18
Rsub_9_206 sn_9 sn_206 35403389.92836784
Csub_9_206 sn_9 sn_206 2.976122773426108e-19
Rsub_9_185 sn_9 sn_185 44372444.71778165
Csub_9_185 sn_9 sn_185 2.374555553394526e-19
Rsub_9_27 sn_9 sn_27 57333923.53686952
Csub_9_27 sn_9 sn_27 1.837739832239868e-19
Rsub_9_222 sn_9 sn_222 1409491.489011014
Csub_9_222 sn_9 sn_222 7.475379301242211e-18
Rsub_9_64 sn_9 sn_64 30838560.4932147
Csub_9_64 sn_9 sn_64 3.416658668146429e-19
Rsub_9_42 sn_9 sn_42 242843086.9787776
Csub_9_42 sn_9 sn_42 4.338803147874167e-20
Rsub_9_203 sn_9 sn_203 41290845.99921913
Csub_9_203 sn_9 sn_203 2.551772250544167e-19
Rsub_9_36 sn_9 sn_36 17387597.08496562
Csub_9_36 sn_9 sn_36 6.059769760446364e-19
Rsub_9_218 sn_9 sn_218 17273653.45655165
Csub_9_218 sn_9 sn_218 6.099742320715402e-19
Rsub_9_162 sn_9 sn_162 28454513.4450167
Csub_9_162 sn_9 sn_162 3.702921690293488e-19
Rsub_9_83 sn_9 sn_83 231074249.1669053
Csub_9_83 sn_9 sn_83 4.559782641387914e-20
Rsub_9_45 sn_9 sn_45 2520031.667434883
Csub_9_45 sn_9 sn_45 4.181091705468524e-18
Rsub_9_212 sn_9 sn_212 16869823.51465333
Csub_9_212 sn_9 sn_212 6.245757990934455e-19
Rsub_9_155 sn_9 sn_155 187344091.4687774
Csub_9_155 sn_9 sn_155 5.624134404039105e-20
Rsub_9_144 sn_9 sn_144 19374241.46833152
Csub_9_144 sn_9 sn_144 5.438397946806115e-19
Rsub_88_179 sn_88 sn_179 17218665.44021937
Csub_88_179 sn_88 sn_179 6.119221921589161e-19
Rsub_88_118 sn_88 sn_118 11301717.17601493
Csub_88_118 sn_88 sn_118 9.322904951639613e-19
Rsub_88_110 sn_88 sn_110 33433215.8059251
Csub_88_110 sn_88 sn_110 3.15150165733166e-19
Rsub_88_207 sn_88 sn_207 43635775.19101059
Csub_88_207 sn_88 sn_207 2.41464336455758e-19
Rsub_88_199 sn_88 sn_199 19743164.98305098
Csub_88_199 sn_88 sn_199 5.336775289714346e-19
Rsub_88_169 sn_88 sn_169 23537577.77541997
Csub_88_169 sn_88 sn_169 4.476451911391297e-19
Rsub_88_131 sn_88 sn_131 14837108.57966955
Csub_88_131 sn_88 sn_131 7.10143991037954e-19
Rsub_88_184 sn_88 sn_184 9773256.248690929
Csub_88_184 sn_88 sn_184 1.078093445430872e-18
Rsub_88_101 sn_88 sn_101 12858883.74618065
Csub_88_101 sn_88 sn_101 8.193933245068456e-19
Rsub_88_145 sn_88 sn_145 22135956.10090831
Csub_88_145 sn_88 sn_145 4.759895373029611e-19
Rsub_88_162 sn_88 sn_162 22135956.10090831
Csub_88_162 sn_88 sn_162 4.759895373029611e-19
Rsub_88_166 sn_88 sn_166 2979182.455449974
Csub_88_166 sn_88 sn_166 3.536702991438158e-18
Rsub_88_219 sn_88 sn_219 21122091.40164064
Csub_88_219 sn_88 sn_219 4.988371322648281e-19
Rsub_88_155 sn_88 sn_155 2936555.881887482
Csub_88_155 sn_88 sn_155 3.588041204057604e-18
Rsub_88_195 sn_88 sn_195 11043481.663194
Csub_88_195 sn_88 sn_195 9.540907318519179e-19
Rsub_88_186 sn_88 sn_186 45212960.3556627
Csub_88_186 sn_88 sn_186 2.330412213521506e-19
Rsub_88_141 sn_88 sn_141 15173421.82782028
Csub_88_141 sn_88 sn_141 6.944039137507854e-19
Rsub_88_204 sn_88 sn_204 21531808.8274119
Csub_88_204 sn_88 sn_204 4.893450237592731e-19
Rsub_88_208 sn_88 sn_208 9819802.582397217
Csub_88_208 sn_88 sn_208 1.072983230957972e-18
Rsub_88_226 sn_88 sn_226 1365280.998202999
Csub_88_226 sn_88 sn_226 7.717446823106934e-18
Rsub_88_213 sn_88 sn_213 115909.6836266958
Csub_88_213 sn_88 sn_213 9.090253007819692e-17
Rsub_88_222 sn_88 sn_222 206966.889365204
Csub_88_222 sn_88 sn_222 5.090902962568964e-17
Rsub_88_137 sn_88 sn_137 20831620.13956345
Csub_88_137 sn_88 sn_137 5.057928011186748e-19
Rsub_88_160 sn_88 sn_160 1223188.712757044
Csub_88_160 sn_88 sn_160 8.613947620952917e-18
Rsub_88_203 sn_88 sn_203 268135.2844847068
Csub_88_203 sn_88 sn_203 3.929540091106866e-17
Rsub_88_144 sn_88 sn_144 426287.4441621985
Csub_88_144 sn_88 sn_144 2.471685161390999e-17
Rsub_88_139 sn_88 sn_139 16578648.35583976
Csub_88_139 sn_88 sn_139 6.355453880242635e-19
Rsub_88_218 sn_88 sn_218 377520.6040075583
Csub_88_218 sn_88 sn_218 2.790969126023927e-17
Rsub_88_133 sn_88 sn_133 3459146.401897193
Csub_88_133 sn_88 sn_133 3.045977902655751e-18
Rsub_88_212 sn_88 sn_212 428260.3050690891
Csub_88_212 sn_88 sn_212 2.460298883066037e-17
Rsub_88_138 sn_88 sn_138 922821.4357741704
Csub_88_138 sn_88 sn_138 1.141768395680012e-17
Rsub_88_174 sn_88 sn_174 35235.5189455826
Csub_88_174 sn_88 sn_174 2.990301780002856e-16
Rsub_88_95 sn_88 sn_95 418678.2045047696
Csub_88_95 sn_88 sn_95 2.516606641774678e-17
Rsub_88_211 sn_88 sn_211 54639.21196237933
Csub_88_211 sn_88 sn_211 1.9283739870708e-16
Rsub_88_132 sn_88 sn_132 21918463.0824496
Csub_88_132 sn_88 sn_132 4.807126969895395e-19
Rsub_88_200 sn_88 sn_200 56504.47642134317
Csub_88_200 sn_88 sn_200 1.864716597612805e-16
Rsub_88_163 sn_88 sn_163 3498258.465894929
Csub_88_163 sn_88 sn_163 3.011922533726948e-18
Rsub_88_230 sn_88 0 220056.1905704792
Csub_88_230 sn_88 0 4.788087749276654e-17
Rsub_88_148 sn_88 sn_148 307120.4498704053
Csub_88_148 sn_88 sn_148 3.430733286134495e-17
Rsub_88_227 sn_88 sn_227 197011.1021730384
Csub_88_227 sn_88 sn_227 5.348167380422865e-17
Rsub_88_198 sn_88 sn_198 2299061.413929188
Csub_88_198 sn_88 sn_198 4.582949997939694e-18
Rsub_88_196 sn_88 sn_196 716055.9781001877
Csub_88_196 sn_88 sn_196 1.471460866814491e-17
Rsub_88_192 sn_88 sn_192 1631147.491363406
Csub_88_192 sn_88 sn_192 6.459552896361941e-18
Rsub_88_221 sn_88 sn_221 687816.913131945
Csub_88_221 sn_88 sn_221 1.531873279220857e-17
Rsub_88_142 sn_88 sn_142 985276.5800025507
Csub_88_142 sn_88 sn_142 1.069393479565172e-17
Rsub_88_177 sn_88 sn_177 11509455.65933442
Csub_88_177 sn_88 sn_177 9.154632342394648e-19
Rsub_88_214 sn_88 sn_214 220547.3838144797
Csub_88_214 sn_88 sn_214 4.777423934936853e-17
Rsub_88_182 sn_88 sn_182 133176.1413356051
Csub_88_182 sn_88 sn_182 7.911690034386842e-17
Rsub_88_103 sn_88 sn_103 1101481.282765535
Csub_88_103 sn_88 sn_103 9.565739942285368e-18
Rsub_88_215 sn_88 sn_215 1360269.272246971
Csub_88_215 sn_88 sn_215 7.745880699653847e-18
Rsub_88_114 sn_88 sn_114 5221629.774702512
Csub_88_114 sn_88 sn_114 2.017853420645911e-18
Rsub_88_146 sn_88 sn_146 22722443.62345145
Csub_88_146 sn_88 sn_146 4.637038021454468e-19
Rsub_197_200 sn_197 sn_200 37325655.53777513
Csub_197_200 sn_197 sn_200 2.822852901154446e-19
Rsub_197_210 sn_197 sn_210 6275528.952736865
Csub_197_210 sn_197 sn_210 1.678979346854079e-18
Rsub_197_219 sn_197 sn_219 8702182.126499761
Csub_197_219 sn_197 sn_219 1.210786369334244e-18
Rsub_197_213 sn_197 sn_213 5673490.042911096
Csub_197_213 sn_197 sn_213 1.857143208596112e-18
Rsub_197_211 sn_197 sn_211 5161771.749649315
Csub_197_211 sn_197 sn_211 2.041253277606829e-18
Rsub_197_228 sn_197 sn_228 24266525.04687518
Csub_197_228 sn_197 sn_228 4.341982826909448e-19
Rsub_197_206 sn_197 sn_206 36323316.32049619
Csub_197_206 sn_197 sn_206 2.900749317397698e-19
Rsub_197_207 sn_197 sn_207 14830.87897021383
Csub_197_207 sn_197 sn_207 7.104422821729822e-16
Rsub_197_224 sn_197 sn_224 127400.7626176556
Csub_197_224 sn_197 sn_224 8.270345707310405e-17
Rsub_197_226 sn_197 sn_226 68568.3766054539
Csub_197_226 sn_197 sn_226 1.536638903215908e-16
Rsub_197_214 sn_197 sn_214 30114832.72707244
Csub_197_214 sn_197 sn_214 3.498768728925392e-19
Rsub_197_218 sn_197 sn_218 51283.69583500073
Csub_197_218 sn_197 sn_218 2.054548396069172e-16
Rsub_197_222 sn_197 sn_222 364370.2118842683
Csub_197_222 sn_197 sn_222 2.891697278913846e-17
Rsub_197_208 sn_197 sn_208 232611.9789885854
Csub_197_208 sn_197 sn_208 4.529639250757177e-17
Rsub_197_230 sn_197 0 188462.5679921646
Csub_197_230 sn_197 0 5.59075662317626e-17
Rsub_197_199 sn_197 sn_199 33534799.76718359
Csub_197_199 sn_197 sn_199 3.141955096013655e-19
Rsub_197_216 sn_197 sn_216 3499517.911919947
Csub_197_216 sn_197 sn_216 3.010838569032885e-18
Rsub_197_221 sn_197 sn_221 26773991.37049079
Csub_197_221 sn_197 sn_221 3.935342831940586e-19
Rsub_197_203 sn_197 sn_203 4752622.432378411
Csub_197_203 sn_197 sn_203 2.216983076637355e-18
Rsub_197_227 sn_197 sn_227 284555.9980859475
Csub_197_227 sn_197 sn_227 3.702780322011541e-17
Rsub_55_123 sn_55 sn_123 44421301.45416647
Csub_55_123 sn_55 sn_123 2.371943900180741e-19
Rsub_55_111 sn_55 sn_111 82316013.58680905
Csub_55_111 sn_55 sn_111 1.280004101646444e-19
Rsub_55_172 sn_55 sn_172 96446064.14731354
Csub_55_172 sn_55 sn_172 1.092474181853225e-19
Rsub_55_171 sn_55 sn_171 97030164.80600028
Csub_55_171 sn_55 sn_171 1.085897722970623e-19
Rsub_55_201 sn_55 sn_201 40272060.11831879
Csub_55_201 sn_55 sn_201 2.616325927025822e-19
Rsub_55_224 sn_55 sn_224 126373593.0466749
Csub_55_224 sn_55 sn_224 8.337567404875834e-20
Rsub_55_162 sn_55 sn_162 8515068.873063277
Csub_55_162 sn_55 sn_162 1.237392634082069e-18
Rsub_55_138 sn_55 sn_138 225612757.8144977
Csub_55_138 sn_55 sn_138 4.670162983820826e-20
Rsub_55_188 sn_55 sn_188 178494882.0150686
Csub_55_188 sn_55 sn_188 5.90296112879052e-20
Rsub_55_130 sn_55 sn_130 119308089.0471539
Csub_55_130 sn_55 sn_130 8.831323664957612e-20
Rsub_55_97 sn_55 sn_97 75204252.60483257
Csub_55_97 sn_55 sn_97 1.401048895146248e-19
Rsub_55_146 sn_55 sn_146 225612757.8144977
Csub_55_146 sn_55 sn_146 4.670162983820826e-20
Rsub_55_213 sn_55 sn_213 225612757.8144977
Csub_55_213 sn_55 sn_213 4.670162983820826e-20
Rsub_55_216 sn_55 sn_216 24123292.67526011
Csub_55_216 sn_55 sn_216 4.367763407785456e-19
Rsub_55_137 sn_55 sn_137 60508017.26235207
Csub_55_137 sn_55 sn_137 1.741336764770472e-19
Rsub_55_128 sn_55 sn_128 81277136.20876923
Csub_55_128 sn_55 sn_128 1.296365004195754e-19
Rsub_55_150 sn_55 sn_150 3162059.620901114
Csub_55_150 sn_55 sn_150 3.332158392139155e-18
Rsub_55_62 sn_55 sn_62 225612757.8144977
Csub_55_62 sn_55 sn_62 4.670162983820826e-20
Rsub_55_229 sn_55 sn_229 58701101.94714721
Csub_55_229 sn_55 sn_229 1.794937940299102e-19
Rsub_55_71 sn_55 sn_71 119014899.474484
Csub_55_71 sn_55 sn_71 8.85307936128531e-20
Rsub_55_153 sn_55 sn_153 9026056.856892971
Csub_55_153 sn_55 sn_153 1.16734069697152e-18
Rsub_55_190 sn_55 sn_190 103705197.5420094
Csub_55_190 sn_55 sn_190 1.016003416604248e-19
Rsub_55_140 sn_55 sn_140 1252375.286238378
Csub_55_140 sn_55 sn_140 8.413199795627774e-18
Rsub_55_219 sn_55 sn_219 3524238.268675797
Csub_55_219 sn_55 sn_219 2.989719394366885e-18
Rsub_55_177 sn_55 sn_177 4629542.319323543
Csub_55_177 sn_55 sn_177 2.275923358179727e-18
Rsub_55_132 sn_55 sn_132 29145929.83577443
Csub_55_132 sn_55 sn_132 3.615078867477841e-19
Rsub_55_169 sn_55 sn_169 26441433.46485751
Csub_55_169 sn_55 sn_169 3.984838233613058e-19
Rsub_55_90 sn_55 sn_90 92925.13111510547
Csub_55_90 sn_55 sn_90 1.133868026419953e-16
Rsub_55_93 sn_55 sn_93 2508644325.145459
Rsub_55_155 sn_55 sn_155 10822387.91142715
Csub_55_155 sn_55 sn_155 9.735821325628823e-19
Rsub_55_168 sn_55 sn_168 1035648.94762453
Csub_55_168 sn_55 sn_168 1.01737982995083e-17
Rsub_55_127 sn_55 sn_127 16035704.27419112
Csub_55_127 sn_55 sn_127 6.57063969381631e-19
Rsub_55_159 sn_55 sn_159 45971148.34031449
Csub_55_159 sn_55 sn_159 2.291977442945451e-19
Rsub_55_80 sn_55 sn_80 1329032.701865159
Csub_55_80 sn_55 sn_80 7.927933968399081e-18
Rsub_55_122 sn_55 sn_122 2054427.295981561
Csub_55_122 sn_55 sn_122 5.128671879914786e-18
Rsub_55_181 sn_55 sn_181 1839550.318209323
Csub_55_181 sn_55 sn_181 5.727749547229866e-18
Rsub_55_107 sn_55 sn_107 6258980.282335241
Csub_55_107 sn_55 sn_107 1.683418548540117e-18
Rsub_55_61 sn_55 sn_61 97374674.98899432
Csub_55_61 sn_55 sn_61 1.082055832630083e-19
Rsub_55_228 sn_55 sn_228 298385.6237852218
Csub_55_228 sn_55 sn_228 3.531163253969021e-17
Rsub_55_142 sn_55 sn_142 12541243.3124303
Csub_55_142 sn_55 sn_142 8.401466457306294e-19
Rsub_55_221 sn_55 sn_221 516550625.5198915
Csub_55_221 sn_55 sn_221 2.039777512925354e-20
Rsub_55_135 sn_55 sn_135 615936.0261909282
Csub_55_135 sn_55 sn_135 1.710645757707943e-17
Rsub_55_214 sn_55 sn_214 52927543.94352766
Csub_55_214 sn_55 sn_214 1.990737282930067e-19
Rsub_55_165 sn_55 sn_165 20864474.7311065
Csub_55_165 sn_55 sn_165 5.049963460868407e-19
Rsub_55_191 sn_55 sn_191 61122462.75553489
Csub_55_191 sn_55 sn_191 1.723831636884736e-19
Rsub_55_112 sn_55 sn_112 496809.5358528599
Csub_55_112 sn_55 sn_112 2.120829561804263e-17
Rsub_55_126 sn_55 sn_126 127792.5142773352
Csub_55_126 sn_55 sn_126 8.244992722628287e-17
Rsub_55_180 sn_55 sn_180 1452616.274594309
Csub_55_180 sn_55 sn_180 7.25345274351457e-18
Rsub_55_210 sn_55 sn_210 48711.37791102107
Csub_55_210 sn_55 sn_210 2.163043616108855e-16
Rsub_55_131 sn_55 sn_131 3300615.472476914
Csub_55_131 sn_55 sn_131 3.192278406888459e-18
Rsub_55_139 sn_55 sn_139 25704639.60108855
Csub_55_139 sn_55 sn_139 4.099059028154512e-19
Rsub_55_176 sn_55 sn_176 928110.7005823856
Csub_55_176 sn_55 sn_176 1.135261504432435e-17
Rsub_55_82 sn_55 sn_82 1205180.984519732
Csub_55_82 sn_55 sn_82 8.742656611387558e-18
Rsub_55_141 sn_55 sn_141 2815347.905294131
Csub_55_141 sn_55 sn_141 3.742515616779238e-18
Rsub_55_220 sn_55 sn_220 227014379.4890094
Csub_55_220 sn_55 sn_220 4.641328679683972e-20
Rsub_55_215 sn_55 sn_215 23722495.75878609
Csub_55_215 sn_55 sn_215 4.441557755712785e-19
Rsub_55_136 sn_55 sn_136 81158381.09923881
Csub_55_136 sn_55 sn_136 1.298261912019438e-19
Rsub_55_151 sn_55 sn_151 106218569.9992808
Csub_55_151 sn_55 sn_151 9.919624696793926e-20
Rsub_55_63 sn_55 sn_63 1507582.579607342
Csub_55_63 sn_55 sn_63 6.988992606278514e-18
Rsub_55_230 sn_55 0 1484888.978786792
Csub_55_230 sn_55 0 7.095805580588719e-18
Rsub_55_158 sn_55 sn_158 55645856.29235834
Csub_55_158 sn_55 sn_158 1.893489327735791e-19
Rsub_55_189 sn_55 sn_189 106225494.4059348
Csub_55_189 sn_55 sn_189 9.918978076925126e-20
Rsub_55_222 sn_55 sn_222 2521946.024410042
Csub_55_222 sn_55 sn_222 4.17791792538256e-18
Rsub_55_134 sn_55 sn_134 45648136.46418469
Csub_55_134 sn_55 sn_134 2.3081957596444e-19
Rsub_55_152 sn_55 sn_152 105855426.2908169
Csub_55_152 sn_55 sn_152 9.953654594222775e-20
Rsub_55_77 sn_55 sn_77 43285399.97531013
Csub_55_77 sn_55 sn_77 2.434188781492139e-19
Rsub_55_195 sn_55 sn_195 1386881.57645498
Csub_55_195 sn_55 sn_195 7.5972481581033e-18
Rsub_55_178 sn_55 sn_178 227014379.4890094
Csub_55_178 sn_55 sn_178 4.641328679683972e-20
Rsub_55_227 sn_55 sn_227 61231319.92345237
Csub_55_227 sn_55 sn_227 1.720767005415213e-19
Rsub_55_148 sn_55 sn_148 179179475.0820461
Csub_55_148 sn_55 sn_148 5.880407617783987e-20
Rsub_55_87 sn_55 sn_87 111333612.5504721
Csub_55_87 sn_55 sn_87 9.463883602495496e-20
Rsub_55_185 sn_55 sn_185 34820248.24338869
Csub_55_185 sn_55 sn_185 3.025964498754129e-19
Rsub_55_117 sn_55 sn_117 48330605.32495394
Csub_55_117 sn_55 sn_117 2.180085151300563e-19
Rsub_55_125 sn_55 sn_125 19146118.48432385
Csub_55_125 sn_55 sn_125 5.503195601164223e-19
Rsub_55_204 sn_55 sn_204 225612757.8144977
Csub_55_204 sn_55 sn_204 4.670162983820826e-20
Rsub_55_198 sn_55 sn_198 173571110.4816338
Csub_55_198 sn_55 sn_198 6.07041314248255e-20
Rsub_55_179 sn_55 sn_179 80393840.3954325
Csub_55_179 sn_55 sn_179 1.310608306607109e-19
Rsub_55_115 sn_55 sn_115 130933643.2102672
Csub_55_115 sn_55 sn_115 8.047193405677559e-20
Rsub_55_144 sn_55 sn_144 225612757.8144977
Csub_55_144 sn_55 sn_144 4.670162983820826e-20
Rsub_55_66 sn_55 sn_66 57588554.4734095
Csub_55_66 sn_55 sn_66 1.829614165275678e-19
Rsub_55_183 sn_55 sn_183 451225515.6289955
Csub_55_183 sn_55 sn_183 2.335081491910413e-20
Rsub_55_167 sn_55 sn_167 150408505.2096651
Csub_55_167 sn_55 sn_167 7.005244475731239e-20
Rsub_13_107 sn_13 sn_107 16181307.54519021
Csub_13_107 sn_13 sn_107 6.51151550812833e-19
Rsub_13_30 sn_13 sn_30 56269732.13126578
Csub_13_30 sn_13 sn_30 1.872495763379598e-19
Rsub_13_77 sn_13 sn_77 199731088.6179117
Csub_13_77 sn_13 sn_77 5.275334738893072e-20
Rsub_13_230 sn_13 0 6512398.505287895
Csub_13_230 sn_13 0 1.617911356879444e-18
Rsub_13_130 sn_13 sn_130 98857888.66393831
Csub_13_130 sn_13 sn_130 1.065821215143302e-19
Rsub_13_118 sn_13 sn_118 127742204.4507445
Csub_13_118 sn_13 sn_118 8.248239920027926e-20
Rsub_13_96 sn_13 sn_96 82913126.60618322
Csub_13_96 sn_13 sn_96 1.270785933845636e-19
Rsub_13_35 sn_13 sn_35 199731088.6179117
Csub_13_35 sn_13 sn_35 5.275334738893072e-20
Rsub_13_212 sn_13 sn_212 85779665.92456999
Csub_13_212 sn_13 sn_212 1.22831948442131e-19
Rsub_13_227 sn_13 sn_227 222366238.3945342
Csub_13_227 sn_13 sn_227 4.738346782453369e-20
Rsub_13_200 sn_13 sn_200 111183119.1972671
Csub_13_200 sn_13 sn_200 9.476693564906739e-20
Rsub_13_164 sn_13 sn_164 5244566.573547664
Csub_13_164 sn_13 sn_164 2.009028459162574e-18
Rsub_13_31 sn_13 sn_31 39271872.69017988
Csub_13_31 sn_13 sn_31 2.682959273511981e-19
Rsub_13_162 sn_13 sn_162 8664235.205971891
Csub_13_162 sn_13 sn_162 1.216089274096304e-18
Rsub_13_216 sn_13 sn_216 14495160.23479681
Csub_13_216 sn_13 sn_216 7.268966559566768e-19
Rsub_13_137 sn_13 sn_137 50809220.73710717
Csub_13_137 sn_13 sn_137 2.07373452089474e-19
Rsub_13_146 sn_13 sn_146 932342.8999477501
Csub_13_146 sn_13 sn_146 1.130108193328922e-17
Rsub_13_93 sn_13 sn_93 9041975.935011206
Csub_13_93 sn_13 sn_93 1.165285505951409e-18
Rsub_13_56 sn_13 sn_56 74623950.98567954
Csub_13_56 sn_13 sn_56 1.411943935299268e-19
Rsub_13_74 sn_13 sn_74 44171.92510612473
Csub_13_74 sn_13 sn_74 2.385334910560429e-16
Rsub_13_222 sn_13 sn_222 53967356.20672821
Csub_13_222 sn_13 sn_222 1.952380891490919e-19
Rsub_13_52 sn_13 sn_52 11048213.02316778
Csub_13_52 sn_13 sn_52 9.536821457130941e-19
Rsub_13_171 sn_13 sn_171 6671443.477359681
Csub_13_171 sn_13 sn_171 1.579340893464328e-18
Rsub_13_208 sn_13 sn_208 20964629.04856674
Csub_13_208 sn_13 sn_208 5.025838271605544e-19
Rsub_13_29 sn_13 sn_29 15401807.55829157
Csub_13_29 sn_13 sn_29 6.84106944094213e-19
Rsub_13_19 sn_13 sn_19 199731088.6179117
Csub_13_19 sn_13 sn_19 5.275334738893072e-20
Rsub_13_177 sn_13 sn_177 99865544.30895585
Csub_13_177 sn_13 sn_177 1.055066947778614e-19
Rsub_13_21 sn_13 sn_21 76895864.97062251
Csub_13_21 sn_13 sn_21 1.370227580671e-19
Rsub_13_132 sn_13 sn_132 82847226.0675834
Csub_13_132 sn_13 sn_132 1.271796776108686e-19
Rsub_13_84 sn_13 sn_84 3857840.339143429
Csub_13_84 sn_13 sn_84 2.731187031075904e-18
Rsub_13_158 sn_13 sn_158 125169821.1163898
Csub_13_158 sn_13 sn_158 8.417750707203293e-20
Rsub_13_123 sn_13 sn_123 101349.8513452505
Csub_13_123 sn_13 sn_123 1.039615091919301e-16
Rsub_13_44 sn_13 sn_44 35396586.13322345
Csub_13_44 sn_13 sn_44 2.97669483225683e-19
Rsub_13_155 sn_13 sn_155 58637670.45645213
Csub_13_155 sn_13 sn_155 1.796879620252825e-19
Rsub_13_145 sn_13 sn_145 187552309.5108152
Csub_13_145 sn_13 sn_145 5.617890565950304e-20
Rsub_13_224 sn_13 sn_224 13001474.17944002
Csub_13_224 sn_13 sn_224 8.104068320876991e-19
Rsub_13_26 sn_13 sn_26 7881119.219236023
Csub_13_26 sn_13 sn_26 1.336927308054526e-18
Rsub_13_184 sn_13 sn_184 40671237.53822401
Csub_13_184 sn_13 sn_184 2.590647381291879e-19
Rsub_13_32 sn_13 sn_32 122638785.2967295
Csub_13_32 sn_13 sn_32 8.591477383550854e-20
Rsub_13_190 sn_13 sn_190 43982950.33734434
Csub_13_190 sn_13 sn_190 2.395583611698702e-19
Rsub_13_37 sn_13 sn_37 172865697.8609782
Csub_13_37 sn_13 sn_37 6.095184662201541e-20
Rsub_13_116 sn_13 sn_116 36615593.45094493
Csub_13_116 sn_13 sn_116 2.877594628186503e-19
Rsub_13_170 sn_13 sn_170 169154487.8344181
Csub_13_170 sn_13 sn_170 6.228911592664304e-20
Rsub_13_138 sn_13 sn_138 199731088.6179117
Csub_13_138 sn_13 sn_138 5.275334738893072e-20
Rsub_13_141 sn_13 sn_141 399462177.2358234
Csub_13_141 sn_13 sn_141 2.637667369446536e-20
Rsub_206_209 sn_206 sn_209 15217138.60548058
Csub_206_209 sn_206 sn_209 6.924089853814698e-19
Rsub_206_228 sn_206 sn_228 39718033.03465594
Csub_206_228 sn_206 sn_228 2.652821073248114e-19
Rsub_206_224 sn_206 sn_224 1079689.6909965
Csub_206_224 sn_206 sn_224 9.758807174036592e-18
Rsub_206_211 sn_206 sn_211 2120456.611576217
Csub_206_211 sn_206 sn_211 4.968969157259872e-18
Rsub_206_210 sn_206 sn_210 6554798.720070668
Csub_206_210 sn_206 sn_210 1.607445774035363e-18
Rsub_206_220 sn_206 sn_220 3141718.174859127
Csub_206_220 sn_206 sn_220 3.353732867112581e-18
Rsub_206_208 sn_206 sn_208 2624645.369372856
Csub_206_208 sn_206 sn_208 4.014440817483709e-18
Rsub_206_230 sn_206 0 24570.96976975939
Csub_206_230 sn_206 0 4.288183820566061e-16
Rsub_206_213 sn_206 sn_213 2061193.186533123
Csub_206_213 sn_206 sn_213 5.111836954959138e-18
Rsub_206_216 sn_206 sn_216 4991604.669723508
Csub_206_216 sn_206 sn_216 2.110840941819543e-18
Rsub_206_215 sn_206 sn_215 19673.076827613
Csub_206_215 sn_206 sn_215 5.35578831646764e-16
Rsub_206_222 sn_206 sn_222 188146.2521594414
Csub_206_222 sn_206 sn_222 5.600155932577938e-17
Rsub_206_217 sn_206 sn_217 1179170.406294937
Csub_206_217 sn_206 sn_217 8.935505373932006e-18
Rsub_206_229 sn_206 sn_229 300988.3165705896
Csub_206_229 sn_206 sn_229 3.500628736118706e-17
Rsub_206_212 sn_206 sn_212 1101628.176846903
Csub_206_212 sn_206 sn_212 9.564464420642987e-18
Rsub_206_225 sn_206 sn_225 3117038.200209357
Csub_206_225 sn_206 sn_225 3.380286934411748e-18
Rsub_206_226 sn_206 sn_226 13703434.36405436
Csub_206_226 sn_206 sn_226 7.688936380699113e-19
Rsub_206_221 sn_206 sn_221 38877061.90502771
Csub_206_221 sn_206 sn_221 2.710205706380139e-19
Rsub_206_227 sn_206 sn_227 352830.6550948751
Csub_206_227 sn_206 sn_227 2.986272125191835e-17
Rsub_206_214 sn_206 sn_214 578877.9201021797
Csub_206_214 sn_206 sn_214 1.820156398497661e-17
Rsub_206_219 sn_206 sn_219 2313168.563542251
Csub_206_219 sn_206 sn_219 4.555000300581229e-18
Rsub_206_218 sn_206 sn_218 820337.8585576735
Csub_206_218 sn_206 sn_218 1.284407807382602e-17
Rsub_182_223 sn_182 sn_223 15608576.79116729
Csub_182_223 sn_182 sn_223 6.750444735097482e-19
Rsub_182_200 sn_182 sn_200 48038.22566094973
Csub_182_200 sn_182 sn_200 2.193354012822148e-16
Rsub_182_221 sn_182 sn_221 224755.8829835954
Csub_182_221 sn_182 sn_221 4.687967835306471e-17
Rsub_182_184 sn_182 sn_184 9543083.208907753
Csub_182_184 sn_182 sn_184 1.104096367135831e-18
Rsub_182_188 sn_182 sn_188 8686189.588015083
Csub_182_188 sn_182 sn_188 1.213015603155599e-18
Rsub_182_222 sn_182 sn_222 105190.5846526683
Csub_182_222 sn_182 sn_222 1.001656520592666e-16
Rsub_182_218 sn_182 sn_218 748091.0085961818
Csub_182_218 sn_182 sn_218 1.408449424088397e-17
Rsub_182_214 sn_182 sn_214 8780.372782383578
Csub_182_214 sn_182 sn_214 1.200004118659948e-15
Rsub_182_226 sn_182 sn_226 379826.6977111349
Csub_182_226 sn_182 sn_226 2.774023934000339e-17
Rsub_182_206 sn_182 sn_206 2940982.035320205
Csub_182_206 sn_182 sn_206 3.582641231972987e-18
Rsub_182_219 sn_182 sn_219 2377531.070012327
Csub_182_219 sn_182 sn_219 4.431691192231348e-18
Rsub_182_199 sn_182 sn_199 6696630.650165961
Csub_182_199 sn_182 sn_199 1.573400722342194e-18
Rsub_182_227 sn_182 sn_227 80868.99260528672
Csub_182_227 sn_182 sn_227 1.302907723069768e-16
Rsub_182_190 sn_182 sn_190 6862718.495155796
Csub_182_190 sn_182 sn_190 1.535322119021408e-18
Rsub_182_213 sn_182 sn_213 10057.00486530213
Csub_182_213 sn_182 sn_213 1.047676086802158e-15
Rsub_182_215 sn_182 sn_215 45283.52652521509
Csub_182_215 sn_182 sn_215 2.326780688417233e-16
Rsub_182_198 sn_182 sn_198 61826.3287600089
Csub_182_198 sn_182 sn_198 1.704206559494976e-16
Rsub_182_229 sn_182 sn_229 120250.0389649122
Csub_182_229 sn_182 sn_229 8.762145603382667e-17
Rsub_182_192 sn_182 sn_192 480276.0017775455
Csub_182_192 sn_182 sn_192 2.193839263930221e-17
Rsub_182_212 sn_182 sn_212 162961.7441061343
Csub_182_212 sn_182 sn_212 6.465617780433036e-17
Rsub_182_230 sn_182 0 50861.59692304223
Csub_182_230 sn_182 0 2.071599033387128e-16
Rsub_182_211 sn_182 sn_211 172756.1885291343
Csub_182_211 sn_182 sn_211 6.09904837096651e-17
Rsub_182_209 sn_182 sn_209 7991890.485219382
Csub_182_209 sn_182 sn_209 1.318396882654576e-18
Rsub_182_220 sn_182 sn_220 15983780.97043876
Csub_182_220 sn_182 sn_220 6.591984413272882e-19
Rsub_182_201 sn_182 sn_201 14819836.74124944
Csub_182_201 sn_182 sn_201 7.109716312125639e-19
Rsub_182_203 sn_182 sn_203 195671.9910370994
Csub_182_203 sn_182 sn_203 5.384768380177766e-17
Rsub_182_195 sn_182 sn_195 10933987.61156176
Csub_182_195 sn_182 sn_195 9.636450923987301e-19
Rsub_182_196 sn_182 sn_196 856779.2625499414
Csub_182_196 sn_182 sn_196 1.229778072694171e-17
Rsub_182_186 sn_182 sn_186 26809383.79349491
Csub_182_186 sn_182 sn_186 3.930147586900746e-19
Rsub_182_216 sn_182 sn_216 477692.9988474495
Csub_182_216 sn_182 sn_216 2.20570188963452e-17
Rsub_182_207 sn_182 sn_207 2236524.498675867
Csub_182_207 sn_182 sn_207 4.711096841759668e-18
Rsub_182_197 sn_182 sn_197 157101358.5504172
Csub_182_197 sn_182 sn_197 6.706806102411024e-20
Rsub_182_210 sn_182 sn_210 15359071.3666609
Csub_182_210 sn_182 sn_210 6.860104527608991e-19
Rsub_182_217 sn_182 sn_217 17070213.9928784
Csub_182_217 sn_182 sn_217 6.172437853811185e-19
Rsub_182_204 sn_182 sn_204 2018744.388149913
Csub_182_204 sn_182 sn_204 5.219325222192298e-18
Rsub_182_228 sn_182 sn_228 39244588.78121464
Csub_182_228 sn_182 sn_228 2.684824540007294e-19
Rsub_72_168 sn_72 sn_168 25859159.26132972
Csub_72_168 sn_72 sn_168 4.074565377686682e-19
Rsub_72_126 sn_72 sn_126 55630357.78020201
Csub_72_126 sn_72 sn_126 1.894016850270874e-19
Rsub_72_87 sn_72 sn_87 28034983.79723832
Csub_72_87 sn_72 sn_87 3.758334079461082e-19
Rsub_72_183 sn_72 sn_183 183177453.3241102
Csub_72_183 sn_72 sn_183 5.752063537856363e-20
Rsub_72_86 sn_72 sn_86 33842946.90493044
Csub_72_86 sn_72 sn_86 3.113346935131995e-19
Rsub_72_152 sn_72 sn_152 840429252.9580209
Csub_72_152 sn_72 sn_152 1.253702612700024e-20
Rsub_72_184 sn_72 sn_184 94271140.55637914
Csub_72_184 sn_72 sn_184 1.117678585412746e-19
Rsub_72_166 sn_72 sn_166 4527158.011531543
Csub_72_166 sn_72 sn_166 2.327394686775136e-18
Rsub_72_174 sn_72 sn_174 37090010.37576772
Csub_72_174 sn_72 sn_174 2.840787423751673e-19
Rsub_72_89 sn_72 sn_89 94271140.55637914
Csub_72_89 sn_72 sn_89 1.117678585412746e-19
Rsub_72_193 sn_72 sn_193 94271140.55637914
Csub_72_193 sn_72 sn_193 1.117678585412746e-19
Rsub_72_203 sn_72 sn_203 6266414.524976037
Csub_72_203 sn_72 sn_203 1.681421402978491e-18
Rsub_72_218 sn_72 sn_218 42680977.75595009
Csub_72_218 sn_72 sn_218 2.468660292291717e-19
Rsub_72_149 sn_72 sn_149 6043438084.261925
Rsub_72_145 sn_72 sn_145 158967792.7774867
Csub_72_145 sn_72 sn_145 6.62806177159314e-20
Rsub_72_125 sn_72 sn_125 22779149.07344405
Csub_72_125 sn_72 sn_125 4.625494775181678e-19
Rsub_72_150 sn_72 sn_150 14547777.32470456
Csub_72_150 sn_72 sn_150 7.242675817107323e-19
Rsub_72_197 sn_72 sn_197 43271502.28948461
Csub_72_197 sn_72 sn_197 2.434970579884505e-19
Rsub_72_182 sn_72 sn_182 5460097.244331235
Csub_72_182 sn_72 sn_182 1.929724514186841e-18
Rsub_72_201 sn_72 sn_201 9160379.173471319
Csub_72_201 sn_72 sn_201 1.15022351178911e-18
Rsub_72_154 sn_72 sn_154 14747447.98932042
Csub_72_154 sn_72 sn_154 7.144614790206516e-19
Rsub_72_83 sn_72 sn_83 79890876.43205518
Csub_72_83 sn_72 sn_83 1.318859420849009e-19
Rsub_72_207 sn_72 sn_207 36081634.94420664
Csub_72_207 sn_72 sn_207 2.92017906575538e-19
Rsub_72_200 sn_72 sn_200 20896988.39992741
Csub_72_200 sn_72 sn_200 5.04210621194899e-19
Rsub_72_162 sn_72 sn_162 89075474.00431006
Csub_72_162 sn_72 sn_162 1.182871449184787e-19
Rsub_72_96 sn_72 sn_96 178102642.4370342
Csub_72_96 sn_72 sn_96 5.915961356920928e-20
Rsub_72_100 sn_72 sn_100 108954842.9277183
Csub_72_100 sn_72 sn_100 9.67050497169732e-20
Rsub_72_77 sn_72 sn_77 25932195.42916875
Csub_72_77 sn_72 sn_77 4.063089656642984e-19
Rsub_72_112 sn_72 sn_112 3052009.270279885
Csub_72_112 sn_72 sn_112 3.452310451620532e-18
Rsub_72_212 sn_72 sn_212 17977566.48030559
Csub_72_212 sn_72 sn_212 5.860906432343172e-19
Rsub_72_211 sn_72 sn_211 30480429.58204243
Csub_72_211 sn_72 sn_211 3.456802822896427e-19
Rsub_72_190 sn_72 sn_190 19624367.98599109
Csub_72_190 sn_72 sn_190 5.369081699727349e-19
Rsub_72_176 sn_72 sn_176 20063992.05752189
Csub_72_176 sn_72 sn_176 5.251439231047703e-19
Rsub_72_221 sn_72 sn_221 11646040.26929882
Csub_72_221 sn_72 sn_221 9.047266932440701e-19
Rsub_72_128 sn_72 sn_128 4601352.180951594
Csub_72_128 sn_72 sn_128 2.289866779997478e-18
Rsub_72_222 sn_72 sn_222 1965680.690384974
Csub_72_222 sn_72 sn_222 5.360221298285459e-18
Rsub_72_148 sn_72 sn_148 4701290.770008571
Csub_72_148 sn_72 sn_148 2.241189498306822e-18
Rsub_72_227 sn_72 sn_227 8041713.138688364
Csub_72_227 sn_72 sn_227 1.310228718746432e-18
Rsub_72_127 sn_72 sn_127 20067732.30689781
Csub_72_127 sn_72 sn_127 5.250460461149532e-19
Rsub_72_206 sn_72 sn_206 817521.689684439
Csub_72_206 sn_72 sn_206 1.288832288510541e-17
Rsub_72_78 sn_72 sn_78 658192.3852383702
Csub_72_78 sn_72 sn_78 1.600821239889325e-17
Rsub_72_157 sn_72 sn_157 24010662.472232
Csub_72_157 sn_72 sn_157 4.388251892014766e-19
Rsub_72_195 sn_72 sn_195 543693.8107518667
Csub_72_195 sn_72 sn_195 1.937944352844342e-17
Rsub_72_198 sn_72 sn_198 3140616.647333133
Csub_72_198 sn_72 sn_198 3.354909142182984e-18
Rsub_72_181 sn_72 sn_181 4442240.667680243
Csub_72_181 sn_72 sn_181 2.371884886581842e-18
Rsub_72_114 sn_72 sn_114 2204356.879647337
Csub_72_114 sn_72 sn_114 4.779844679195354e-18
Rsub_72_225 sn_72 sn_225 17223240.08446432
Csub_72_225 sn_72 sn_225 6.117596602357126e-19
Rsub_72_135 sn_72 sn_135 13900391.82324137
Csub_72_135 sn_72 sn_135 7.579990288196815e-19
Rsub_72_214 sn_72 sn_214 1838637.480790677
Csub_72_214 sn_72 sn_214 5.730593231298078e-18
Rsub_72_120 sn_72 sn_120 23666709.10245943
Csub_72_120 sn_72 sn_120 4.452027299872907e-19
Rsub_72_199 sn_72 sn_199 3397384.316754952
Csub_72_199 sn_72 sn_199 3.101351663474458e-18
Rsub_72_117 sn_72 sn_117 880594.0835377795
Csub_72_117 sn_72 sn_117 1.196519906186488e-17
Rsub_72_204 sn_72 sn_204 30291.33701972727
Csub_72_204 sn_72 sn_204 3.478381787957429e-16
Rsub_72_210 sn_72 sn_210 31724648.23079921
Csub_72_210 sn_72 sn_210 3.321229419338644e-19
Rsub_72_131 sn_72 sn_131 1412727.829865615
Csub_72_131 sn_72 sn_131 7.458254363993298e-18
Rsub_72_99 sn_72 sn_99 573373.5909301132
Csub_72_99 sn_72 sn_99 1.837629718023455e-17
Rsub_72_178 sn_72 sn_178 3151928.781673973
Csub_72_178 sn_72 sn_178 3.342868520218953e-18
Rsub_72_133 sn_72 sn_133 8566842.625980018
Csub_72_133 sn_72 sn_133 1.229914445991666e-18
Rsub_72_129 sn_72 sn_129 2851138.922307827
Csub_72_129 sn_72 sn_129 3.695534938613706e-18
Rsub_72_138 sn_72 sn_138 15435777.56534667
Csub_72_138 sn_72 sn_138 6.826014081651713e-19
Rsub_72_217 sn_72 sn_217 93019697.63799404
Csub_72_217 sn_72 sn_217 1.132715303293607e-19
Rsub_72_101 sn_72 sn_101 207979.4531698049
Csub_72_101 sn_72 sn_101 5.066117513842816e-17
Rsub_72_230 sn_72 0 149597.4319718853
Csub_72_230 sn_72 0 7.043224849080421e-17
Rsub_72_220 sn_72 sn_220 34559274.84030938
Csub_72_220 sn_72 sn_220 3.048814985533324e-19
Rsub_72_141 sn_72 sn_141 4416870.712389603
Csub_72_141 sn_72 sn_141 2.385508697973544e-18
Rsub_72_110 sn_72 sn_110 856076.1463176463
Csub_72_110 sn_72 sn_110 1.230788119439138e-17
Rsub_72_189 sn_72 sn_189 66890979.81428161
Csub_72_189 sn_72 sn_189 1.575172546654848e-19
Rsub_72_177 sn_72 sn_177 2013945.350459864
Csub_72_177 sn_72 sn_177 5.231762371220303e-18
Rsub_72_98 sn_72 sn_98 34620716.16638292
Csub_72_98 sn_72 sn_98 3.043404258766038e-19
Rsub_72_219 sn_72 sn_219 1793524.103865463
Csub_72_219 sn_72 sn_219 5.874737607106266e-18
Rsub_72_140 sn_72 sn_140 91250404.18889712
Csub_72_140 sn_72 sn_140 1.154678008923497e-19
Rsub_72_216 sn_72 sn_216 49519429.79231993
Csub_72_216 sn_72 sn_216 2.127747340068146e-19
Rsub_72_105 sn_72 sn_105 185680.9528324632
Csub_72_105 sn_72 sn_105 5.674509604513336e-17
Rsub_72_97 sn_72 sn_97 77697.80749355156
Csub_72_97 sn_72 sn_97 1.356085048230539e-16
Rsub_72_153 sn_72 sn_153 597653.885181268
Csub_72_153 sn_72 sn_153 1.76297415000227e-17
Rsub_72_215 sn_72 sn_215 1194547.289203751
Csub_72_215 sn_72 sn_215 8.820482535482797e-18
Rsub_72_158 sn_72 sn_158 33257324.28534122
Csub_72_158 sn_72 sn_158 3.168169336723866e-19
Rsub_72_79 sn_72 sn_79 26368912.02989798
Csub_72_79 sn_72 sn_79 3.995797585536853e-19
Rsub_72_160 sn_72 sn_160 5674992.653174067
Csub_72_160 sn_72 sn_160 1.856651478894315e-18
Rsub_72_163 sn_72 sn_163 14082483.96581068
Csub_72_163 sn_72 sn_163 7.481977986135382e-19
Rsub_72_188 sn_72 sn_188 14817823.20568994
Csub_72_188 sn_72 sn_188 7.110682423437245e-19
Rsub_72_165 sn_72 sn_165 45548827.00017563
Csub_72_165 sn_72 sn_165 2.313228286249693e-19
Rsub_72_169 sn_72 sn_169 30648701.52940121
Csub_72_169 sn_72 sn_169 3.437823782558092e-19
Rsub_72_159 sn_72 sn_159 9463057.167140195
Csub_72_159 sn_72 sn_159 1.113433356274884e-18
Rsub_72_192 sn_72 sn_192 5506203.324420772
Csub_72_192 sn_72 sn_192 1.913566005726531e-18
Rsub_72_191 sn_72 sn_191 10312908.11427096
Csub_72_191 sn_72 sn_191 1.021679179672867e-18
Rsub_72_209 sn_72 sn_209 89341298.80464847
Csub_72_209 sn_72 sn_209 1.179351950688429e-19
Rsub_72_130 sn_72 sn_130 11082927.02618568
Csub_72_130 sn_72 sn_130 9.506950174205252e-19
Rsub_72_229 sn_72 sn_229 4969818.879643976
Csub_72_229 sn_72 sn_229 2.120094063263892e-18
Rsub_72_179 sn_72 sn_179 17796005.39787215
Csub_72_179 sn_72 sn_179 5.920701453310323e-19
Rsub_72_76 sn_72 sn_76 5597174.939456495
Csub_72_76 sn_72 sn_76 1.882464567607945e-18
Rsub_72_107 sn_72 sn_107 13308651.66538153
Csub_72_107 sn_72 sn_107 7.917018017413067e-19
Rsub_72_185 sn_72 sn_185 11392426.4319714
Csub_72_185 sn_72 sn_185 9.248673726486124e-19
Rsub_72_88 sn_72 sn_88 91250404.18889712
Csub_72_88 sn_72 sn_88 1.154678008923497e-19
Rsub_72_132 sn_72 sn_132 11719012.86843297
Csub_72_132 sn_72 sn_132 8.990930909045842e-19
Rsub_72_139 sn_72 sn_139 6375012.472628102
Csub_72_139 sn_72 sn_139 1.65277849219428e-18
Rsub_72_213 sn_72 sn_213 21507226.11267762
Csub_72_213 sn_72 sn_213 4.899043441041046e-19
Rsub_72_170 sn_72 sn_170 1810195.109602786
Csub_72_170 sn_72 sn_170 5.820634166082814e-18
Rsub_72_164 sn_72 sn_164 91250404.18889712
Csub_72_164 sn_72 sn_164 1.154678008923497e-19
Rsub_72_175 sn_72 sn_175 277660.977952867
Csub_72_175 sn_72 sn_175 3.794729666341005e-17
Rsub_72_161 sn_72 sn_161 43518641.80419029
Csub_72_161 sn_72 sn_161 2.421142541543076e-19
Rsub_72_171 sn_72 sn_171 28660789.64125676
Csub_72_171 sn_72 sn_171 3.676271182376252e-19
Rsub_72_226 sn_72 sn_226 8713324.277784135
Csub_72_226 sn_72 sn_226 1.209238077950831e-18
Rsub_105_166 sn_105 sn_166 14323932.97822253
Csub_105_166 sn_105 sn_166 7.355859258940406e-19
Rsub_105_216 sn_105 sn_216 2806026.452607036
Csub_105_216 sn_105 sn_216 3.754948030671884e-18
Rsub_105_190 sn_105 sn_190 26050830.52921763
Csub_105_190 sn_105 sn_190 4.044586405954574e-19
Rsub_105_213 sn_105 sn_213 24415605.23625808
Csub_105_213 sn_105 sn_213 4.315470945845295e-19
Rsub_105_175 sn_105 sn_175 16146497.18685211
Csub_105_175 sn_105 sn_175 6.525553734843323e-19
Rsub_105_138 sn_105 sn_138 1711454.020656703
Csub_105_138 sn_105 sn_138 6.156451400422104e-18
Rsub_105_145 sn_105 sn_145 3079565.923175077
Csub_105_145 sn_105 sn_145 3.421418396319549e-18
Rsub_105_181 sn_105 sn_181 374611875.7377657
Csub_105_181 sn_105 sn_181 2.812640010805666e-20
Rsub_105_118 sn_105 sn_118 26050830.52921763
Csub_105_118 sn_105 sn_118 4.044586405954574e-19
Rsub_105_197 sn_105 sn_197 26332765.92455548
Csub_105_197 sn_105 sn_197 4.001282482978615e-19
Rsub_105_124 sn_105 sn_124 7950578.119212699
Csub_105_124 sn_105 sn_124 1.325247465560828e-18
Rsub_105_230 sn_105 0 385642.999067372
Csub_105_230 sn_105 0 2.732185863016088e-17
Rsub_105_128 sn_105 sn_128 4267445.802529248
Csub_105_128 sn_105 sn_128 2.469037449985936e-18
Rsub_105_170 sn_105 sn_170 12416961.81370492
Csub_105_170 sn_105 sn_170 8.485556821637814e-19
Rsub_105_178 sn_105 sn_178 2957379.643774177
Csub_105_178 sn_105 sn_178 3.562776772475329e-18
Rsub_105_220 sn_105 sn_220 12526512.80673534
Csub_105_220 sn_105 sn_220 8.4113461302372e-19
Rsub_105_141 sn_105 sn_141 13333398.39097471
Csub_105_141 sn_105 sn_141 7.902324068680103e-19
Rsub_105_116 sn_105 sn_116 17397767.94205022
Csub_105_116 sn_105 sn_116 6.056227176569834e-19
Rsub_105_195 sn_105 sn_195 618780.9016374283
Csub_105_195 sn_105 sn_195 1.702780980206109e-17
Rsub_105_110 sn_105 sn_110 349426.8927674381
Csub_105_110 sn_105 sn_110 3.015361358933121e-17
Rsub_105_112 sn_105 sn_112 6365860.75812431
Csub_105_112 sn_105 sn_112 1.655154566298519e-18
Rsub_105_129 sn_105 sn_129 794038.7452316991
Csub_105_129 sn_105 sn_129 1.326948283758556e-17
Rsub_105_206 sn_105 sn_206 3765302.942378098
Csub_105_206 sn_105 sn_206 2.798309634968002e-18
Rsub_105_153 sn_105 sn_153 766245.0569360618
Csub_105_153 sn_105 sn_153 1.375080127023802e-17
Rsub_105_204 sn_105 sn_204 134678.9217936788
Csub_105_204 sn_105 sn_204 7.82340945554298e-17
Rsub_105_177 sn_105 sn_177 3309882.047274312
Csub_105_177 sn_105 sn_177 3.183341083379934e-18
Rsub_105_168 sn_105 sn_168 1893717.261944274
Csub_105_168 sn_105 sn_168 5.563915856906866e-18
Rsub_105_117 sn_105 sn_117 12435082.17554197
Csub_105_117 sn_105 sn_117 8.473191695470863e-19
Rsub_105_214 sn_105 sn_214 26332765.92455548
Csub_105_214 sn_105 sn_214 4.001282482978615e-19
Rsub_105_222 sn_105 sn_222 15573289.99854103
Csub_105_222 sn_105 sn_222 6.765740253483434e-19
Rsub_105_227 sn_105 sn_227 1906338.808923284
Csub_105_227 sn_105 sn_227 5.527078110622472e-18
Rsub_105_188 sn_105 sn_188 19798257.8098176
Csub_105_188 sn_105 sn_188 5.321924587225622e-19
Rsub_105_114 sn_105 sn_114 5018928.672473082
Csub_105_114 sn_105 sn_114 2.099349122058381e-18
Rsub_105_144 sn_105 sn_144 4492243.824091796
Csub_105_144 sn_105 sn_144 2.345483440975108e-18
Rsub_105_131 sn_105 sn_131 536429.9945155327
Csub_105_131 sn_105 sn_131 1.964186121200371e-17
Rsub_105_210 sn_105 sn_210 2451278.929517644
Csub_105_210 sn_105 sn_210 4.298361714512571e-18
Rsub_105_215 sn_105 sn_215 1865202.149134341
Csub_105_215 sn_105 sn_215 5.648976711248209e-18
Rsub_105_136 sn_105 sn_136 25205024.34320407
Csub_105_136 sn_105 sn_136 4.180310781993318e-19
Rsub_105_150 sn_105 sn_150 16311543.27719759
Csub_105_150 sn_105 sn_150 6.45952582362901e-19
Rsub_105_229 sn_105 sn_229 1198629376.348559
Rsub_105_219 sn_105 sn_219 858337.8254916047
Csub_105_219 sn_105 sn_219 1.22754505152972e-17
Rsub_105_199 sn_105 sn_199 3070786.444495129
Csub_105_199 sn_105 sn_199 3.431200343194922e-18
Rsub_105_133 sn_105 sn_133 5977179.954384306
Csub_105_133 sn_105 sn_133 1.762785056270795e-18
Rsub_105_212 sn_105 sn_212 24894895.40833243
Csub_105_212 sn_105 sn_212 4.23238713375088e-19
Rsub_18_174 sn_18 sn_174 18021513.29436028
Csub_18_174 sn_18 sn_174 5.846614171700736e-19
Rsub_18_136 sn_18 sn_136 80779940.82566272
Csub_18_136 sn_18 sn_136 1.304344048105901e-19
Rsub_18_223 sn_18 sn_223 310198822.2296036
Csub_18_223 sn_18 sn_223 3.396687139718114e-20
Rsub_18_94 sn_18 sn_94 155099411.1148018
Csub_18_94 sn_18 sn_94 6.793374279436228e-20
Rsub_18_130 sn_18 sn_130 295258855.5031633
Csub_18_130 sn_18 sn_130 3.568557997786154e-20
Rsub_18_36 sn_18 sn_36 295258855.5031633
Csub_18_36 sn_18 sn_36 3.568557997786154e-20
Rsub_18_106 sn_18 sn_106 433045895.4771628
Csub_18_106 sn_18 sn_106 2.433110118875531e-20
Rsub_18_71 sn_18 sn_71 216522947.7385814
Csub_18_71 sn_18 sn_71 4.866220237751061e-20
Rsub_18_27 sn_18 sn_27 194719126.4469913
Csub_18_27 sn_18 sn_27 5.411118925237355e-20
Rsub_18_100 sn_18 sn_100 89355514.83090691
Csub_18_100 sn_18 sn_100 1.179164321549583e-19
Rsub_18_191 sn_18 sn_191 295258855.5031633
Csub_18_191 sn_18 sn_191 3.568557997786154e-20
Rsub_18_66 sn_18 sn_66 295258855.5031633
Csub_18_66 sn_18 sn_66 3.568557997786154e-20
Rsub_18_117 sn_18 sn_117 226029808.3543235
Csub_18_117 sn_18 sn_117 4.661546005345034e-20
Rsub_18_96 sn_18 sn_96 590517711.0063267
Csub_18_96 sn_18 sn_96 1.784278998893077e-20
Rsub_18_79 sn_18 sn_79 295258855.5031633
Csub_18_79 sn_18 sn_79 3.568557997786154e-20
Rsub_18_154 sn_18 sn_154 261863188.5051451
Csub_18_154 sn_18 sn_154 4.023659668385569e-20
Rsub_18_125 sn_18 sn_125 130931594.2525726
Csub_18_125 sn_18 sn_125 8.047319336771139e-20
Rsub_18_230 sn_18 0 3042966.263419634
Csub_18_230 sn_18 0 3.462569936739712e-18
Rsub_18_229 sn_18 sn_229 111024379.7196288
Csub_18_229 sn_18 sn_229 9.490243069889615e-20
Rsub_18_141 sn_18 sn_141 126019726.0981897
Csub_18_141 sn_18 sn_141 8.36097952952253e-20
Rsub_18_32 sn_18 sn_32 295258855.5031633
Csub_18_32 sn_18 sn_32 3.568557997786154e-20
Rsub_18_199 sn_18 sn_199 168885653.8261035
Csub_18_199 sn_18 sn_199 6.238826841431481e-20
Rsub_18_155 sn_18 sn_155 145002459.6289381
Csub_18_155 sn_18 sn_155 7.26641708643626e-20
Rsub_18_176 sn_18 sn_176 111918790.7183726
Csub_18_176 sn_18 sn_176 9.414400776312473e-20
Rsub_18_97 sn_18 sn_97 1621929.101645687
Csub_18_97 sn_18 sn_97 6.496266385219417e-18
Rsub_18_50 sn_18 sn_50 82470872.72606531
Csub_18_50 sn_18 sn_50 1.277600582356866e-19
Rsub_18_129 sn_18 sn_129 6599162.209041629
Csub_18_129 sn_18 sn_129 1.596639568549138e-18
Rsub_18_43 sn_18 sn_43 63348535.33139755
Csub_18_43 sn_18 sn_43 1.663256055899336e-19
Rsub_18_122 sn_18 sn_122 269928400.3192679
Csub_18_122 sn_18 sn_122 3.903436426018004e-20
Rsub_18_212 sn_18 sn_212 221234019.2176042
Csub_18_212 sn_18 sn_212 4.762596430464157e-20
Rsub_18_45 sn_18 sn_45 144410080.1454098
Csub_18_45 sn_18 sn_45 7.296224399031273e-20
Rsub_18_131 sn_18 sn_131 3661140.233428755
Csub_18_131 sn_18 sn_131 2.877924042904607e-18
Rsub_18_222 sn_18 sn_222 30046231.43783133
Csub_18_222 sn_18 sn_222 3.506757086668604e-19
Rsub_18_169 sn_18 sn_169 590517711.0063267
Csub_18_169 sn_18 sn_169 1.784278998893077e-20
Rsub_18_165 sn_18 sn_165 295258855.5031633
Csub_18_165 sn_18 sn_165 3.568557997786154e-20
Rsub_18_215 sn_18 sn_215 249875631.6997723
Csub_18_215 sn_18 sn_215 4.216691091706645e-20
Rsub_18_48 sn_18 sn_48 1137936.613715924
Csub_18_48 sn_18 sn_48 9.259288588863654e-18
Rsub_18_211 sn_18 sn_211 8764786.138321854
Csub_18_211 sn_18 sn_211 1.202138116771822e-18
Rsub_18_132 sn_18 sn_132 36272326.73400369
Csub_18_132 sn_18 sn_132 2.904827026812293e-19
Rsub_18_61 sn_18 sn_61 3437940.863130219
Csub_18_61 sn_18 sn_61 3.064765777453372e-18
Rsub_18_52 sn_18 sn_52 7019535.586404141
Csub_18_52 sn_18 sn_52 1.501022877159808e-18
Rsub_18_219 sn_18 sn_219 28606517.48256112
Csub_18_219 sn_18 sn_219 3.683245787835995e-19
Rsub_18_140 sn_18 sn_140 2474685310.899105
Rsub_18_34 sn_18 sn_34 14779824.21976001
Csub_18_34 sn_18 sn_34 7.128964015785223e-19
Rsub_18_192 sn_18 sn_192 156484195.5913134
Csub_18_192 sn_18 sn_192 6.733257286728124e-20
Rsub_18_46 sn_18 sn_46 1406858.408590052
Csub_18_46 sn_18 sn_46 7.489370243583807e-18
Rsub_18_166 sn_18 sn_166 80789468.27405924
Csub_18_166 sn_18 sn_166 1.304190227677631e-19
Rsub_18_78 sn_18 sn_78 5628236.083029884
Csub_18_78 sn_18 sn_78 1.872075610687217e-18
Rsub_18_128 sn_18 sn_128 45213226.06718492
Csub_18_128 sn_18 sn_128 2.33039851802949e-19
Rsub_18_110 sn_18 sn_110 5046282.116501145
Csub_18_110 sn_18 sn_110 2.087969570265624e-18
Rsub_18_99 sn_18 sn_99 1342699.799550556
Csub_18_99 sn_18 sn_99 7.847236966712063e-18
Rsub_18_178 sn_18 sn_178 25283416.80039797
Csub_18_178 sn_18 sn_178 4.167349526138474e-19
Rsub_18_20 sn_18 sn_20 102211328.4131262
Csub_18_20 sn_18 sn_20 1.030852809156611e-19
Rsub_18_51 sn_18 sn_51 1101990.171257565
Csub_18_51 sn_18 sn_51 9.561322575323899e-18
Rsub_18_209 sn_18 sn_209 295258855.5031633
Csub_18_209 sn_18 sn_209 3.568557997786154e-20
Rsub_18_105 sn_18 sn_105 2164997.35877203
Csub_18_105 sn_18 sn_105 4.866741966006929e-18
Rsub_18_101 sn_18 sn_101 60729.50283719134
Csub_18_101 sn_18 sn_101 1.734985963984766e-16
Rsub_18_72 sn_18 sn_72 2466260.83894695
Csub_18_72 sn_18 sn_72 4.27225025667962e-18
Rsub_18_76 sn_18 sn_76 27167646.98757097
Csub_18_76 sn_18 sn_76 3.878320234008627e-19
Rsub_18_206 sn_18 sn_206 39177250.7225607
Csub_18_206 sn_18 sn_206 2.689439230140372e-19
Rsub_18_39 sn_18 sn_39 9733478.777852919
Csub_18_39 sn_18 sn_39 1.082499252600643e-18
Rsub_18_118 sn_18 sn_118 153364610.8672665
Csub_18_118 sn_18 sn_118 6.870218261336105e-20
Rsub_18_40 sn_18 sn_40 1308870826.907969
Rsub_18_119 sn_18 sn_119 147629427.7515817
Csub_18_119 sn_18 sn_119 7.137115995572309e-20
Rsub_18_158 sn_18 sn_158 217924848.5039709
Csub_18_158 sn_18 sn_158 4.834916061459607e-20
Rsub_18_204 sn_18 sn_204 432671.4294983178
Csub_18_204 sn_18 sn_204 2.435215913019043e-17
Rsub_18_37 sn_18 sn_37 269347586.724589
Csub_18_37 sn_18 sn_37 3.911853687036623e-20
Rsub_18_214 sn_18 sn_214 295258855.5031633
Csub_18_214 sn_18 sn_214 3.568557997786154e-20
Rsub_18_47 sn_18 sn_47 45808809.85919364
Csub_18_47 sn_18 sn_47 2.30009981368581e-19
Rsub_18_115 sn_18 sn_115 295258855.5031633
Csub_18_115 sn_18 sn_115 3.568557997786154e-20
Rsub_18_177 sn_18 sn_177 16532698.27210417
Csub_18_177 sn_18 sn_177 6.373117883611496e-19
Rsub_18_190 sn_18 sn_190 85365427.37125538
Csub_18_190 sn_18 sn_190 1.234279945253093e-19
Rsub_18_41 sn_18 sn_41 439012536.1648819
Csub_18_41 sn_18 sn_41 2.400041601152083e-20
Rsub_18_150 sn_18 sn_150 538695173.4491781
Csub_18_150 sn_18 sn_150 1.955926843518312e-20
Rsub_18_30 sn_18 sn_30 248258777.6302742
Csub_18_30 sn_18 sn_30 4.244153460677121e-20
Rsub_18_49 sn_18 sn_49 24265540.63811635
Csub_18_49 sn_18 sn_49 4.342158973239309e-19
Rsub_18_216 sn_18 sn_216 79571293.98435041
Csub_18_216 sn_18 sn_216 1.324156360244971e-19
Rsub_18_170 sn_18 sn_170 66829365.96739319
Csub_18_170 sn_18 sn_170 1.576624789074143e-19
Rsub_18_60 sn_18 sn_60 40582929.26298831
Csub_18_60 sn_18 sn_60 2.596284618577125e-19
Rsub_18_227 sn_18 sn_227 76117286.59995285
Csub_18_227 sn_18 sn_227 1.384243182183603e-19
Rsub_18_148 sn_18 sn_148 295258855.5031633
Csub_18_148 sn_18 sn_148 3.568557997786154e-20
Rsub_18_153 sn_18 sn_153 19668946.16916067
Csub_18_153 sn_18 sn_153 5.356913080961276e-19
Rsub_18_68 sn_18 sn_68 590517711.0063267
Csub_18_68 sn_18 sn_68 1.784278998893077e-20
Rsub_18_226 sn_18 sn_226 164973131.7529666
Csub_18_226 sn_18 sn_226 6.386787587937351e-20
Rsub_18_67 sn_18 sn_67 19754235.74423162
Csub_18_67 sn_18 sn_67 5.333784429147926e-19
Rsub_18_181 sn_18 sn_181 42862129.87159174
Csub_18_181 sn_18 sn_181 2.458226768897314e-19
Rsub_18_133 sn_18 sn_133 295258855.5031633
Csub_18_133 sn_18 sn_133 3.568557997786154e-20
Rsub_18_77 sn_18 sn_77 34196256.60002088
Csub_18_77 sn_18 sn_77 3.081180383417631e-19
Rsub_18_53 sn_18 sn_53 295258855.5031633
Csub_18_53 sn_18 sn_53 3.568557997786154e-20
Rsub_18_220 sn_18 sn_220 276774782.5496106
Csub_18_220 sn_18 sn_220 3.806879877266776e-20
Rsub_18_114 sn_18 sn_114 88266074.0559257
Csub_18_114 sn_18 sn_114 1.193718381034377e-19
Rsub_18_35 sn_18 sn_35 295258855.5031633
Csub_18_35 sn_18 sn_35 3.568557997786154e-20
Rsub_18_138 sn_18 sn_138 295258855.5031633
Csub_18_138 sn_18 sn_138 3.568557997786154e-20
Rsub_15_18 sn_15 sn_18 1687707496.87769
Rsub_15_113 sn_15 sn_113 1330609505.800071
Rsub_15_124 sn_15 sn_124 2251835891.223548
Rsub_15_143 sn_15 sn_143 895097840.9184862
Csub_15_143 sn_15 sn_143 1.1771320430645e-20
Rsub_15_174 sn_15 sn_174 1903263448.385977
Rsub_15_21 sn_15 sn_21 330516480.4226149
Csub_15_21 sn_15 sn_21 3.187884455491456e-20
Rsub_15_193 sn_15 sn_193 335031350.5429984
Csub_15_193 sn_15 sn_193 3.144924642172475e-20
Rsub_15_187 sn_15 sn_187 1044458991.145251
Csub_15_187 sn_15 sn_187 1.008798199982627e-20
Rsub_15_42 sn_15 sn_42 675729019.0820333
Csub_15_42 sn_15 sn_42 1.559276456195953e-20
Rsub_15_54 sn_15 sn_54 4455648619.637729
Rsub_15_17 sn_15 sn_17 1151283576.843131
Rsub_15_105 sn_15 sn_105 379670551.9348639
Csub_15_105 sn_15 sn_105 2.775164797094307e-20
Rsub_15_133 sn_15 sn_133 1018292360.018306
Csub_15_133 sn_15 sn_133 1.034720863666363e-20
Rsub_15_95 sn_15 sn_95 1893641412.012507
Rsub_15_74 sn_15 sn_74 1675435080.793605
Rsub_15_23 sn_15 sn_23 1023311465.372591
Csub_15_23 sn_15 sn_23 1.029645797860149e-20
Rsub_15_144 sn_15 sn_144 1764633461.865606
Rsub_15_59 sn_15 sn_59 506723057.6613227
Csub_15_59 sn_15 sn_59 2.079337686123659e-20
Rsub_15_85 sn_15 sn_85 298635483.3436044
Csub_15_85 sn_15 sn_85 3.528208833143555e-20
Rsub_15_106 sn_15 sn_106 1393806029.425259
Rsub_15_94 sn_15 sn_94 796047220.5874959
Csub_15_94 sn_15 sn_94 1.323600312862584e-20
Rsub_15_121 sn_15 sn_121 309084583.3252695
Csub_15_121 sn_15 sn_121 3.408932075768329e-20
Rsub_15_119 sn_15 sn_119 728557055.2508425
Csub_15_119 sn_15 sn_119 1.446212541116946e-20
Rsub_15_88 sn_15 sn_88 276195208.3940471
Csub_15_88 sn_15 sn_88 3.814868318496541e-20
Rsub_15_104 sn_15 sn_104 1880472731.285021
Rsub_15_91 sn_15 sn_91 251302735.4459438
Csub_15_91 sn_15 sn_91 4.192745249482747e-20
Rsub_15_99 sn_15 sn_99 188510440.6435896
Csub_15_99 sn_15 sn_99 5.589336837926647e-20
Rsub_15_123 sn_15 sn_123 1529828397.959921
Rsub_15_56 sn_15 sn_56 366121123.8990631
Csub_15_56 sn_15 sn_56 2.877868228421268e-20
Rsub_15_75 sn_15 sn_75 692995439.8332047
Csub_15_75 sn_15 sn_75 1.520426094689165e-20
Rsub_15_20 sn_15 sn_20 335876263.551065
Csub_15_20 sn_15 sn_20 3.137013431920618e-20
Rsub_15_110 sn_15 sn_110 202625448.4765556
Csub_15_110 sn_15 sn_110 5.199980348692039e-20
Rsub_15_197 sn_15 sn_197 804797936.3713641
Csub_15_197 sn_15 sn_197 1.309208563547816e-20
Rsub_15_108 sn_15 sn_108 688020983.4814196
Csub_15_108 sn_15 sn_108 1.531418918201431e-20
Rsub_15_211 sn_15 sn_211 831770915.0872457
Csub_15_211 sn_15 sn_211 1.266753057976884e-20
Rsub_15_60 sn_15 sn_60 1495719944.877075
Rsub_15_209 sn_15 sn_209 146204405.8976406
Csub_15_209 sn_15 sn_209 7.206679879132174e-20
Rsub_15_28 sn_15 sn_28 35146336.68745479
Csub_15_28 sn_15 sn_28 2.997889537088204e-19
Rsub_15_89 sn_15 sn_89 292239129.1876373
Csub_15_89 sn_15 sn_89 3.605432144394622e-20
Rsub_15_194 sn_15 sn_194 1711880129.519714
Rsub_15_24 sn_15 sn_24 621577199.0997651
Csub_15_24 sn_15 sn_24 1.695120657175017e-20
Rsub_15_208 sn_15 sn_208 264711088.4815165
Csub_15_208 sn_15 sn_208 3.980371038731803e-20
Rsub_15_161 sn_15 sn_161 172648827.431834
Csub_15_161 sn_15 sn_161 6.102841043846687e-20
Rsub_15_45 sn_15 sn_45 50411365.33364265
Csub_15_45 sn_15 sn_45 2.090100800185697e-19
Rsub_15_212 sn_15 sn_212 62829923.82692979
Csub_15_212 sn_15 sn_212 1.676984923816495e-19
Rsub_15_226 sn_15 sn_226 65092191.69125034
Csub_15_226 sn_15 sn_226 1.618701602829316e-19
Rsub_15_126 sn_15 sn_126 1545048.01664173
Csub_15_126 sn_15 sn_126 6.819518480164637e-18
Rsub_15_77 sn_15 sn_77 24929643.6538751
Csub_15_77 sn_15 sn_77 4.226487810463426e-19
Rsub_15_25 sn_15 sn_25 452687600.2512838
Csub_15_25 sn_15 sn_25 2.327539675569039e-20
Rsub_15_192 sn_15 sn_192 339522684.869624
Csub_15_192 sn_15 sn_192 3.103322391043176e-20
Rsub_15_139 sn_15 sn_139 27850034.7001727
Csub_15_139 sn_15 sn_139 3.7832927734789e-19
Rsub_15_150 sn_15 sn_150 9287992.744452711
Csub_15_150 sn_15 sn_150 1.134419867901271e-18
Rsub_15_130 sn_15 sn_130 11221376.84434209
Csub_15_130 sn_15 sn_130 9.389653024212075e-19
Rsub_15_93 sn_15 sn_93 82042314.10495976
Csub_15_93 sn_15 sn_93 1.284274293963757e-19
Rsub_15_200 sn_15 sn_200 453349952.5228564
Csub_15_200 sn_15 sn_200 2.324139099076841e-20
Rsub_15_190 sn_15 sn_190 41320754.09715284
Csub_15_190 sn_15 sn_190 2.549925269383214e-19
Rsub_15_163 sn_15 sn_163 178763055.4766735
Csub_15_163 sn_15 sn_163 5.894105733499779e-20
Rsub_15_84 sn_15 sn_84 205395477.9932258
Csub_15_84 sn_15 sn_84 5.129851740249854e-20
Rsub_15_122 sn_15 sn_122 300205499.5139166
Csub_15_122 sn_15 sn_122 3.509756989558934e-20
Rsub_15_53 sn_15 sn_53 30446729.0749804
Csub_15_53 sn_15 sn_53 3.460629046976463e-19
Rsub_15_220 sn_15 sn_220 103948390.8768016
Csub_15_220 sn_15 sn_220 1.013626417239851e-19
Rsub_15_132 sn_15 sn_132 16142717.12419784
Csub_15_132 sn_15 sn_132 6.527081792467189e-19
Rsub_15_96 sn_15 sn_96 138048762.7874981
Csub_15_96 sn_15 sn_96 7.632436024398906e-20
Rsub_15_158 sn_15 sn_158 29238335.58346579
Csub_15_158 sn_15 sn_158 3.603653659474501e-19
Rsub_15_79 sn_15 sn_79 39968284.63504735
Csub_15_79 sn_15 sn_79 2.636211085474202e-19
Rsub_15_137 sn_15 sn_137 30650528.64914539
Csub_15_137 sn_15 sn_137 3.437618849201736e-19
Rsub_15_66 sn_15 sn_66 43167624.44863445
Csub_15_66 sn_15 sn_66 2.440830051875441e-19
Rsub_15_157 sn_15 sn_157 27430828.45045122
Csub_15_157 sn_15 sn_157 3.841110202436005e-19
Rsub_15_72 sn_15 sn_72 140955090.6330906
Csub_15_72 sn_15 sn_72 7.475064188817922e-20
Rsub_15_138 sn_15 sn_138 53744041.978928
Csub_15_138 sn_15 sn_138 1.960493315028511e-19
Rsub_15_48 sn_15 sn_48 14283381.76283554
Csub_15_48 sn_15 sn_48 7.376742901072115e-19
Rsub_15_215 sn_15 sn_215 32531902.94526756
Csub_15_215 sn_15 sn_215 3.23881560816065e-19
Rsub_15_127 sn_15 sn_127 8661884.098170204
Csub_15_127 sn_15 sn_127 1.216419358977085e-18
Rsub_15_83 sn_15 sn_83 117444732.3651611
Csub_15_83 sn_15 sn_83 8.971439833904e-20
Rsub_15_152 sn_15 sn_152 86604981.90959971
Csub_15_152 sn_15 sn_152 1.216614018028227e-19
Rsub_15_141 sn_15 sn_141 5722914.32138016
Csub_15_141 sn_15 sn_141 1.841104533553279e-18
Rsub_15_165 sn_15 sn_165 22516165.95287642
Csub_15_165 sn_15 sn_165 4.679519383664863e-19
Rsub_15_118 sn_15 sn_118 5609209.89295056
Csub_15_118 sn_15 sn_118 1.878425607761951e-18
Rsub_15_155 sn_15 sn_155 2613408.098208511
Csub_15_155 sn_15 sn_155 4.031702323664165e-18
Rsub_15_214 sn_15 sn_214 189338935.5348931
Csub_15_214 sn_15 sn_214 5.564879443556523e-20
Rsub_15_47 sn_15 sn_47 41844554.58771249
Csub_15_47 sn_15 sn_47 2.518005892533506e-19
Rsub_15_135 sn_15 sn_135 1563868.590694175
Csub_15_135 sn_15 sn_135 6.737448123792188e-18
Rsub_15_219 sn_15 sn_219 6927045.593948023
Csub_15_219 sn_15 sn_219 1.521064551882761e-18
Rsub_15_52 sn_15 sn_52 4425061.534468531
Csub_15_52 sn_15 sn_52 2.381093103487312e-18
Rsub_15_140 sn_15 sn_140 3002750.663265673
Csub_15_140 sn_15 sn_140 3.508943859751225e-18
Rsub_15_213 sn_15 sn_213 322592413.9245648
Csub_15_213 sn_15 sn_213 3.26619072471241e-20
Rsub_15_46 sn_15 sn_46 227747770.4757717
Csub_15_46 sn_15 sn_46 4.626382721648156e-20
Rsub_15_134 sn_15 sn_134 76961351.85885558
Csub_15_134 sn_15 sn_134 1.369061645584597e-19
Rsub_15_55 sn_15 sn_55 1196316.557104316
Csub_15_55 sn_15 sn_55 8.807437663266615e-18
Rsub_15_222 sn_15 sn_222 6948761.781736494
Csub_15_222 sn_15 sn_222 1.5163109390112e-18
Rsub_15_159 sn_15 sn_159 32649892.46226702
Csub_15_159 sn_15 sn_159 3.22711124222135e-19
Rsub_15_80 sn_15 sn_80 2097733.252627767
Csub_15_80 sn_15 sn_80 5.022794718552165e-18
Rsub_15_154 sn_15 sn_154 42244329.57679626
Csub_15_154 sn_15 sn_154 2.494176995536325e-19
Rsub_15_195 sn_15 sn_195 753513.3027412534
Csub_15_195 sn_15 sn_195 1.398314198820202e-17
Rsub_15_198 sn_15 sn_198 80771806.83646184
Csub_15_198 sn_15 sn_198 1.304475399883421e-19
Rsub_15_31 sn_15 sn_31 21109486.70258756
Csub_15_31 sn_15 sn_31 4.991349932226661e-19
Rsub_15_40 sn_15 sn_40 680427131.0060785
Csub_15_40 sn_15 sn_40 1.548510196330762e-20
Rsub_15_207 sn_15 sn_207 439810691.5875539
Csub_15_207 sn_15 sn_207 2.395686076706593e-20
Rsub_15_188 sn_15 sn_188 14342746.13163442
Csub_15_188 sn_15 sn_188 7.34621069461077e-19
Rsub_15_34 sn_15 sn_34 806227.9993367519
Csub_15_34 sn_15 sn_34 1.306886328792587e-17
Rsub_15_201 sn_15 sn_201 2939847399.854002
Rsub_15_185 sn_15 sn_185 39739453.45089271
Csub_15_185 sn_15 sn_185 2.651391145892397e-19
Rsub_15_27 sn_15 sn_27 3548681.971477985
Csub_15_27 sn_15 sn_27 2.969125885868459e-18
Rsub_15_169 sn_15 sn_169 12628821.47625398
Csub_15_169 sn_15 sn_169 8.343204092354771e-19
Rsub_15_90 sn_15 sn_90 529995.4457454716
Csub_15_90 sn_15 sn_90 1.98803283817086e-17
Rsub_15_228 sn_15 sn_228 5409016.285073177
Csub_15_228 sn_15 sn_228 1.947948193705144e-18
Rsub_15_61 sn_15 sn_61 105498055.6129223
Csub_15_61 sn_15 sn_61 9.987372223132619e-20
Rsub_15_70 sn_15 sn_70 465941.9736225049
Csub_15_70 sn_15 sn_70 2.261329542885614e-17
Rsub_15_181 sn_15 sn_181 1208043.109444878
Csub_15_181 sn_15 sn_181 8.721943298092849e-18
Rsub_15_177 sn_15 sn_177 714040.5664843158
Csub_15_177 sn_15 sn_177 1.4756141312962e-17
Rsub_15_19 sn_15 sn_19 463794976.1323439
Csub_15_19 sn_15 sn_19 2.271797678813885e-20
Rsub_15_186 sn_15 sn_186 1186994552.047102
Rsub_15_63 sn_15 sn_63 7284478.316036584
Csub_15_63 sn_15 sn_63 1.446429386581358e-18
Rsub_15_230 sn_15 0 616538.16563696
Csub_15_230 sn_15 0 1.708975062613442e-17
Rsub_15_191 sn_15 sn_191 34189927.55487745
Csub_15_191 sn_15 sn_191 3.081750754024892e-19
Rsub_15_112 sn_15 sn_112 1172703.10722579
Csub_15_112 sn_15 sn_112 8.984783477853722e-18
Rsub_15_35 sn_15 sn_35 24911092.9677197
Csub_15_35 sn_15 sn_35 4.229635173327557e-19
Rsub_15_202 sn_15 sn_202 67948566.51717933
Csub_15_202 sn_15 sn_202 1.550655744822237e-19
Rsub_15_180 sn_15 sn_180 2330879.078438993
Csub_15_180 sn_15 sn_180 4.520390439681823e-18
Rsub_15_170 sn_15 sn_170 58166724.56263292
Csub_15_170 sn_15 sn_170 1.811428025465745e-19
Rsub_15_115 sn_15 sn_115 82368329.55565245
Csub_15_115 sn_15 sn_115 1.279191111325256e-19
Rsub_15_189 sn_15 sn_189 89923180.386718
Csub_15_189 sn_15 sn_189 1.171720512655075e-19
Rsub_15_22 sn_15 sn_22 379509509.3962714
Csub_15_22 sn_15 sn_22 2.776342421298369e-20
Rsub_15_41 sn_15 sn_41 87349398.39702477
Csub_15_41 sn_15 sn_41 1.206245686357113e-19
Rsub_15_44 sn_15 sn_44 34392735.80873165
Csub_15_44 sn_15 sn_44 3.063578181400444e-19
Rsub_15_128 sn_15 sn_128 24811630.19980885
Csub_15_128 sn_15 sn_128 4.246590577636118e-19
Rsub_15_210 sn_15 sn_210 82099.75057012669
Csub_15_210 sn_15 sn_210 1.283375823807176e-16
Rsub_15_43 sn_15 sn_43 96693944.24048987
Csub_15_43 sn_15 sn_43 1.08967356590858e-19
Rsub_15_131 sn_15 sn_131 7968391.425793262
Csub_15_131 sn_15 sn_131 1.322284880248724e-18
Rsub_15_64 sn_15 sn_64 1460600343.82896
Rsub_15_153 sn_15 sn_153 4190737.651894858
Csub_15_153 sn_15 sn_153 2.514231235034694e-18
Rsub_15_87 sn_15 sn_87 133935158.2769885
Csub_15_87 sn_15 sn_87 7.866854108941074e-20
Rsub_15_217 sn_15 sn_217 50566413.0944616
Csub_15_217 sn_15 sn_217 2.083692090745514e-19
Rsub_15_50 sn_15 sn_50 193430354.947035
Csub_15_50 sn_15 sn_50 5.447171673295589e-20
Rsub_15_151 sn_15 sn_151 60321556.341568
Csub_15_151 sn_15 sn_151 1.746719438498512e-19
Rsub_15_205 sn_15 sn_205 303835022.1586386
Csub_15_205 sn_15 sn_205 3.467830478320792e-20
Rsub_15_38 sn_15 sn_38 16026748.01773463
Csub_15_38 sn_15 sn_38 6.574311576229129e-19
Rsub_15_49 sn_15 sn_49 208500951.4817783
Csub_15_49 sn_15 sn_49 5.053446244417175e-20
Rsub_15_216 sn_15 sn_216 25107646.21116855
Csub_15_216 sn_15 sn_216 4.196523805382876e-19
Rsub_15_221 sn_15 sn_221 222345317.2116877
Csub_15_221 sn_15 sn_221 4.738792628674325e-20
Rsub_15_172 sn_15 sn_172 279919853.4220324
Csub_15_172 sn_15 sn_172 3.764107251922659e-20
Rsub_15_101 sn_15 sn_101 96710087.64268841
Csub_15_101 sn_15 sn_101 1.089491671350645e-19
Rsub_15_168 sn_15 sn_168 15289975.13778435
Csub_15_168 sn_15 sn_168 6.891105712914084e-19
Rsub_15_171 sn_15 sn_171 312692177.2607077
Csub_15_171 sn_15 sn_171 3.36960252556788e-20
Rsub_15_76 sn_15 sn_76 182628372.600815
Csub_15_76 sn_15 sn_76 5.769357385262592e-20
Rsub_15_156 sn_15 sn_156 65634411.81674357
Csub_15_156 sn_15 sn_156 1.6053291574622e-19
Rsub_15_166 sn_15 sn_166 92530608.7344249
Csub_15_166 sn_15 sn_166 1.138702494919395e-19
Rsub_15_229 sn_15 sn_229 47459418.89033458
Csub_15_229 sn_15 sn_229 2.22010377467471e-19
Rsub_15_62 sn_15 sn_62 124456450.5868877
Csub_15_62 sn_15 sn_62 8.466000317817264e-20
Rsub_15_129 sn_15 sn_129 222861746.2005838
Csub_15_129 sn_15 sn_129 4.727811606011011e-20
Rsub_15_117 sn_15 sn_117 42285016.9852934
Csub_15_117 sn_15 sn_117 2.491777053298703e-19
Rsub_15_125 sn_15 sn_125 34722838.50266042
Csub_15_125 sn_15 sn_125 3.034453390503402e-19
Rsub_15_183 sn_15 sn_183 82952115.09220178
Csub_15_183 sn_15 sn_183 1.270188649260918e-19
Rsub_15_223 sn_15 sn_223 365902490.2927911
Csub_15_223 sn_15 sn_223 2.87958780870795e-20
Rsub_15_142 sn_15 sn_142 273690726.0638021
Csub_15_142 sn_15 sn_142 3.849777321199318e-20
Rsub_15_145 sn_15 sn_145 85626856.75488448
Csub_15_145 sn_15 sn_145 1.230511535929872e-19
Rsub_15_149 sn_15 sn_149 1621107605.586172
Rsub_15_162 sn_15 sn_162 248076843.5376966
Csub_15_162 sn_15 sn_162 4.247266029337771e-20
Rsub_15_82 sn_15 sn_82 23460509.59748689
Csub_15_82 sn_15 sn_82 4.491157132988567e-19
Rsub_15_164 sn_15 sn_164 147154172.1168658
Csub_15_164 sn_15 sn_164 7.160166341639445e-20
Rsub_15_218 sn_15 sn_218 177223466.3638876
Csub_15_218 sn_15 sn_218 5.945309455010749e-20
Rsub_15_51 sn_15 sn_51 202639932.9241848
Csub_15_51 sn_15 sn_51 5.199608660634572e-20
Rsub_15_37 sn_15 sn_37 8615388.990272561
Csub_15_37 sn_15 sn_37 1.222984071192433e-18
Rsub_15_204 sn_15 sn_204 86990958.99468902
Csub_15_204 sn_15 sn_204 1.211215926803759e-19
Rsub_15_81 sn_15 sn_81 167361507.8727051
Csub_15_81 sn_15 sn_81 6.295643267174691e-20
Rsub_15_136 sn_15 sn_136 83632183.22822259
Csub_15_136 sn_15 sn_136 1.259859912239425e-19
Rsub_15_167 sn_15 sn_167 239420343.9157417
Csub_15_167 sn_15 sn_167 4.400830493309318e-20
Rsub_15_107 sn_15 sn_107 24729292.46566711
Csub_15_107 sn_15 sn_107 4.260729867972695e-19
Rsub_15_147 sn_15 sn_147 455909246.8244606
Csub_15_147 sn_15 sn_147 2.311092300851463e-20
Rsub_15_68 sn_15 sn_68 196366402.7670303
Csub_15_68 sn_15 sn_68 5.365726190304825e-20
Rsub_15_36 sn_15 sn_36 829033330.4698441
Csub_15_36 sn_15 sn_36 1.270936054676907e-20
Rsub_15_203 sn_15 sn_203 231242653.8699909
Csub_15_203 sn_15 sn_203 4.556461935501664e-20
Rsub_15_92 sn_15 sn_92 219625994.8027804
Csub_15_92 sn_15 sn_92 4.797466489197485e-20
Rsub_15_98 sn_15 sn_98 409447547.4545497
Csub_15_98 sn_15 sn_98 2.573341461618986e-20
Rsub_15_29 sn_15 sn_29 1314501601.917614
Rsub_15_196 sn_15 sn_196 223000870.4310795
Csub_15_196 sn_15 sn_196 4.72486205182163e-20
Rsub_15_160 sn_15 sn_160 77315624.58131042
Csub_15_160 sn_15 sn_160 1.362788383239291e-19
Rsub_15_114 sn_15 sn_114 337679910.6401303
Csub_15_114 sn_15 sn_114 3.12025772639429e-20
Rsub_15_97 sn_15 sn_97 45582148.53441879
Csub_15_97 sn_15 sn_97 2.31153726645289e-19
Rsub_15_225 sn_15 sn_225 153414978.0866514
Csub_15_225 sn_15 sn_225 6.867962720223324e-20
Rsub_15_179 sn_15 sn_179 90099607.46927302
Csub_15_179 sn_15 sn_179 1.169426127169677e-19
Rsub_15_227 sn_15 sn_227 114812090.7281842
Csub_15_227 sn_15 sn_227 9.177154980284227e-20
Rsub_15_67 sn_15 sn_67 266951094.1413076
Csub_15_67 sn_15 sn_67 3.946971461616348e-20
Rsub_15_73 sn_15 sn_73 890454291.714932
Csub_15_73 sn_15 sn_73 1.183270562033871e-20
Rsub_15_78 sn_15 sn_78 248343760.0477544
Csub_15_78 sn_15 sn_78 4.242701125328828e-20
Rsub_15_71 sn_15 sn_71 127006565.7158621
Csub_15_71 sn_15 sn_71 8.296014810606029e-20
Rsub_15_146 sn_15 sn_146 1083555803.410182
Rsub_15_184 sn_15 sn_184 271265365.7868651
Csub_15_184 sn_15 sn_184 3.884197848725216e-20
Rsub_15_57 sn_15 sn_57 498078636.3697187
Csub_15_57 sn_15 sn_57 2.115425704468255e-20
Rsub_15_224 sn_15 sn_224 180031095.8576151
Csub_15_224 sn_15 sn_224 5.852590882723507e-20
Rsub_15_32 sn_15 sn_32 1605599312.22656
Rsub_15_199 sn_15 sn_199 697564803.909251
Csub_15_199 sn_15 sn_199 1.510466618037789e-20
Rsub_15_65 sn_15 sn_65 166617176.6735277
Csub_15_65 sn_15 sn_65 6.323767880712172e-20
Rsub_15_109 sn_15 sn_109 449420296.2872895
Csub_15_109 sn_15 sn_109 2.344460984355413e-20
Rsub_15_111 sn_15 sn_111 473059264.2613617
Csub_15_111 sn_15 sn_111 2.227307294928839e-20
Rsub_15_116 sn_15 sn_116 869005389.2581986
Csub_15_116 sn_15 sn_116 1.212476197785628e-20
Rsub_15_30 sn_15 sn_30 277191589.6301822
Csub_15_30 sn_15 sn_30 3.801155553199629e-20
Rsub_15_182 sn_15 sn_182 620690074.0623057
Csub_15_182 sn_15 sn_182 1.697543418613189e-20
Rsub_15_175 sn_15 sn_175 140436220.3933783
Csub_15_175 sn_15 sn_175 7.502682337018242e-20
Rsub_15_206 sn_15 sn_206 169580562.8951794
Csub_15_206 sn_15 sn_206 6.213261309164766e-20
Rsub_15_100 sn_15 sn_100 143667250.9883317
Csub_15_100 sn_15 sn_100 7.333949407221377e-20
Rsub_15_178 sn_15 sn_178 391235219.2178239
Csub_15_178 sn_15 sn_178 2.693132669214965e-20
Rsub_15_103 sn_15 sn_103 816988149.4144193
Csub_15_103 sn_15 sn_103 1.289673970152698e-20
Rsub_15_120 sn_15 sn_120 662216570.8965807
Csub_15_120 sn_15 sn_120 1.591093301692008e-20
Rsub_15_69 sn_15 sn_69 271012651.2298391
Csub_15_69 sn_15 sn_69 3.887819795281169e-20
Rsub_8_81 sn_8 sn_81 242587080.9701163
Csub_8_81 sn_8 sn_81 4.343381955912139e-20
Rsub_8_96 sn_8 sn_96 256908562.612642
Csub_8_96 sn_8 sn_96 4.101258204506229e-20
Rsub_8_153 sn_8 sn_153 295138026.0484641
Csub_8_153 sn_8 sn_153 3.570018964787622e-20
Rsub_8_38 sn_8 sn_38 248951974.3370948
Csub_8_38 sn_8 sn_38 4.232335786967096e-20
Rsub_8_86 sn_8 sn_86 269722595.8119716
Csub_8_86 sn_8 sn_86 3.90641483725567e-20
Rsub_8_184 sn_8 sn_184 295138026.0484641
Csub_8_184 sn_8 sn_184 3.570018964787622e-20
Rsub_8_123 sn_8 sn_123 1707485586.793026
Rsub_8_80 sn_8 sn_80 295138026.0484641
Csub_8_80 sn_8 sn_80 3.570018964787622e-20
Rsub_8_170 sn_8 sn_170 112663824.7889823
Csub_8_170 sn_8 sn_170 9.352144330236151e-20
Rsub_8_13 sn_8 sn_13 79477340.51795977
Csub_8_13 sn_8 sn_13 1.325721700495129e-19
Rsub_8_156 sn_8 sn_156 295138026.0484641
Csub_8_156 sn_8 sn_156 3.570018964787622e-20
Rsub_8_29 sn_8 sn_29 126792881.0023406
Csub_8_29 sn_8 sn_29 8.309996128280655e-20
Rsub_8_158 sn_8 sn_158 28792061.28075846
Csub_8_158 sn_8 sn_158 3.659509959876149e-19
Rsub_8_164 sn_8 sn_164 164948926.8986157
Csub_8_164 sn_8 sn_164 6.387724794782177e-20
Rsub_8_32 sn_8 sn_32 39353724.75376757
Csub_8_32 sn_8 sn_32 2.677378969374755e-19
Rsub_8_190 sn_8 sn_190 71789776.43016441
Csub_8_190 sn_8 sn_190 1.467685794018271e-19
Rsub_8_222 sn_8 sn_222 3527381.315122345
Csub_8_222 sn_8 sn_222 2.987055427508991e-18
Rsub_8_64 sn_8 sn_64 2521281.824797684
Csub_8_64 sn_8 sn_64 4.179018544694218e-18
Rsub_8_44 sn_8 sn_44 5389286.250939474
Csub_8_44 sn_8 sn_44 1.955079580416285e-18
Rsub_8_155 sn_8 sn_155 11250156.54894526
Csub_8_155 sn_8 sn_155 9.36563278598806e-19
Rsub_8_76 sn_8 sn_76 252763309.1401242
Csub_8_76 sn_8 sn_76 4.168517787678155e-20
Rsub_8_33 sn_8 sn_33 177041017.1806228
Csub_8_33 sn_8 sn_33 5.95143637899479e-20
Rsub_8_218 sn_8 sn_218 16986059.0355709
Csub_8_218 sn_8 sn_218 6.20301829880922e-19
Rsub_8_139 sn_8 sn_139 435723857.5520897
Csub_8_139 sn_8 sn_139 2.418156205956749e-20
Rsub_8_142 sn_8 sn_142 113800101.9399184
Csub_8_142 sn_8 sn_142 9.258764555231077e-20
Rsub_8_221 sn_8 sn_221 84734814.89607115
Csub_8_221 sn_8 sn_221 1.243465689416233e-19
Rsub_8_36 sn_8 sn_36 105247955.0314104
Csub_8_36 sn_8 sn_36 1.001110520302791e-19
Rsub_8_203 sn_8 sn_203 140237342.5561153
Csub_8_203 sn_8 sn_203 7.513322279345017e-20
Rsub_8_128 sn_8 sn_128 100036549.8607918
Csub_8_128 sn_8 sn_128 1.053263383922406e-19
Rsub_8_216 sn_8 sn_216 17289746.10888264
Csub_8_216 sn_8 sn_216 6.09406490753318e-19
Rsub_8_49 sn_8 sn_49 70874480.58860593
Csub_8_49 sn_8 sn_49 1.486639960494312e-19
Rsub_8_166 sn_8 sn_166 30205875.39123527
Csub_8_166 sn_8 sn_166 3.488223190276198e-19
Rsub_8_168 sn_8 sn_168 87925196.5899394
Csub_8_168 sn_8 sn_168 1.198346311509482e-19
Rsub_8_177 sn_8 sn_177 74817523.83473845
Csub_8_177 sn_8 sn_177 1.408290860507979e-19
Rsub_8_10 sn_8 sn_10 34383447.19682683
Csub_8_10 sn_8 sn_10 3.064405800242853e-19
Rsub_8_59 sn_8 sn_59 15686648.32418093
Csub_8_59 sn_8 sn_59 6.716848165702826e-19
Rsub_8_226 sn_8 sn_226 3503121.282278197
Csub_8_226 sn_8 sn_226 3.007741569078012e-18
Rsub_8_26 sn_8 sn_26 84667211.95712113
Csub_8_26 sn_8 sn_26 1.244458540522877e-19
Rsub_8_41 sn_8 sn_41 271404124.5452403
Csub_8_41 sn_8 sn_41 3.882212003920256e-20
Rsub_8_208 sn_8 sn_208 88346.91803016594
Csub_8_208 sn_8 sn_208 1.192626040291788e-16
Rsub_8_146 sn_8 sn_146 11496371.23820532
Csub_8_146 sn_8 sn_146 9.165051548800569e-19
Rsub_8_30 sn_8 sn_30 275062821.6451094
Csub_8_30 sn_8 sn_30 3.83057348107348e-20
Rsub_8_197 sn_8 sn_197 136111229.1253191
Csub_8_197 sn_8 sn_197 7.74108320815246e-20
Rsub_8_118 sn_8 sn_118 130796554.1005383
Csub_8_118 sn_8 sn_118 8.055627745461102e-20
Rsub_8_150 sn_8 sn_150 52922945.80290037
Csub_8_150 sn_8 sn_150 1.990910245523893e-19
Rsub_8_229 sn_8 sn_229 142701030.1473738
Csub_8_229 sn_8 sn_229 7.383607176029844e-20
Rsub_8_57 sn_8 sn_57 20929049.1312893
Csub_8_57 sn_8 sn_57 5.034382324841395e-19
Rsub_8_224 sn_8 sn_224 2007625.796489751
Csub_8_224 sn_8 sn_224 5.248230781180735e-18
Rsub_8_66 sn_8 sn_66 85689515.10126099
Csub_8_66 sn_8 sn_66 1.229611754691205e-19
Rsub_8_107 sn_8 sn_107 92551502.98454903
Csub_8_107 sn_8 sn_107 1.138445423624186e-19
Rsub_8_9 sn_8 sn_9 164373.3353761612
Csub_8_9 sn_8 sn_9 6.410092901088684e-17
Rsub_8_120 sn_8 sn_120 4592174.74736502
Csub_8_120 sn_8 sn_120 2.294443064971736e-18
Rsub_8_52 sn_8 sn_52 1232057.260274305
Csub_8_52 sn_8 sn_52 8.551943032164074e-18
Rsub_8_131 sn_8 sn_131 272717496.8807288
Csub_8_131 sn_8 sn_131 3.863515770987756e-20
Rsub_8_27 sn_8 sn_27 45388214.0989231
Csub_8_27 sn_8 sn_27 2.32141398629738e-19
Rsub_8_130 sn_8 sn_130 68334300.06733088
Csub_8_130 sn_8 sn_130 1.541902601160506e-19
Rsub_8_56 sn_8 sn_56 5419781.181322377
Csub_8_56 sn_8 sn_56 1.944079133405012e-18
Rsub_8_214 sn_8 sn_214 445265990.2646458
Csub_8_214 sn_8 sn_214 2.366334670197379e-20
Rsub_8_93 sn_8 sn_93 143156.4277230072
Csub_8_93 sn_8 sn_93 7.360119045871275e-17
Rsub_8_186 sn_8 sn_186 20746346.42181743
Csub_8_186 sn_8 sn_186 5.078717615140922e-19
Rsub_8_19 sn_8 sn_19 1408412289.865761
Rsub_8_42 sn_8 sn_42 20359773.81241622
Csub_8_42 sn_8 sn_42 5.175147621632429e-19
Rsub_8_162 sn_8 sn_162 42082355.9218211
Csub_8_162 sn_8 sn_162 2.503777003788537e-19
Rsub_8_25 sn_8 sn_25 57457065.4561776
Csub_8_25 sn_8 sn_25 1.833801190258517e-19
Rsub_8_192 sn_8 sn_192 73079949.85507074
Csub_8_192 sn_8 sn_192 1.441774867542402e-19
Rsub_8_202 sn_8 sn_202 295138026.0484641
Csub_8_202 sn_8 sn_202 3.570018964787622e-20
Rsub_8_35 sn_8 sn_35 85162568.11536764
Csub_8_35 sn_8 sn_35 1.237220029339238e-19
Rsub_8_141 sn_8 sn_141 38800469.88902276
Csub_8_141 sn_8 sn_141 2.715555644652369e-19
Rsub_8_74 sn_8 sn_74 6764893.912878721
Csub_8_74 sn_8 sn_74 1.557523833769379e-18
Rsub_8_171 sn_8 sn_171 18493794.1410016
Csub_8_171 sn_8 sn_171 5.697307660016681e-19
Rsub_8_160 sn_8 sn_160 4641917.861276349
Csub_8_160 sn_8 sn_160 2.26985565387253e-18
Rsub_8_45 sn_8 sn_45 1165906.059528722
Csub_8_45 sn_8 sn_45 9.037163342721641e-18
Rsub_8_212 sn_8 sn_212 48901424.76821693
Csub_8_212 sn_8 sn_212 2.154637324407386e-19
Rsub_8_101 sn_8 sn_101 214760714.4235784
Csub_8_101 sn_8 sn_101 4.906150331316465e-20
Rsub_8_78 sn_8 sn_78 62982345.74148758
Csub_8_78 sn_8 sn_78 1.672926496811857e-19
Rsub_8_215 sn_8 sn_215 99150540.85132208
Csub_8_215 sn_8 sn_215 1.062675343146099e-19
Rsub_8_230 sn_8 0 2288237.553623508
Csub_8_230 sn_8 0 4.604628346189447e-18
Rsub_8_227 sn_8 sn_227 146626604.511243
Csub_8_227 sn_8 sn_227 7.185928868333089e-20
Rsub_8_148 sn_8 sn_148 72089313.46910834
Csub_8_148 sn_8 sn_148 1.461587438579934e-19
Rsub_8_213 sn_8 sn_213 215920728.9973069
Csub_8_213 sn_8 sn_213 4.879792482713145e-20
Rsub_8_21 sn_8 sn_21 291392312.9527864
Csub_8_21 sn_8 sn_21 3.615909903545466e-20
Rsub_8_116 sn_8 sn_116 721094624.7760516
Csub_8_116 sn_8 sn_116 1.461179038118928e-20
Rsub_8_31 sn_8 sn_31 116030028.5981705
Csub_8_31 sn_8 sn_31 9.080824705059272e-20
Rsub_8_181 sn_8 sn_181 123428813.7506183
Csub_8_181 sn_8 sn_181 8.536486078136045e-20
Rsub_8_207 sn_8 sn_207 16523428.66956441
Csub_8_207 sn_8 sn_207 6.376693186952078e-19
Rsub_8_40 sn_8 sn_40 1788632857.065308
Rsub_8_144 sn_8 sn_144 10627077.07865688
Csub_8_144 sn_8 sn_144 9.914752122567339e-19
Rsub_27_30 sn_27 sn_30 138670878.8225313
Csub_27_30 sn_27 sn_30 7.598194798862144e-20
Rsub_27_88 sn_27 sn_88 202147677.7118973
Csub_27_88 sn_27 sn_88 5.212270366640912e-20
Rsub_27_199 sn_27 sn_199 107600538.9115546
Csub_27_199 sn_27 sn_199 9.792221868787077e-20
Rsub_27_42 sn_27 sn_42 43892456.258495
Csub_27_42 sn_27 sn_42 2.400522641106638e-19
Rsub_27_201 sn_27 sn_201 23608497.21092066
Csub_27_201 sn_27 sn_201 4.463004742782233e-19
Rsub_27_193 sn_27 sn_193 68696163.93901634
Csub_27_193 sn_27 sn_193 1.533780475949655e-19
Rsub_27_109 sn_27 sn_109 191369690.3527215
Csub_27_109 sn_27 sn_109 5.505826697430387e-20
Rsub_27_92 sn_27 sn_92 29118592.76641556
Csub_27_92 sn_27 sn_92 3.618472769873152e-19
Rsub_27_31 sn_27 sn_31 47321314.40498114
Csub_27_31 sn_27 sn_31 2.226583017550524e-19
Rsub_27_81 sn_27 sn_81 81894150.31436312
Csub_27_81 sn_27 sn_81 1.286597817033831e-19
Rsub_27_174 sn_27 sn_174 57273161.52745926
Csub_27_174 sn_27 sn_174 1.839689519702583e-19
Rsub_27_40 sn_27 sn_40 292420466.3229434
Csub_27_40 sn_27 sn_40 3.603196327097609e-20
Rsub_27_120 sn_27 sn_120 181466312.2517745
Csub_27_120 sn_27 sn_120 5.8063027630226e-20
Rsub_27_86 sn_27 sn_86 31554300.6488331
Csub_27_86 sn_27 sn_86 3.339159254229786e-19
Rsub_27_66 sn_27 sn_66 6161866.23637028
Csub_27_66 sn_27 sn_66 1.709950053774072e-18
Rsub_27_87 sn_27 sn_87 12539889.89229755
Csub_27_87 sn_27 sn_87 8.402373220758414e-19
Rsub_27_99 sn_27 sn_99 7012705.850831768
Csub_27_99 sn_27 sn_99 1.5024847364702e-18
Rsub_27_221 sn_27 sn_221 5573102.014987063
Csub_27_221 sn_27 sn_221 1.890595843014451e-18
Rsub_27_230 sn_27 0 134963.5325908538
Csub_27_230 sn_27 0 7.806911467093618e-17
Rsub_27_63 sn_27 sn_63 194221265.4836245
Csub_27_63 sn_27 sn_63 5.424989625102805e-20
Rsub_27_72 sn_27 sn_72 2279649.005028146
Csub_27_72 sn_27 sn_72 4.621976224844275e-18
Rsub_27_170 sn_27 sn_170 8264459.731940852
Csub_27_170 sn_27 sn_170 1.27491497859299e-18
Rsub_27_104 sn_27 sn_104 70213593.71874414
Csub_27_104 sn_27 sn_104 1.500632989166768e-19
Rsub_27_183 sn_27 sn_183 9507976.814704167
Csub_27_183 sn_27 sn_183 1.108173032767102e-18
Rsub_27_105 sn_27 sn_105 13392107.43526581
Csub_27_105 sn_27 sn_105 7.86768143338216e-19
Rsub_27_43 sn_27 sn_43 9202482.579035787
Csub_27_43 sn_27 sn_43 1.144960983271319e-18
Rsub_27_210 sn_27 sn_210 5288028.660751954
Csub_27_210 sn_27 sn_210 1.992516337975317e-18
Rsub_27_122 sn_27 sn_122 61924344.88359549
Csub_27_122 sn_27 sn_122 1.701509078866533e-19
Rsub_27_225 sn_27 sn_225 24848923.4302045
Csub_27_225 sn_27 sn_225 4.240217300288607e-19
Rsub_27_58 sn_27 sn_58 194269597.2655042
Csub_27_58 sn_27 sn_58 5.423639957326936e-20
Rsub_27_94 sn_27 sn_94 407481519.2453588
Csub_27_94 sn_27 sn_94 2.585757391339659e-20
Rsub_27_150 sn_27 sn_150 3054538.048773599
Csub_27_150 sn_27 sn_150 3.449452366933328e-18
Rsub_27_229 sn_27 sn_229 7169768.306082497
Csub_27_229 sn_27 sn_229 1.469570989245404e-18
Rsub_27_62 sn_27 sn_62 882834673.3817647
Csub_27_62 sn_27 sn_62 1.193483199053477e-20
Rsub_27_179 sn_27 sn_179 28362525.44238724
Csub_27_179 sn_27 sn_179 3.714931353215617e-19
Rsub_27_160 sn_27 sn_160 7578929.983381422
Csub_27_160 sn_27 sn_160 1.390233651100314e-18
Rsub_27_223 sn_27 sn_223 10114287.10055487
Csub_27_223 sn_27 sn_223 1.041742576365266e-18
Rsub_27_215 sn_27 sn_215 2603896.868770221
Csub_27_215 sn_27 sn_215 4.046428884568772e-18
Rsub_27_48 sn_27 sn_48 144613.1715911103
Csub_27_48 sn_27 sn_48 7.285977747602143e-17
Rsub_27_185 sn_27 sn_185 14571721.13183712
Csub_27_185 sn_27 sn_185 7.230774873401398e-19
Rsub_27_212 sn_27 sn_212 15805033.28880275
Csub_27_212 sn_27 sn_212 6.666536735290958e-19
Rsub_27_45 sn_27 sn_45 5285660.397509009
Csub_27_45 sn_27 sn_45 1.993409093629164e-18
Rsub_27_41 sn_27 sn_41 6111442.142761567
Csub_27_41 sn_27 sn_41 1.724058455615011e-18
Rsub_27_208 sn_27 sn_208 194269597.2655042
Csub_27_208 sn_27 sn_208 5.423639957326936e-20
Rsub_27_191 sn_27 sn_191 17762955.28468206
Csub_27_191 sn_27 sn_191 5.931717629957764e-19
Rsub_27_200 sn_27 sn_200 105039361.9920663
Csub_27_200 sn_27 sn_200 1.003098581560866e-19
Rsub_27_112 sn_27 sn_112 732049.2455041871
Csub_27_112 sn_27 sn_112 1.439313484296151e-17
Rsub_27_69 sn_27 sn_69 31986043.89505029
Csub_27_69 sn_27 sn_69 3.294087739265711e-19
Rsub_27_148 sn_27 sn_148 30393722.29902378
Csub_27_148 sn_27 sn_148 3.466664398183445e-19
Rsub_27_77 sn_27 sn_77 7486734.780150308
Csub_27_77 sn_27 sn_77 1.407353647703073e-18
Rsub_27_195 sn_27 sn_195 53995.36908370076
Csub_27_195 sn_27 sn_195 1.951367993410121e-16
Rsub_27_28 sn_27 sn_28 18076180.39406771
Csub_27_28 sn_27 sn_28 5.828932480496761e-19
Rsub_27_205 sn_27 sn_205 78843505.18999964
Csub_27_205 sn_27 sn_205 1.336379385573846e-19
Rsub_27_38 sn_27 sn_38 1975813.214039194
Csub_27_38 sn_27 sn_38 5.332732581887161e-18
Rsub_27_126 sn_27 sn_126 4947637.012116246
Csub_27_126 sn_27 sn_126 2.129599135188627e-18
Rsub_27_47 sn_27 sn_47 14637741.33411918
Csub_27_47 sn_27 sn_47 7.198162108296356e-19
Rsub_27_214 sn_27 sn_214 77804139.25579011
Csub_27_214 sn_27 sn_214 1.354231741783055e-19
Rsub_27_50 sn_27 sn_50 2240270.986465119
Csub_27_50 sn_27 sn_50 4.703218300771424e-18
Rsub_27_217 sn_27 sn_217 8682330.007874897
Csub_27_217 sn_27 sn_217 1.213554828332185e-18
Rsub_27_138 sn_27 sn_138 5943109.73297771
Csub_27_138 sn_27 sn_138 1.772890620505311e-18
Rsub_27_80 sn_27 sn_80 4545723.490219236
Csub_27_80 sn_27 sn_80 2.317889225972659e-18
Rsub_27_159 sn_27 sn_159 15233342.37079443
Csub_27_159 sn_27 sn_159 6.916724672604147e-19
Rsub_27_134 sn_27 sn_134 16323158.42564745
Csub_27_134 sn_27 sn_134 6.454929387730963e-19
Rsub_27_176 sn_27 sn_176 15590978.46949339
Csub_27_176 sn_27 sn_176 6.758064301638645e-19
Rsub_27_97 sn_27 sn_97 164685.7649646041
Csub_27_97 sn_27 sn_97 6.397932149445101e-17
Rsub_27_52 sn_27 sn_52 745715.1725527645
Csub_27_52 sn_27 sn_52 1.412936720351425e-17
Rsub_27_34 sn_27 sn_34 337187.569032975
Csub_27_34 sn_27 sn_34 3.124813744601478e-17
Rsub_27_182 sn_27 sn_182 13950663.70753731
Csub_27_182 sn_27 sn_182 7.552675430443725e-19
Rsub_27_177 sn_27 sn_177 213654.1203177448
Csub_27_177 sn_27 sn_177 4.931561107532223e-17
Rsub_27_153 sn_27 sn_153 227601.972491454
Csub_27_153 sn_27 sn_153 4.629346304380392e-17
Rsub_27_181 sn_27 sn_181 116879.0422609459
Csub_27_181 sn_27 sn_181 9.014861260332792e-17
Rsub_27_222 sn_27 sn_222 926955.348461359
Csub_27_222 sn_27 sn_222 1.136676488216975e-17
Rsub_27_141 sn_27 sn_141 1030605.431576916
Csub_27_141 sn_27 sn_141 1.022358623329615e-17
Rsub_27_49 sn_27 sn_49 14634782.60525612
Csub_27_49 sn_27 sn_49 7.199617368040573e-19
Rsub_27_137 sn_27 sn_137 15240308.49470691
Csub_27_137 sn_27 sn_137 6.913563138101447e-19
Rsub_27_53 sn_27 sn_53 4649615.599832867
Csub_27_53 sn_27 sn_53 2.266097761416824e-18
Rsub_27_220 sn_27 sn_220 9499583.978704456
Csub_27_220 sn_27 sn_220 1.109152098223459e-18
Rsub_27_44 sn_27 sn_44 6429713.671442094
Csub_27_44 sn_27 sn_44 1.638717373843308e-18
Rsub_27_207 sn_27 sn_207 57621017.28903605
Csub_27_207 sn_27 sn_207 1.82858338813724e-19
Rsub_27_128 sn_27 sn_128 5789705.010138921
Csub_27_128 sn_27 sn_128 1.819865344396395e-18
Rsub_27_131 sn_27 sn_131 469994.3380796643
Csub_27_131 sn_27 sn_131 2.241832007015383e-17
Rsub_27_204 sn_27 sn_204 2897803.603950789
Csub_27_204 sn_27 sn_204 3.636024017592095e-18
Rsub_27_37 sn_27 sn_37 5424973.814682313
Csub_27_37 sn_27 sn_37 1.942218315176701e-18
Rsub_27_36 sn_27 sn_36 13384773.03286631
Csub_27_36 sn_27 sn_36 7.871992656399675e-19
Rsub_27_203 sn_27 sn_203 41150233.37886774
Csub_27_203 sn_27 sn_203 2.560491797269101e-19
Rsub_27_115 sn_27 sn_115 38333511.81706016
Csub_27_115 sn_27 sn_115 2.748635072234834e-19
Rsub_27_189 sn_27 sn_189 13952441.26378085
Csub_27_189 sn_27 sn_189 7.551713211351524e-19
Rsub_27_117 sn_27 sn_117 5383030.833600094
Csub_27_117 sn_27 sn_117 1.957351504743909e-18
Rsub_27_75 sn_27 sn_75 25751562.60481683
Csub_27_75 sn_27 sn_75 4.091589960548318e-19
Rsub_27_154 sn_27 sn_154 19730746.57606043
Csub_27_154 sn_27 sn_154 5.340134222297526e-19
Rsub_27_206 sn_27 sn_206 4249066.492879782
Csub_27_206 sn_27 sn_206 2.479717255516271e-18
Rsub_27_39 sn_27 sn_39 788325.4998014607
Csub_27_39 sn_27 sn_39 1.33656509968073e-17
Rsub_27_127 sn_27 sn_127 1755550.819608947
Csub_27_127 sn_27 sn_127 6.001810591035482e-18
Rsub_27_169 sn_27 sn_169 2390369.721364
Csub_27_169 sn_27 sn_169 4.407888624115285e-18
Rsub_27_107 sn_27 sn_107 75428387.89297195
Csub_27_107 sn_27 sn_107 1.396885681446698e-19
Rsub_27_68 sn_27 sn_68 193382851.8030611
Csub_27_68 sn_27 sn_68 5.448509732889985e-20
Rsub_27_96 sn_27 sn_96 20257793.92309221
Csub_27_96 sn_27 sn_96 5.201199865213005e-19
Rsub_27_83 sn_27 sn_83 23165010.0225744
Csub_27_83 sn_27 sn_83 4.548447633720923e-19
Rsub_27_118 sn_27 sn_118 15002349.29120143
Csub_27_118 sn_27 sn_118 7.023222361853307e-19
Rsub_27_166 sn_27 sn_166 11227116.0186153
Csub_27_166 sn_27 sn_166 9.384853140165131e-19
Rsub_27_61 sn_27 sn_61 507903.0376866787
Csub_27_61 sn_27 sn_61 2.074506888208429e-17
Rsub_27_228 sn_27 sn_228 12990016.20381674
Csub_27_228 sn_27 sn_228 8.111216596584507e-19
Rsub_27_79 sn_27 sn_79 10391518.299197
Csub_27_79 sn_27 sn_79 1.013950339003321e-18
Rsub_27_168 sn_27 sn_168 22913437.56968601
Csub_27_168 sn_27 sn_168 4.598386195954092e-19
Rsub_27_35 sn_27 sn_35 2566221.384726478
Csub_27_35 sn_27 sn_35 4.105835749378667e-18
Rsub_27_202 sn_27 sn_202 8263334.756249138
Csub_27_202 sn_27 sn_202 1.275088546335581e-18
Rsub_27_157 sn_27 sn_157 8709045.968202244
Csub_27_157 sn_27 sn_157 1.209832114872277e-18
Rsub_27_139 sn_27 sn_139 4683267.321713539
Csub_27_139 sn_27 sn_139 2.249814665368036e-18
Rsub_27_46 sn_27 sn_46 7176316.116512149
Csub_27_46 sn_27 sn_46 1.468230124086419e-18
Rsub_27_213 sn_27 sn_213 76122683.66003907
Csub_27_213 sn_27 sn_213 1.384145040036361e-19
Rsub_27_125 sn_27 sn_125 26881804.58107004
Csub_27_125 sn_27 sn_125 3.919559592978261e-19
Rsub_27_151 sn_27 sn_151 14699671.96390612
Csub_27_151 sn_27 sn_151 7.167835804840749e-19
Rsub_27_67 sn_27 sn_67 18653790.77875743
Csub_27_67 sn_27 sn_67 5.648440913269351e-19
Rsub_27_218 sn_27 sn_218 74962518.66374771
Csub_27_218 sn_27 sn_218 1.405566900639039e-19
Rsub_27_51 sn_27 sn_51 3954252.064330054
Csub_27_51 sn_27 sn_51 2.664595815040722e-18
Rsub_27_209 sn_27 sn_209 24066227.93300761
Csub_27_209 sn_27 sn_209 4.378120049207577e-19
Rsub_27_110 sn_27 sn_110 399976.4989424745
Csub_27_110 sn_27 sn_110 2.63427564621625e-17
Rsub_27_178 sn_27 sn_178 17506529.87900918
Csub_27_178 sn_27 sn_178 6.018601958840248e-19
Rsub_27_227 sn_27 sn_227 7547453.357745403
Csub_27_227 sn_27 sn_227 1.396031615275525e-18
Rsub_27_60 sn_27 sn_60 3797441.302796944
Csub_27_60 sn_27 sn_60 2.774627087578556e-18
Rsub_27_82 sn_27 sn_82 9736303.26367965
Csub_27_82 sn_27 sn_82 1.082185221318583e-18
Rsub_27_180 sn_27 sn_180 1298398.783137971
Csub_27_180 sn_27 sn_180 8.114982576281704e-18
Rsub_27_70 sn_27 sn_70 31652935.10448262
Csub_27_70 sn_27 sn_70 3.328754021530801e-19
Rsub_27_130 sn_27 sn_130 3743630.896775429
Csub_27_130 sn_27 sn_130 2.814509173782486e-18
Rsub_27_226 sn_27 sn_226 20997716.27819467
Csub_27_226 sn_27 sn_226 5.017918788231146e-19
Rsub_27_84 sn_27 sn_84 90776428.1978462
Csub_27_84 sn_27 sn_84 1.16070699314869e-19
Rsub_27_155 sn_27 sn_155 2124341.55592469
Csub_27_155 sn_27 sn_155 4.959882026901106e-18
Rsub_27_158 sn_27 sn_158 28730481.79775451
Csub_27_158 sn_27 sn_158 3.667353571165487e-19
Rsub_27_192 sn_27 sn_192 28089646.24205931
Csub_27_192 sn_27 sn_192 3.751020362247735e-19
Rsub_27_132 sn_27 sn_132 6715894.112113357
Csub_27_132 sn_27 sn_132 1.568887675466101e-18
Rsub_27_165 sn_27 sn_165 17878623.64353747
Csub_27_165 sn_27 sn_165 5.893341519070787e-19
Rsub_27_136 sn_27 sn_136 27957226.03978991
Csub_27_136 sn_27 sn_136 3.768787177681374e-19
Rsub_27_149 sn_27 sn_149 1148981379.307055
Rsub_27_156 sn_27 sn_156 26306734.68249608
Csub_27_156 sn_27 sn_156 4.005241862738953e-19
Rsub_27_90 sn_27 sn_90 1780000148.03496
Rsub_27_145 sn_27 sn_145 39077228.00558521
Csub_27_145 sn_27 sn_145 2.696323163128165e-19
Rsub_27_140 sn_27 sn_140 27472264.02989357
Csub_27_140 sn_27 sn_140 3.835316772860391e-19
Rsub_27_188 sn_27 sn_188 7496790.698194359
Csub_27_188 sn_27 sn_188 1.405465875520277e-18
Rsub_27_103 sn_27 sn_103 64535902.52458818
Csub_27_103 sn_27 sn_103 1.632654551970603e-19
Rsub_27_152 sn_27 sn_152 9658076.826104645
Csub_27_152 sn_27 sn_152 1.090950475124729e-18
Rsub_27_167 sn_27 sn_167 15308042.35112065
Csub_27_167 sn_27 sn_167 6.882972532055128e-19
Rsub_27_187 sn_27 sn_187 4534574726.314437
Rsub_27_98 sn_27 sn_98 80299593.21647368
Csub_27_98 sn_27 sn_98 1.312146560173161e-19
Rsub_27_133 sn_27 sn_133 15209707.71015861
Csub_27_133 sn_27 sn_133 6.927472705601472e-19
Rsub_27_129 sn_27 sn_129 2382368.128860653
Csub_27_129 sn_27 sn_129 4.422693275060302e-18
Rsub_27_119 sn_27 sn_119 90237144.00556579
Csub_27_119 sn_27 sn_119 1.167643725690179e-19
Rsub_27_57 sn_27 sn_57 191418022.1346012
Csub_27_57 sn_27 sn_57 5.504436512681635e-20
Rsub_27_224 sn_27 sn_224 37061269.55998469
Csub_27_224 sn_27 sn_224 2.842990439163561e-19
Rsub_27_93 sn_27 sn_93 16194906.96542838
Csub_27_93 sn_27 sn_93 6.50604756465873e-19
Rsub_27_121 sn_27 sn_121 40164421.16415035
Csub_27_121 sn_27 sn_121 2.623337570126512e-19
Rsub_27_196 sn_27 sn_196 30531815.4756911
Csub_27_196 sn_27 sn_196 3.450984927712198e-19
Rsub_27_71 sn_27 sn_71 56521117.78952489
Csub_27_71 sn_27 sn_71 1.864167573873201e-19
Rsub_27_85 sn_27 sn_85 60525669.29966928
Csub_27_85 sn_27 sn_85 1.740828911789923e-19
Rsub_27_146 sn_27 sn_146 72267659.21777618
Csub_27_146 sn_27 sn_146 1.457980459900971e-19
Rsub_27_162 sn_27 sn_162 8129198.875641797
Csub_27_162 sn_27 sn_162 1.296128150315199e-18
Rsub_27_101 sn_27 sn_101 6439112.1475092
Csub_27_101 sn_27 sn_101 1.636325515204105e-18
Rsub_27_95 sn_27 sn_95 143917256.9169842
Csub_27_95 sn_27 sn_95 7.321209233655532e-20
Rsub_27_76 sn_27 sn_76 34242424.12874247
Csub_27_76 sn_27 sn_76 3.077026165733947e-19
Rsub_27_114 sn_27 sn_114 98451446.11913815
Csub_27_114 sn_27 sn_114 1.070221303756126e-19
Rsub_27_65 sn_27 sn_65 48479060.34216762
Csub_27_65 sn_27 sn_65 2.1734091848858e-19
Rsub_27_144 sn_27 sn_144 194269597.2655042
Csub_27_144 sn_27 sn_144 5.423639957326936e-20
Rsub_27_89 sn_27 sn_89 37142875.4414138
Csub_27_89 sn_27 sn_89 2.836744160760899e-19
Rsub_27_73 sn_27 sn_73 194269597.2655042
Csub_27_73 sn_27 sn_73 5.423639957326936e-20
Rsub_27_78 sn_27 sn_78 6950926.489104851
Csub_27_78 sn_27 sn_78 1.515838718585974e-18
Rsub_27_175 sn_27 sn_175 42176354.74568091
Csub_27_175 sn_27 sn_175 2.498196813300703e-19
Rsub_110_171 sn_110 sn_171 16311976.38440295
Csub_110_171 sn_110 sn_171 6.459354313622405e-19
Rsub_110_132 sn_110 sn_132 25374368.90400271
Csub_110_132 sn_110 sn_132 4.152412043070719e-19
Rsub_110_228 sn_110 sn_228 51183357.01061549
Csub_110_228 sn_110 sn_228 2.0585760914519e-19
Rsub_110_149 sn_110 sn_149 139968840.3236473
Csub_110_149 sn_110 sn_149 7.527735085799592e-20
Rsub_110_145 sn_110 sn_145 69984420.16182363
Csub_110_145 sn_110 sn_145 1.505547017159918e-19
Rsub_110_176 sn_110 sn_176 15518517.10259072
Csub_110_176 sn_110 sn_176 6.78962006007069e-19
Rsub_110_148 sn_110 sn_148 12386389.59260452
Csub_110_148 sn_110 sn_148 8.506500964995453e-19
Rsub_110_117 sn_110 sn_117 32533548.94800583
Csub_110_117 sn_110 sn_117 3.238651743487654e-19
Rsub_110_190 sn_110 sn_190 17018205.0446719
Csub_110_190 sn_110 sn_190 6.191301300326491e-19
Rsub_110_172 sn_110 sn_172 33131436.47854289
Csub_110_172 sn_110 sn_172 3.180207266006654e-19
Rsub_110_135 sn_110 sn_135 33131436.47854289
Csub_110_135 sn_110 sn_135 3.180207266006654e-19
Rsub_110_218 sn_110 sn_218 8340988.902048144
Csub_110_218 sn_110 sn_218 1.263217542423866e-18
Rsub_110_146 sn_110 sn_146 12263703.71081933
Csub_110_146 sn_110 sn_146 8.591599854890868e-19
Rsub_110_154 sn_110 sn_154 19260728.55152447
Csub_110_154 sn_110 sn_154 5.470449092329921e-19
Rsub_110_160 sn_110 sn_160 3811244.883781989
Csub_110_160 sn_110 sn_160 2.764577932807718e-18
Rsub_110_138 sn_110 sn_138 1953545.913502787
Csub_110_138 sn_110 sn_138 5.393517208580809e-18
Rsub_110_217 sn_110 sn_217 8613682.367957374
Csub_110_217 sn_110 sn_217 1.223226380093302e-18
Rsub_110_221 sn_110 sn_221 16145386.61752128
Csub_110_221 sn_110 sn_221 6.526002598659117e-19
Rsub_110_206 sn_110 sn_206 1850232.957734191
Csub_110_206 sn_110 sn_206 5.69467939601133e-18
Rsub_110_127 sn_110 sn_127 28339.41865066552
Csub_110_127 sn_110 sn_127 3.717960354836906e-16
Rsub_110_210 sn_110 sn_210 4505652.309610344
Csub_110_210 sn_110 sn_210 2.338503457036883e-18
Rsub_110_131 sn_110 sn_131 86726.72725654684
Csub_110_131 sn_110 sn_131 1.214906158174511e-16
Rsub_110_144 sn_110 sn_144 37729391.65466809
Csub_110_144 sn_110 sn_144 2.792646008891153e-19
Rsub_110_181 sn_110 sn_181 7290209.462396597
Csub_110_181 sn_110 sn_181 1.445292286398342e-18
Rsub_110_150 sn_110 sn_150 4155339.572340417
Csub_110_150 sn_110 sn_150 2.535649209601305e-18
Rsub_110_229 sn_110 sn_229 7377226.542269287
Csub_110_229 sn_110 sn_229 1.428244536325288e-18
Rsub_110_139 sn_110 sn_139 5539665.895565512
Csub_110_139 sn_110 sn_139 1.902007034515282e-18
Rsub_110_180 sn_110 sn_180 14100040.29749104
Csub_110_180 sn_110 sn_180 7.4726619782107e-19
Rsub_110_183 sn_110 sn_183 9088220.681473603
Csub_110_183 sn_110 sn_183 1.159356035852946e-18
Rsub_110_226 sn_110 sn_226 4488350.003694906
Csub_110_226 sn_110 sn_226 2.347518240234416e-18
Rsub_110_114 sn_110 sn_114 4734455.322687819
Csub_110_114 sn_110 sn_114 2.22549011113031e-18
Rsub_110_188 sn_110 sn_188 3202080.555066535
Csub_110_188 sn_110 sn_188 3.290511691081134e-18
Rsub_110_204 sn_110 sn_204 715120.279004586
Csub_110_204 sn_110 sn_204 1.473386199716822e-17
Rsub_110_125 sn_110 sn_125 16453859.50360319
Csub_110_125 sn_110 sn_125 6.403654716951146e-19
Rsub_110_133 sn_110 sn_133 12228847.67199378
Csub_110_133 sn_110 sn_133 8.616088600367808e-19
Rsub_110_212 sn_110 sn_212 102424638.8823534
Csub_110_212 sn_110 sn_212 1.028705945874252e-19
Rsub_110_153 sn_110 sn_153 46607.60684341432
Csub_110_153 sn_110 sn_153 2.260678935442662e-16
Rsub_110_227 sn_110 sn_227 4032400.362500201
Csub_110_227 sn_110 sn_227 2.612955697607637e-18
Rsub_110_159 sn_110 sn_159 4809821.136964998
Csub_110_159 sn_110 sn_159 2.190618570252808e-18
Rsub_110_195 sn_110 sn_195 240837.4950873484
Csub_110_195 sn_110 sn_195 4.37493484908094e-17
Rsub_110_189 sn_110 sn_189 5973412.772080457
Csub_110_189 sn_110 sn_189 1.763896771285788e-18
Rsub_110_177 sn_110 sn_177 1735183.739285499
Csub_110_177 sn_110 sn_177 6.072258092142239e-18
Rsub_110_126 sn_110 sn_126 6412471.745811488
Csub_110_126 sn_110 sn_126 1.643123575415711e-18
Rsub_110_205 sn_110 sn_205 22067470.91070249
Csub_110_205 sn_110 sn_205 4.774667448239354e-19
Rsub_110_230 sn_110 0 122285.2892879103
Csub_110_230 sn_110 0 8.616313183364805e-17
Rsub_110_219 sn_110 sn_219 39526.33308809953
Csub_110_219 sn_110 sn_219 2.665687069616456e-16
Rsub_110_140 sn_110 sn_140 29807272.52424008
Csub_110_140 sn_110 sn_140 3.534870053494981e-19
Rsub_110_166 sn_110 sn_166 337367753.7332197
Csub_110_166 sn_110 sn_166 3.123144813230115e-20
Rsub_110_129 sn_110 sn_129 36682.57230546959
Csub_110_129 sn_110 sn_129 2.872340416721253e-16
Rsub_110_208 sn_110 sn_208 3600701.00083964
Csub_110_208 sn_110 sn_208 2.926231169923028e-18
Rsub_110_155 sn_110 sn_155 13298491.45734478
Csub_110_155 sn_110 sn_155 7.923066714766873e-19
Rsub_110_222 sn_110 sn_222 490378.5978326247
Csub_110_222 sn_110 sn_222 2.148642609771134e-17
Rsub_110_141 sn_110 sn_141 2896729.120754092
Csub_110_141 sn_110 sn_141 3.637372727308063e-18
Rsub_110_215 sn_110 sn_215 1848452.632108939
Csub_110_215 sn_110 sn_215 5.700164190958305e-18
Rsub_110_201 sn_110 sn_201 6069905.030124875
Csub_110_201 sn_110 sn_201 1.735856401366668e-18
Rsub_110_202 sn_110 sn_202 32115369.42484271
Csub_110_202 sn_110 sn_202 3.280822762100799e-19
Rsub_110_118 sn_110 sn_118 5176133.24978525
Csub_110_118 sn_110 sn_118 2.035589694810724e-18
Rsub_110_211 sn_110 sn_211 14063846.38164273
Csub_110_211 sn_110 sn_211 7.491893196432431e-19
Rsub_110_152 sn_110 sn_152 14183513.51203251
Csub_110_152 sn_110 sn_152 7.428683656762077e-19
Rsub_110_161 sn_110 sn_161 16516371.80954936
Csub_110_161 sn_110 sn_161 6.379417721837716e-19
Rsub_110_165 sn_110 sn_165 17230144.66709679
Csub_110_165 sn_110 sn_165 6.115145116773624e-19
Rsub_110_169 sn_110 sn_169 29513969.34726657
Csub_110_169 sn_110 sn_169 3.56999879557232e-19
Rsub_110_115 sn_110 sn_115 8556576.156257637
Csub_110_115 sn_110 sn_115 1.231390138978008e-18
Rsub_110_216 sn_110 sn_216 34557224.0439944
Csub_110_216 sn_110 sn_216 3.048995917269317e-19
Rsub_110_196 sn_110 sn_196 16924466.03237025
Csub_110_196 sn_110 sn_196 6.225592867791279e-19
Rsub_110_214 sn_110 sn_214 3984400.350428764
Csub_110_214 sn_110 sn_214 2.644433936237397e-18
Rsub_110_185 sn_110 sn_185 33824880.58206391
Csub_110_185 sn_110 sn_185 3.115009815531208e-19
Rsub_110_187 sn_110 sn_187 9741967.764422566
Csub_110_187 sn_110 sn_187 1.081555980990718e-18
Rsub_110_225 sn_110 sn_225 34750551.17151325
Csub_110_225 sn_110 sn_225 3.032033492138472e-19
Rsub_110_199 sn_110 sn_199 4791653.71924624
Csub_110_199 sn_110 sn_199 2.19892423776555e-18
Rsub_110_178 sn_110 sn_178 37254394.22936264
Csub_110_178 sn_110 sn_178 2.828252537770566e-19
Rsub_110_130 sn_110 sn_130 3808278.062593634
Csub_110_130 sn_110 sn_130 2.766731664298198e-18
Rsub_110_112 sn_110 sn_112 4896173.070647491
Csub_110_112 sn_110 sn_112 2.151983467536332e-18
Rsub_110_111 sn_110 sn_111 30893763.33532963
Csub_110_111 sn_110 sn_111 3.41055357609367e-19
Rsub_110_157 sn_110 sn_157 10138775.95581054
Csub_110_157 sn_110 sn_157 1.039226386711064e-18
Rsub_110_134 sn_110 sn_134 5647448.07790217
Csub_110_134 sn_110 sn_134 1.865707016140277e-18
Rsub_110_198 sn_110 sn_198 3160151.175863625
Csub_110_198 sn_110 sn_198 3.334170713953433e-18
Rsub_110_119 sn_110 sn_119 10247433.00413919
Csub_110_119 sn_110 sn_119 1.028207112744631e-18
Rsub_110_175 sn_110 sn_175 4223781.440137991
Csub_110_175 sn_110 sn_175 2.494561721897659e-18
Rsub_110_128 sn_110 sn_128 7623629.412205542
Csub_110_128 sn_110 sn_128 1.382082330151166e-18
Rsub_110_203 sn_110 sn_203 1270142131.42444
Rsub_110_200 sn_110 sn_200 7398088.87708305
Csub_110_200 sn_110 sn_200 1.424216939981447e-18
Rsub_58_199 sn_58 sn_199 101230917.1470577
Csub_58_199 sn_58 sn_199 1.040836515085969e-19
Rsub_58_93 sn_58 sn_93 51615140.35919059
Csub_58_93 sn_58 sn_93 2.041355197119768e-19
Rsub_58_69 sn_58 sn_69 58553092.12892996
Csub_58_69 sn_58 sn_69 1.799475163332002e-19
Rsub_58_187 sn_58 sn_187 59351384.11408108
Csub_58_187 sn_58 sn_187 1.775271741258386e-19
Rsub_58_110 sn_58 sn_110 33131436.47854289
Csub_58_110 sn_58 sn_110 3.180207266006654e-19
Rsub_58_72 sn_58 sn_72 73622087.14106816
Csub_58_72 sn_58 sn_72 1.431157946125722e-19
Rsub_58_71 sn_58 sn_71 103596823.1851849
Csub_58_71 sn_58 sn_71 1.017066274647773e-19
Rsub_58_156 sn_58 sn_156 132501580.0232317
Csub_58_156 sn_58 sn_156 7.951968195686894e-20
Rsub_58_145 sn_58 sn_145 110736674.7360108
Csub_58_145 sn_58 sn_145 9.514899672893658e-20
Rsub_58_140 sn_58 sn_140 2552797.218825802
Csub_58_140 sn_58 sn_140 4.127426739784846e-18
Rsub_58_130 sn_58 sn_130 132501580.0232317
Csub_58_130 sn_58 sn_130 7.951968195686894e-20
Rsub_58_107 sn_58 sn_107 54994438.83981757
Csub_58_107 sn_58 sn_107 1.915917995439437e-19
Rsub_58_165 sn_58 sn_165 132501580.0232317
Csub_58_165 sn_58 sn_165 7.951968195686894e-20
Rsub_58_81 sn_58 sn_81 85160599.67205334
Csub_58_81 sn_58 sn_81 1.237248627041749e-19
Rsub_58_175 sn_58 sn_175 67512980.75616802
Csub_58_175 sn_58 sn_175 1.56066039215242e-19
Rsub_58_163 sn_58 sn_163 85160599.67205334
Csub_58_163 sn_58 sn_163 1.237248627041749e-19
Rsub_58_217 sn_58 sn_217 35095356.60874183
Csub_58_217 sn_58 sn_217 3.002244319582006e-19
Rsub_58_205 sn_58 sn_205 83299826.06968442
Csub_58_205 sn_58 sn_205 1.264886614939113e-19
Rsub_58_227 sn_58 sn_227 945697.4068148197
Csub_58_227 sn_58 sn_227 1.114149560557396e-17
Rsub_58_148 sn_58 sn_148 315296.7198160469
Csub_58_148 sn_58 sn_148 3.341767560530692e-17
Rsub_58_198 sn_58 sn_198 3608325.704005227
Csub_58_198 sn_58 sn_198 2.920047791288505e-18
Rsub_58_196 sn_58 sn_196 462482.3531914194
Csub_58_196 sn_58 sn_196 2.278245522131089e-17
Rsub_58_117 sn_58 sn_117 35722779.21091858
Csub_58_117 sn_58 sn_117 2.949513933397867e-19
Rsub_58_144 sn_58 sn_144 164347.4824470737
Csub_58_144 sn_58 sn_144 6.41110125043939e-17
Rsub_58_221 sn_58 sn_221 116258.6259780618
Csub_58_221 sn_58 sn_221 9.062969232251423e-17
Rsub_58_142 sn_58 sn_142 959860.5345099828
Csub_58_142 sn_58 sn_142 1.097709836315853e-17
Rsub_58_230 sn_58 0 333598.4220820527
Csub_58_230 sn_58 0 3.158433255310309e-17
Rsub_58_63 sn_58 sn_63 80424085.04784152
Csub_58_63 sn_58 sn_63 1.31011543320166e-19
Rsub_58_218 sn_58 sn_218 8875427.786789251
Csub_58_218 sn_58 sn_218 1.187152186389615e-18
Rsub_58_139 sn_58 sn_139 15760609.52284742
Csub_58_139 sn_58 sn_139 6.685327421478056e-19
Rsub_58_134 sn_58 sn_134 58372784.75156598
Csub_58_134 sn_58 sn_134 1.805033552377735e-19
Rsub_58_192 sn_58 sn_192 2147608.609811977
Csub_58_192 sn_58 sn_192 4.906146983249647e-18
Rsub_58_160 sn_58 sn_160 3396749.233611643
Csub_58_160 sn_58 sn_160 3.101931516748127e-18
Rsub_58_197 sn_58 sn_197 27007100.54082787
Csub_58_197 sn_58 sn_197 3.901375301766111e-19
Rsub_58_225 sn_58 sn_225 70282867.34879901
Csub_58_225 sn_58 sn_225 1.499153904740349e-19
Rsub_58_137 sn_58 sn_137 83299826.06968442
Csub_58_137 sn_58 sn_137 1.264886614939113e-19
Rsub_58_216 sn_58 sn_216 13244504.48100309
Csub_58_216 sn_58 sn_216 7.95536255610222e-19
Rsub_58_95 sn_58 sn_95 339052.4846168138
Csub_58_95 sn_58 sn_95 3.107626099286073e-17
Rsub_58_174 sn_58 sn_174 395475.3834047508
Csub_58_174 sn_58 sn_174 2.664257737490173e-17
Rsub_58_129 sn_58 sn_129 14022396.99069436
Csub_58_129 sn_58 sn_129 7.514038797519638e-19
Rsub_58_203 sn_58 sn_203 38746.42629589858
Csub_58_203 sn_58 sn_203 2.719343307113028e-16
Rsub_58_211 sn_58 sn_211 116602.8912290036
Csub_58_211 sn_58 sn_211 9.036211187539727e-17
Rsub_58_132 sn_58 sn_132 10633000.33185634
Csub_58_132 sn_58 sn_132 9.909228979014343e-19
Rsub_58_214 sn_58 sn_214 964347.7157391828
Csub_58_214 sn_58 sn_214 1.092602111278262e-17
Rsub_58_135 sn_58 sn_135 49556437.8221453
Csub_58_135 sn_58 sn_135 2.126158369179949e-19
Rsub_58_103 sn_58 sn_103 680618.4430154519
Csub_58_103 sn_58 sn_103 1.548074932490596e-17
Rsub_58_182 sn_58 sn_182 1688095.113624713
Csub_58_182 sn_58 sn_182 6.241640898779598e-18
Rsub_58_162 sn_58 sn_162 10915768.04786996
Csub_58_162 sn_58 sn_162 9.65253517299319e-19
Rsub_58_88 sn_58 sn_88 95540.19386652678
Csub_58_88 sn_58 sn_88 1.102832543646485e-16
Rsub_58_138 sn_58 sn_138 824608.6716569499
Csub_58_138 sn_58 sn_138 1.277755602673718e-17
Rsub_58_64 sn_58 sn_64 25054283.11066147
Csub_58_64 sn_58 sn_64 4.205461978573381e-19
Rsub_58_222 sn_58 sn_222 451645.4883701675
Csub_58_222 sn_58 sn_222 2.332910163733181e-17
Rsub_58_212 sn_58 sn_212 1388360.717927998
Csub_58_212 sn_58 sn_212 7.589154148609693e-18
Rsub_58_133 sn_58 sn_133 83299826.06968442
Csub_58_133 sn_58 sn_133 1.264886614939113e-19
Rsub_58_215 sn_58 sn_215 1287097.841213688
Csub_58_215 sn_58 sn_215 8.186233528520621e-18
Rsub_58_185 sn_58 sn_185 62819602.61349768
Csub_58_185 sn_58 sn_185 1.677260451177398e-19
Rsub_58_201 sn_58 sn_201 15685700.62223935
Csub_58_201 sn_58 sn_201 6.71725398564044e-19
Rsub_58_122 sn_58 sn_122 40784351.10735017
Csub_58_122 sn_58 sn_122 2.583462336938129e-19
Rsub_58_200 sn_58 sn_200 477530.8960091401
Csub_58_200 sn_58 sn_200 2.206450638123387e-17
Rsub_58_114 sn_58 sn_114 26758482.271475
Csub_58_114 sn_58 sn_114 3.937623739393498e-19
Rsub_58_66 sn_58 sn_66 13411033.31951798
Csub_58_66 sn_58 sn_66 7.856578424046969e-19
Rsub_58_153 sn_58 sn_153 21382489.67679553
Csub_58_153 sn_58 sn_153 4.927622396406106e-19
Rsub_58_206 sn_58 sn_206 29139806.21089272
Csub_58_206 sn_58 sn_206 3.615838563226741e-19
Rsub_58_141 sn_58 sn_141 19864111.9537001
Csub_58_141 sn_58 sn_141 5.304281171385244e-19
Rsub_58_128 sn_58 sn_128 13135763.73972482
Csub_58_128 sn_58 sn_128 8.021218797020425e-19
Rsub_58_78 sn_58 sn_78 20304497.78066749
Csub_58_78 sn_58 sn_78 5.189236205715021e-19
Rsub_58_157 sn_58 sn_157 73920848.18371975
Csub_58_157 sn_58 sn_157 1.425373728943568e-19
Rsub_58_115 sn_58 sn_115 24637806.41760796
Csub_58_115 sn_58 sn_115 4.276550973588244e-19
Rsub_58_202 sn_58 sn_202 49275612.83521591
Csub_58_202 sn_58 sn_202 2.138275486794122e-19
Rsub_58_123 sn_58 sn_123 73710361.34471777
Csub_58_123 sn_58 sn_123 1.429444017097478e-19
Rsub_58_219 sn_58 sn_219 935977.0782739444
Csub_58_219 sn_58 sn_219 1.125720249651899e-17
Rsub_58_166 sn_58 sn_166 2775548.943866329
Csub_58_166 sn_58 sn_166 3.796180040533791e-18
Rsub_58_87 sn_58 sn_87 85063936.10829392
Csub_58_87 sn_58 sn_87 1.23865459139066e-19
Rsub_58_59 sn_58 sn_59 18202778.27474812
Csub_58_59 sn_58 sn_59 5.788393037147951e-19
Rsub_58_226 sn_58 sn_226 914263.601029705
Csub_58_226 sn_58 sn_226 1.152455756782082e-17
Rsub_58_164 sn_58 sn_164 76013809.95131777
Csub_58_164 sn_58 sn_164 1.386127535112104e-19
Rsub_58_195 sn_58 sn_195 51553759.57608321
Csub_58_195 sn_58 sn_195 2.043785669341966e-19
Rsub_58_177 sn_58 sn_177 11800004.40571741
Csub_58_177 sn_58 sn_177 8.929219973108484e-19
Rsub_58_170 sn_58 sn_170 3515412.470807656
Csub_58_170 sn_58 sn_170 2.997225386701002e-18
Rsub_58_131 sn_58 sn_131 9881177.014491018
Csub_58_131 sn_58 sn_131 1.066318666974386e-18
Rsub_58_210 sn_58 sn_210 80424085.04784152
Csub_58_210 sn_58 sn_210 1.31011543320166e-19
Rsub_58_190 sn_58 sn_190 29489138.35721619
Csub_58_190 sn_58 sn_190 3.573004872029994e-19
Rsub_58_105 sn_58 sn_105 65145910.3361176
Csub_58_105 sn_58 sn_105 1.617366838204801e-19
Rsub_58_125 sn_58 sn_125 47364408.0747065
Csub_58_125 sn_58 sn_125 2.224557200337247e-19
Rsub_58_204 sn_58 sn_204 24571773.99037935
Csub_58_204 sn_58 sn_204 4.288043470673049e-19
Rsub_58_181 sn_58 sn_181 85063936.10829392
Csub_58_181 sn_58 sn_181 1.23865459139066e-19
Rsub_58_229 sn_58 sn_229 74585897.20678021
Csub_58_229 sn_58 sn_229 1.412664310120035e-19
Rsub_58_146 sn_58 sn_146 31462433.79710048
Csub_58_146 sn_58 sn_146 3.348909232572155e-19
Rsub_58_77 sn_58 sn_77 76110002.14055654
Csub_58_77 sn_58 sn_77 1.384375667572797e-19
Rsub_58_97 sn_58 sn_97 23718078.57523106
Csub_58_97 sn_58 sn_97 4.442384938058733e-19
Rsub_114_183 sn_114 sn_183 37524.44915209321
Csub_114_183 sn_114 sn_183 2.807898247759422e-16
Rsub_114_194 sn_114 sn_194 6210633.97154305
Csub_114_194 sn_114 sn_194 1.696523020114834e-18
Rsub_114_155 sn_114 sn_155 9502197.806122847
Csub_114_155 sn_114 sn_155 1.108846997001125e-18
Rsub_114_197 sn_114 sn_197 17190003.73976145
Csub_114_197 sn_114 sn_197 6.129424787650581e-19
Rsub_114_181 sn_114 sn_181 27823211.41999143
Csub_114_181 sn_114 sn_181 3.786940099466507e-19
Rsub_114_135 sn_114 sn_135 5555061.45634333
Csub_114_135 sn_114 sn_135 1.896735722014089e-18
Rsub_114_214 sn_114 sn_214 1026610.736384157
Csub_114_214 sn_114 sn_214 1.026336772917525e-17
Rsub_114_162 sn_114 sn_162 16379871.01564898
Csub_114_162 sn_114 sn_162 6.432580264010426e-19
Rsub_114_219 sn_114 sn_219 5047394.114976047
Csub_114_219 sn_114 sn_219 2.087509566761858e-18
Rsub_114_158 sn_114 sn_158 3498273.112478495
Csub_114_158 sn_114 sn_158 3.01190992339789e-18
Rsub_114_172 sn_114 sn_172 3347654.654093406
Csub_114_172 sn_114 sn_172 3.147422476612491e-18
Rsub_114_157 sn_114 sn_157 16810254.02533372
Csub_114_157 sn_114 sn_157 6.267890709058352e-19
Rsub_114_159 sn_114 sn_159 3331312.489356757
Csub_114_159 sn_114 sn_159 3.16286254618656e-18
Rsub_114_192 sn_114 sn_192 14939976.62041678
Csub_114_192 sn_114 sn_192 7.052543501193288e-19
Rsub_114_174 sn_114 sn_174 6311153.282027595
Csub_114_174 sn_114 sn_174 1.669502075355224e-18
Rsub_114_182 sn_114 sn_182 1405392.155201279
Csub_114_182 sn_114 sn_182 7.497183944876211e-18
Rsub_114_195 sn_114 sn_195 892358.160697965
Csub_114_195 sn_114 sn_195 1.180746023994313e-17
Rsub_114_177 sn_114 sn_177 3310618.211848128
Csub_114_177 sn_114 sn_177 3.18263322074462e-18
Rsub_114_202 sn_114 sn_202 10434526.57019432
Csub_114_202 sn_114 sn_202 1.00977111240743e-18
Rsub_114_128 sn_114 sn_128 6402660.239778198
Csub_114_128 sn_114 sn_128 1.645641515813903e-18
Rsub_114_151 sn_114 sn_151 37570.42068170046
Csub_114_151 sn_114 sn_151 2.804462476344332e-16
Rsub_114_230 sn_114 0 160521.5142265223
Csub_114_230 sn_114 0 6.56390736967587e-17
Rsub_114_222 sn_114 sn_222 1031024.685803015
Csub_114_222 sn_114 sn_222 1.021942893057274e-17
Rsub_114_185 sn_114 sn_185 9569385.006327072
Csub_114_185 sn_114 sn_185 1.101061718727327e-18
Rsub_114_144 sn_114 sn_144 7026755.449472692
Csub_114_144 sn_114 sn_144 1.499480603529569e-18
Rsub_114_223 sn_114 sn_223 10963273.46800066
Csub_114_223 sn_114 sn_223 9.61070936794894e-19
Rsub_114_189 sn_114 sn_189 4473507.561170482
Csub_114_189 sn_114 sn_189 2.35530696174193e-18
Rsub_114_226 sn_114 sn_226 3426551.241682028
Csub_114_226 sn_114 sn_226 3.074952848817707e-18
Rsub_114_127 sn_114 sn_127 1883914.211125402
Csub_114_127 sn_114 sn_127 5.592867997920021e-18
Rsub_114_206 sn_114 sn_206 20278.74483289157
Csub_114_206 sn_114 sn_206 5.195826264917597e-16
Rsub_114_132 sn_114 sn_132 4502881.684866079
Csub_114_132 sn_114 sn_132 2.339942339067558e-18
Rsub_114_188 sn_114 sn_188 1727467.644681354
Csub_114_188 sn_114 sn_188 6.099381099652114e-18
Rsub_114_146 sn_114 sn_146 16405187.82553432
Csub_114_146 sn_114 sn_146 6.422653379091578e-19
Rsub_114_225 sn_114 sn_225 47690621.54382885
Csub_114_225 sn_114 sn_225 2.209340780460728e-19
Rsub_114_199 sn_114 sn_199 399583.1634412661
Csub_114_199 sn_114 sn_199 2.636868733779555e-17
Rsub_114_178 sn_114 sn_178 35279.78180952277
Csub_114_178 sn_114 sn_178 2.986550075370925e-16
Rsub_114_220 sn_114 sn_220 15736060.32009136
Csub_114_220 sn_114 sn_220 6.695756935284059e-19
Rsub_114_141 sn_114 sn_141 5113957.036232552
Csub_114_141 sn_114 sn_141 2.060338682468131e-18
Rsub_114_153 sn_114 sn_153 848091.5507509735
Csub_114_153 sn_114 sn_153 1.242375719095431e-17
Rsub_114_130 sn_114 sn_130 6861680.761357524
Csub_114_130 sn_114 sn_130 1.535554315142089e-18
Rsub_114_204 sn_114 sn_204 26970.39986804588
Csub_114_204 sn_114 sn_204 3.906684199633787e-16
Rsub_114_198 sn_114 sn_198 719367.7447542055
Csub_114_198 sn_114 sn_198 1.464686675078839e-17
Rsub_114_170 sn_114 sn_170 579532.9400771229
Csub_114_170 sn_114 sn_170 1.818099157716183e-17
Rsub_114_212 sn_114 sn_212 2341257.468875933
Csub_114_212 sn_114 sn_212 4.500352328737555e-18
Rsub_114_133 sn_114 sn_133 2074865.639818698
Csub_114_133 sn_114 sn_133 5.078152194544356e-18
Rsub_114_215 sn_114 sn_215 388247.2216863842
Csub_114_215 sn_114 sn_215 2.71385934365838e-17
Rsub_114_136 sn_114 sn_136 8703017.408398403
Csub_114_136 sn_114 sn_136 1.210670162748647e-18
Rsub_114_213 sn_114 sn_213 3071476.986849639
Csub_114_213 sn_114 sn_213 3.430428926324821e-18
Rsub_114_218 sn_114 sn_218 2336176.865088433
Csub_114_218 sn_114 sn_218 4.510139476032845e-18
Rsub_114_139 sn_114 sn_139 5047967.589274173
Csub_114_139 sn_114 sn_139 2.087272415262278e-18
Rsub_114_160 sn_114 sn_160 1005928.991808519
Csub_114_160 sn_114 sn_160 1.047438098318141e-17
Rsub_114_210 sn_114 sn_210 28386627.82769989
Csub_114_210 sn_114 sn_210 3.711777096661133e-19
Rsub_114_131 sn_114 sn_131 1329537.920939503
Csub_114_131 sn_114 sn_131 7.924921385306947e-18
Rsub_114_196 sn_114 sn_196 1748209.787524296
Csub_114_196 sn_114 sn_196 6.027013220850973e-18
Rsub_114_117 sn_114 sn_117 33377053.02545279
Csub_114_117 sn_114 sn_117 3.156804614893668e-19
Rsub_114_201 sn_114 sn_201 1142408.190696025
Csub_114_201 sn_114 sn_201 9.223046182652567e-18
Rsub_114_126 sn_114 sn_126 2372906.618260338
Csub_114_126 sn_114 sn_126 4.44032791730956e-18
Rsub_114_138 sn_114 sn_138 1171262.930673986
Csub_114_138 sn_114 sn_138 8.995831103582298e-18
Rsub_195_200 sn_195 sn_200 6472898.944631708
Csub_195_200 sn_195 sn_200 1.627784334709632e-18
Rsub_195_221 sn_195 sn_221 4007474.822681426
Csub_195_221 sn_195 sn_221 2.629207660294164e-18
Rsub_195_213 sn_195 sn_213 3164205.357757104
Csub_195_213 sn_195 sn_213 3.329898761595745e-18
Rsub_195_208 sn_195 sn_208 1355731.566657711
Csub_195_208 sn_195 sn_208 7.771806573926449e-18
Rsub_195_212 sn_195 sn_212 3731706.581036178
Csub_195_212 sn_195 sn_212 2.823502671880582e-18
Rsub_195_207 sn_195 sn_207 10809737.03820509
Csub_195_207 sn_195 sn_207 9.747215371651206e-19
Rsub_195_220 sn_195 sn_220 14001168.91997214
Csub_195_220 sn_195 sn_220 7.525431313952726e-19
Rsub_195_214 sn_195 sn_214 3199904.595854247
Csub_195_214 sn_195 sn_214 3.292749263800216e-18
Rsub_195_226 sn_195 sn_226 280416.3803180932
Csub_195_226 sn_195 sn_226 3.757442232967215e-17
Rsub_195_218 sn_195 sn_218 406408.1308584268
Csub_195_218 sn_195 sn_218 2.592586787074004e-17
Rsub_195_216 sn_195 sn_216 423751.6328544128
Csub_195_216 sn_195 sn_216 2.486476200989647e-17
Rsub_195_229 sn_195 sn_229 162293.104044217
Csub_195_229 sn_195 sn_229 6.49225582582937e-17
Rsub_195_211 sn_195 sn_211 2277122.357702699
Csub_195_211 sn_195 sn_211 4.627104672960944e-18
Rsub_195_203 sn_195 sn_203 1453727.923683043
Csub_195_203 sn_195 sn_203 7.247906111300145e-18
Rsub_195_201 sn_195 sn_201 3395619.270690664
Csub_195_201 sn_195 sn_201 3.102963748962025e-18
Rsub_195_217 sn_195 sn_217 535168.8449745033
Csub_195_217 sn_195 sn_217 1.968814814459535e-17
Rsub_195_202 sn_195 sn_202 19784170.86536859
Csub_195_202 sn_195 sn_202 5.325713962910469e-19
Rsub_195_219 sn_195 sn_219 11474.81499821881
Csub_195_219 sn_195 sn_219 9.182268737113002e-16
Rsub_195_230 sn_195 0 7192.735247967368
Csub_195_230 sn_195 0 1.464878539107575e-15
Rsub_195_199 sn_195 sn_199 68794454.04309054
Csub_195_199 sn_195 sn_199 1.531589086473497e-19
Rsub_195_198 sn_195 sn_198 426441.7408079241
Csub_195_198 sn_195 sn_198 2.470790847600398e-17
Rsub_195_215 sn_195 sn_215 164604.8252402143
Csub_195_215 sn_195 sn_215 6.40107814995927e-17
Rsub_195_225 sn_195 sn_225 421499.8461024967
Csub_195_225 sn_195 sn_225 2.499759750723095e-17
Rsub_195_206 sn_195 sn_206 225246.2840911746
Csub_195_206 sn_195 sn_206 4.677761297924484e-17
Rsub_195_205 sn_195 sn_205 272571.8840578928
Csub_195_205 sn_195 sn_205 3.865579730883802e-17
Rsub_195_222 sn_195 sn_222 60311.45197218276
Csub_195_222 sn_195 sn_222 1.747012077754272e-16
Rsub_195_204 sn_195 sn_204 1439726.08062855
Csub_195_204 sn_195 sn_204 7.318394550184175e-18
Rsub_195_227 sn_195 sn_227 215429.8366095287
Csub_195_227 sn_195 sn_227 4.890911894125236e-17
Rsub_195_210 sn_195 sn_210 254194.3876789884
Csub_195_210 sn_195 sn_210 4.145049620661213e-17
Rsub_195_228 sn_195 sn_228 356882.5036040023
Csub_195_228 sn_195 sn_228 2.952367626831409e-17
Rsub_188_207 sn_188 sn_207 10143920.41118251
Csub_188_207 sn_188 sn_207 1.038699346518407e-18
Rsub_188_224 sn_188 sn_224 44803561.80249345
Csub_188_224 sn_188 sn_224 2.351706667580973e-19
Rsub_188_211 sn_188 sn_211 33428118.77335462
Csub_188_211 sn_188 sn_211 3.151982190104152e-19
Rsub_188_205 sn_188 sn_205 26837602.77279595
Csub_188_205 sn_188 sn_205 3.926015148011042e-19
Rsub_188_195 sn_188 sn_195 823130.7338832766
Csub_188_195 sn_188 sn_195 1.280049823011969e-17
Rsub_188_213 sn_188 sn_213 6889866.221387708
Csub_188_213 sn_188 sn_213 1.529272581450474e-18
Rsub_188_214 sn_188 sn_214 2536355.187283566
Csub_188_214 sn_188 sn_214 4.154182961068069e-18
Rsub_188_203 sn_188 sn_203 11410893.00915241
Csub_188_203 sn_188 sn_203 9.233706331116188e-19
Rsub_188_217 sn_188 sn_217 64018691.04040966
Csub_188_217 sn_188 sn_217 1.645844882329631e-19
Rsub_188_227 sn_188 sn_227 2197189.232111956
Csub_188_227 sn_188 sn_227 4.795437438086409e-18
Rsub_188_216 sn_188 sn_216 230968159.9475513
Csub_188_216 sn_188 sn_216 4.561877058994906e-20
Rsub_188_204 sn_188 sn_204 1426395.621271556
Csub_188_204 sn_188 sn_204 7.386789012179723e-18
Rsub_188_218 sn_188 sn_218 2098850.678654963
Csub_188_218 sn_188 sn_218 5.020120587607619e-18
Rsub_188_225 sn_188 sn_225 17540511.05302862
Csub_188_225 sn_188 sn_225 6.006942141181643e-19
Rsub_188_222 sn_188 sn_222 4850167.106722716
Csub_188_222 sn_188 sn_222 2.172395975310954e-18
Rsub_188_198 sn_188 sn_198 479482.1583894124
Csub_188_198 sn_188 sn_198 2.197471442445784e-17
Rsub_188_215 sn_188 sn_215 351967.5592880732
Csub_188_215 sn_188 sn_215 2.993595069824676e-17
Rsub_188_201 sn_188 sn_201 66440.12612328627
Csub_188_201 sn_188 sn_201 1.585861454067457e-16
Rsub_188_199 sn_188 sn_199 163045.1274160082
Csub_188_199 sn_188 sn_199 6.462311182931738e-17
Rsub_188_206 sn_188 sn_206 602495.5058933207
Csub_188_206 sn_188 sn_206 1.748806986801926e-17
Rsub_188_223 sn_188 sn_223 44102750.96523761
Csub_188_223 sn_188 sn_223 2.389076252983629e-19
Rsub_188_219 sn_188 sn_219 2213226.335933181
Csub_188_219 sn_188 sn_219 4.760689555859372e-18
Rsub_188_202 sn_188 sn_202 110550312.8614043
Csub_188_202 sn_188 sn_202 9.530939560016874e-20
Rsub_188_230 sn_188 0 179882.0096018748
Csub_188_230 sn_188 0 5.857441511549683e-17
Rsub_188_196 sn_188 sn_196 12150971.94406239
Csub_188_196 sn_188 sn_196 8.671309217678419e-19
Rsub_188_212 sn_188 sn_212 3174646.457507332
Csub_188_212 sn_188 sn_212 3.318947052297292e-18
Rsub_188_192 sn_188 sn_192 3664471.733320055
Csub_188_192 sn_188 sn_192 2.875307621129833e-18
Rsub_188_226 sn_188 sn_226 551494.185447863
Csub_188_226 sn_188 sn_226 1.910533924065478e-17
Rsub_188_221 sn_188 sn_221 44102750.96523761
Csub_188_221 sn_188 sn_221 2.389076252983629e-19
Rsub_199_203 sn_199 sn_203 23492869.60933286
Csub_199_203 sn_199 sn_203 4.484970834743935e-19
Rsub_199_229 sn_199 sn_229 31171314.2469178
Csub_199_229 sn_199 sn_229 3.38018583970095e-19
Rsub_199_205 sn_199 sn_205 346874.1619880319
Csub_199_205 sn_199 sn_205 3.037552131828585e-17
Rsub_199_223 sn_199 sn_223 53961417.16562333
Csub_199_223 sn_199 sn_223 1.952595772251581e-19
Rsub_199_209 sn_199 sn_209 14225024.85681358
Csub_199_209 sn_199 sn_209 7.407005336221386e-19
Rsub_199_216 sn_199 sn_216 22708114.37868866
Csub_199_216 sn_199 sn_216 4.639964079148018e-19
Rsub_199_218 sn_199 sn_218 12339097.08066735
Csub_199_218 sn_199 sn_218 8.53910414461229e-19
Rsub_199_213 sn_199 sn_213 9642962.385391451
Csub_199_213 sn_199 sn_213 1.092660437853847e-18
Rsub_199_228 sn_199 sn_228 26916137.26013758
Csub_199_228 sn_199 sn_228 3.914560027836678e-19
Rsub_199_230 sn_199 0 105371.6055761442
Csub_199_230 sn_199 0 9.999357459364203e-17
Rsub_199_206 sn_199 sn_206 211552.3579728194
Csub_199_206 sn_199 sn_206 4.980555926294021e-17
Rsub_199_204 sn_199 sn_204 716462.5310776094
Csub_199_204 sn_199 sn_204 1.470625893915541e-17
Rsub_199_221 sn_199 sn_221 2786994.875957079
Csub_199_221 sn_199 sn_221 3.780589477622086e-18
Rsub_199_222 sn_199 sn_222 977821.0969231637
Csub_199_222 sn_199 sn_222 1.077547164341654e-17
Rsub_199_201 sn_199 sn_201 20659.18271198546
Csub_199_201 sn_199 sn_201 5.100145368343754e-16
Rsub_199_215 sn_199 sn_215 237058.6470282326
Csub_199_215 sn_199 sn_215 4.444673769261475e-17
Rsub_199_211 sn_199 sn_211 6507335.936046772
Csub_199_211 sn_199 sn_211 1.619170057575197e-18
Rsub_199_219 sn_199 sn_219 7027033.007022271
Csub_199_219 sn_199 sn_219 1.499421376233847e-18
Rsub_199_202 sn_199 sn_202 572376214.3668762
Csub_199_202 sn_199 sn_202 1.840831823154068e-20
Rsub_199_214 sn_199 sn_214 2717763.983913433
Csub_199_214 sn_199 sn_214 3.876894227974143e-18
Rsub_199_200 sn_199 sn_200 7552503.739760595
Csub_199_200 sn_199 sn_200 1.395098084726535e-18
Rsub_199_226 sn_199 sn_226 15355063.58534006
Csub_199_226 sn_199 sn_226 6.861895063912012e-19
Rsub_101_154 sn_101 sn_154 10130684.92045831
Csub_101_154 sn_101 sn_154 1.040056381671905e-18
Rsub_101_126 sn_101 sn_126 3038868.86135952
Csub_101_126 sn_101 sn_126 3.467238628229657e-18
Rsub_101_167 sn_101 sn_167 25320388.46761876
Csub_101_167 sn_101 sn_167 4.161264553940272e-19
Rsub_101_207 sn_101 sn_207 9253966.370526735
Csub_101_207 sn_101 sn_207 1.138591073314033e-18
Rsub_101_121 sn_101 sn_121 5102610.613910505
Csub_101_121 sn_101 sn_121 2.064920155480005e-18
Rsub_101_169 sn_101 sn_169 8478548.997443294
Csub_101_169 sn_101 sn_169 1.242722487704827e-18
Rsub_101_146 sn_101 sn_146 12925689.4839778
Csub_101_146 sn_101 sn_146 8.15158333742322e-19
Rsub_101_190 sn_101 sn_190 8268641.557429424
Csub_101_190 sn_101 sn_190 1.274270196506814e-18
Rsub_101_228 sn_101 sn_228 4906245.143887469
Csub_101_228 sn_101 sn_228 2.147565641997539e-18
Rsub_101_139 sn_101 sn_139 3330991.06694451
Csub_101_139 sn_101 sn_139 3.16316774511648e-18
Rsub_101_218 sn_101 sn_218 1386478.971686861
Csub_101_218 sn_101 sn_218 7.599454241567601e-18
Rsub_101_219 sn_101 sn_219 482268.0374449273
Csub_101_219 sn_101 sn_219 2.184777485576828e-17
Rsub_101_140 sn_101 sn_140 13483327.86798132
Csub_101_140 sn_101 sn_140 7.814453230979312e-19
Rsub_101_110 sn_101 sn_110 347471.501569921
Csub_101_110 sn_101 sn_110 3.032330264388536e-17
Rsub_101_189 sn_101 sn_189 26966655.73596264
Csub_101_189 sn_101 sn_189 3.907226615489656e-19
Rsub_101_157 sn_101 sn_157 83829429.36292207
Csub_101_157 sn_101 sn_157 1.256895529684986e-19
Rsub_101_195 sn_101 sn_195 345871.8748572342
Csub_101_195 sn_101 sn_195 3.046354522633317e-17
Rsub_101_127 sn_101 sn_127 2422604.858792563
Csub_101_127 sn_101 sn_127 4.349237335997679e-18
Rsub_101_206 sn_101 sn_206 181099.5877992689
Csub_101_206 sn_101 sn_206 5.818060455172685e-17
Rsub_101_201 sn_101 sn_201 157199.212475231
Csub_101_201 sn_101 sn_201 6.702631225897633e-17
Rsub_101_122 sn_101 sn_122 11027844.15914924
Csub_101_122 sn_101 sn_122 9.554436343288742e-19
Rsub_101_227 sn_101 sn_227 517183.8551873858
Csub_101_227 sn_101 sn_227 2.037280049744095e-17
Rsub_101_148 sn_101 sn_148 3675005.391528084
Csub_101_148 sn_101 sn_148 2.867066134520386e-18
Rsub_101_153 sn_101 sn_153 191623.1557919153
Csub_101_153 sn_101 sn_153 5.498543982686325e-17
Rsub_101_131 sn_101 sn_131 1155587.266487268
Csub_101_131 sn_101 sn_131 9.117860509365595e-18
Rsub_101_199 sn_101 sn_199 291717.8598504975
Csub_101_199 sn_101 sn_199 3.611874674944429e-17
Rsub_101_225 sn_101 sn_225 714353.324570569
Csub_101_225 sn_101 sn_225 1.474968078095524e-17
Rsub_101_188 sn_101 sn_188 373863.8623900811
Csub_101_188 sn_101 sn_188 2.818267439615887e-17
Rsub_101_109 sn_101 sn_109 2625431.686958594
Csub_101_109 sn_101 sn_109 4.013238491242515e-18
Rsub_101_114 sn_101 sn_114 67080.3651659718
Csub_101_114 sn_101 sn_114 1.570725424073108e-16
Rsub_101_179 sn_101 sn_179 8127130.642871546
Csub_101_179 sn_101 sn_179 1.296457995476145e-18
Rsub_101_105 sn_101 sn_105 39424.00915293322
Csub_101_105 sn_101 sn_105 2.672605787340648e-16
Rsub_101_184 sn_101 sn_184 7508137.753361461
Csub_101_184 sn_101 sn_184 1.403341793710794e-18
Rsub_101_216 sn_101 sn_216 870617.4696517671
Csub_101_216 sn_101 sn_216 1.210231114067172e-17
Rsub_101_215 sn_101 sn_215 261545.9105455824
Csub_101_215 sn_101 sn_215 4.028540717861347e-17
Rsub_101_136 sn_101 sn_136 13483327.86798132
Csub_101_136 sn_101 sn_136 7.814453230979312e-19
Rsub_101_178 sn_101 sn_178 240440.0633263499
Csub_101_178 sn_101 sn_178 4.382166331377481e-17
Rsub_101_222 sn_101 sn_222 638955.3254732738
Csub_101_222 sn_101 sn_222 1.649017244582105e-17
Rsub_101_138 sn_101 sn_138 581577.5453579829
Csub_101_138 sn_101 sn_138 1.811707413109356e-17
Rsub_101_230 sn_101 0 87273.54787375656
Csub_101_230 sn_101 0 1.207294049449129e-16
Rsub_101_204 sn_101 sn_204 13235.40545303675
Csub_101_204 sn_101 sn_204 7.960831679555761e-16
Rsub_101_130 sn_101 sn_130 2272226.115753461
Csub_101_130 sn_101 sn_130 4.637075258126829e-18
Rsub_101_198 sn_101 sn_198 1472247.162436176
Csub_101_198 sn_101 sn_198 7.1567354796561e-18
Rsub_101_129 sn_101 sn_129 1162244.570289681
Csub_101_129 sn_101 sn_129 9.065633664009167e-18
Rsub_101_203 sn_101 sn_203 2532586.296675652
Csub_101_203 sn_101 sn_203 4.16036504503736e-18
Rsub_101_166 sn_101 sn_166 2743560.691072895
Csub_101_166 sn_101 sn_166 3.840441196184952e-18
Rsub_101_170 sn_101 sn_170 550691.3646574524
Csub_101_170 sn_101 sn_170 1.91331917993376e-17
Rsub_101_133 sn_101 sn_133 766492.3700951188
Csub_101_133 sn_101 sn_133 1.374636449534712e-17
Rsub_101_226 sn_101 sn_226 1207016.810026937
Csub_101_226 sn_101 sn_226 8.729359371552464e-18
Rsub_101_150 sn_101 sn_150 7176934.725909889
Csub_101_150 sn_101 sn_150 1.46810357131877e-18
Rsub_101_229 sn_101 sn_229 13904681.86385574
Csub_101_229 sn_101 sn_229 7.577651617919332e-19
Rsub_101_144 sn_101 sn_144 36487020.40209788
Csub_101_144 sn_101 sn_144 2.887734702947733e-19
Rsub_101_160 sn_101 sn_160 21157905.17782776
Csub_101_160 sn_101 sn_160 4.979927556000022e-19
Rsub_101_142 sn_101 sn_142 3850074.065998999
Csub_101_142 sn_101 sn_142 2.736696313268468e-18
Rsub_101_211 sn_101 sn_211 6160544.497576467
Csub_101_211 sn_101 sn_211 1.71031692188491e-18
Rsub_101_132 sn_101 sn_132 1949499.121414526
Csub_101_132 sn_101 sn_132 5.404713131947911e-18
Rsub_101_128 sn_101 sn_128 13235472.57629049
Csub_101_128 sn_101 sn_128 7.960791306465815e-19
Rsub_101_141 sn_101 sn_141 901035.3007929539
Csub_101_141 sn_101 sn_141 1.169375216815301e-17
Rsub_101_220 sn_101 sn_220 5501884.88862596
Csub_101_220 sn_101 sn_220 1.915067965891482e-18
Rsub_101_177 sn_101 sn_177 2058581.168500929
Csub_101_177 sn_101 sn_177 5.11832307778407e-18
Rsub_101_192 sn_101 sn_192 2719130.260719827
Csub_101_192 sn_101 sn_192 3.874946211455391e-18
Rsub_101_135 sn_101 sn_135 1450391.43242143
Csub_101_135 sn_101 sn_135 7.26457924854074e-18
Rsub_101_214 sn_101 sn_214 1426962.888396602
Csub_101_214 sn_101 sn_214 7.383852507943819e-18
Rsub_101_111 sn_101 sn_111 13731183.15967215
Csub_101_111 sn_101 sn_111 7.673398118506761e-19
Rsub_101_186 sn_101 sn_186 45212960.3556627
Csub_101_186 sn_101 sn_186 2.330412213521506e-19
Rsub_101_156 sn_101 sn_156 3102914.279525244
Csub_101_156 sn_101 sn_156 3.395673406692408e-18
Rsub_101_191 sn_101 sn_191 10199969.4256883
Csub_101_191 sn_101 sn_191 1.032991675023476e-18
Rsub_101_174 sn_101 sn_174 12987617.28459966
Csub_101_174 sn_101 sn_174 8.11271480468081e-19
Rsub_101_202 sn_101 sn_202 10787721.04305745
Csub_101_202 sn_101 sn_202 9.767107862889046e-19
Rsub_101_134 sn_101 sn_134 4229006.08133138
Csub_101_134 sn_101 sn_134 2.491479865385508e-18
Rsub_101_196 sn_101 sn_196 14108047.11385653
Csub_101_196 sn_101 sn_196 7.46842097789804e-19
Rsub_101_200 sn_101 sn_200 14815119.51951315
Csub_101_200 sn_101 sn_200 7.111980087877312e-19
Rsub_101_168 sn_101 sn_168 3036122.439061963
Csub_101_168 sn_101 sn_168 3.470375030555534e-18
Rsub_168_204 sn_168 sn_204 5512323.037914747
Csub_168_204 sn_168 sn_204 1.911441588193975e-18
Rsub_168_211 sn_168 sn_211 20199162.66469009
Csub_168_211 sn_168 sn_211 5.216297168916163e-19
Rsub_168_213 sn_168 sn_213 16864074.04084364
Csub_168_213 sn_168 sn_213 6.247887359075484e-19
Rsub_168_189 sn_168 sn_189 1439513.607175922
Csub_168_189 sn_168 sn_189 7.319474751545261e-18
Rsub_168_226 sn_168 sn_226 961347.2945845324
Csub_168_226 sn_168 sn_226 1.096012186395508e-17
Rsub_168_169 sn_168 sn_169 623729.4872624319
Csub_168_169 sn_168 sn_169 1.68927134557562e-17
Rsub_168_206 sn_168 sn_206 1587910.484532105
Csub_168_206 sn_168 sn_206 6.635439217050509e-18
Rsub_168_186 sn_168 sn_186 7587959.452221727
Csub_168_186 sn_168 sn_186 1.388579310231416e-18
Rsub_168_190 sn_168 sn_190 245616.7956043828
Csub_168_190 sn_168 sn_190 4.289805783152228e-17
Rsub_168_222 sn_168 sn_222 10883.45992129246
Csub_168_222 sn_168 sn_222 9.681189234331972e-16
Rsub_168_170 sn_168 sn_170 1148731.88502941
Csub_168_170 sn_168 sn_170 9.172273913124861e-18
Rsub_168_207 sn_168 sn_207 3644206.537451384
Csub_168_207 sn_168 sn_207 2.891297020063744e-18
Rsub_168_200 sn_168 sn_200 5538572.195238151
Csub_168_200 sn_168 sn_200 1.902382623321018e-18
Rsub_168_181 sn_168 sn_181 380445.77289082
Csub_168_181 sn_168 sn_181 2.769509941500586e-17
Rsub_168_218 sn_168 sn_218 542599.7475221854
Csub_168_218 sn_168 sn_218 1.941851899184526e-17
Rsub_168_216 sn_168 sn_216 37327.38066004981
Csub_168_216 sn_168 sn_216 2.822722440180977e-16
Rsub_168_196 sn_168 sn_196 11849897.19910547
Csub_168_196 sn_168 sn_196 8.891624395716599e-19
Rsub_168_230 sn_168 0 45078.03760588391
Csub_168_230 sn_168 0 2.337387353537924e-16
Rsub_168_228 sn_168 sn_228 4590645.315480896
Csub_168_228 sn_168 sn_228 2.295207487866277e-18
Rsub_168_191 sn_168 sn_191 3876504.105410579
Csub_168_191 sn_168 sn_191 2.718037493504481e-18
Rsub_168_177 sn_168 sn_177 150987.7255206151
Csub_168_177 sn_168 sn_177 6.978370901276611e-17
Rsub_168_214 sn_168 sn_214 1895105.27629896
Csub_168_214 sn_168 sn_214 5.55984072969666e-18
Rsub_168_210 sn_168 sn_210 12097.99260970757
Csub_168_210 sn_168 sn_210 8.709282475321902e-16
Rsub_168_215 sn_168 sn_215 556041.792812495
Csub_168_215 sn_168 sn_215 1.894908555152985e-17
Rsub_168_197 sn_168 sn_197 10399478.69880081
Csub_168_197 sn_168 sn_197 1.01317419914952e-18
Rsub_168_212 sn_168 sn_212 4348804.610522981
Csub_168_212 sn_168 sn_212 2.422845918792129e-18
Rsub_168_209 sn_168 sn_209 5420500.866526911
Csub_168_209 sn_168 sn_209 1.943821016116001e-18
Rsub_168_219 sn_168 sn_219 1036266.73072376
Csub_168_219 sn_168 sn_219 1.016773306508741e-17
Rsub_168_180 sn_168 sn_180 1274244.388111261
Csub_168_180 sn_168 sn_180 8.268809029520326e-18
Rsub_168_195 sn_168 sn_195 147515.5918493086
Csub_168_195 sn_168 sn_195 7.1426236170298e-17
Rsub_168_229 sn_168 sn_229 5958558.712412609
Csub_168_229 sn_168 sn_229 1.768293980267554e-18
Rsub_168_176 sn_168 sn_176 370841.2250013743
Csub_168_176 sn_168 sn_176 2.841238457830829e-17
Rsub_168_224 sn_168 sn_224 3800389.666636638
Csub_168_224 sn_168 sn_224 2.772474516160558e-18
Rsub_168_174 sn_168 sn_174 27696659.54375551
Csub_168_174 sn_168 sn_174 3.804243427112335e-19
Rsub_168_203 sn_168 sn_203 2736458.914059951
Csub_168_203 sn_168 sn_203 3.850408075960305e-18
Rsub_168_198 sn_168 sn_198 5748565.45382538
Csub_168_198 sn_168 sn_198 1.832889194158606e-18
Rsub_168_194 sn_168 sn_194 3764575.464297108
Csub_168_194 sn_168 sn_194 2.798850388883701e-18
Rsub_60_218 sn_60 sn_218 1179296.265739695
Csub_60_218 sn_60 sn_218 8.93455173931307e-18
Rsub_60_152 sn_60 sn_152 21731828.62165203
Csub_60_152 sn_60 sn_152 4.848410911786874e-19
Rsub_60_74 sn_60 sn_74 5837608.947172992
Csub_60_74 sn_60 sn_74 1.804931367890368e-18
Rsub_60_168 sn_60 sn_168 17820409.27376654
Csub_60_168 sn_60 sn_168 5.912593442924333e-19
Rsub_60_68 sn_60 sn_68 23990552.4169341
Csub_60_68 sn_60 sn_68 4.391930339541771e-19
Rsub_60_211 sn_60 sn_211 15359969.73510912
Csub_60_211 sn_60 sn_211 6.859703296254669e-19
Rsub_60_214 sn_60 sn_214 3436662.460382657
Csub_60_214 sn_60 sn_214 3.06590583849681e-18
Rsub_60_212 sn_60 sn_212 8645301.241079081
Csub_60_212 sn_60 sn_212 1.218752615833068e-18
Rsub_60_173 sn_60 sn_173 23880348.25843663
Csub_60_173 sn_60 sn_173 4.41219842700895e-19
Rsub_60_226 sn_60 sn_226 67801638.53559057
Csub_60_226 sn_60 sn_226 1.554016057694413e-19
Rsub_60_150 sn_60 sn_150 35214661.72753511
Csub_60_150 sn_60 sn_150 2.992072899564812e-19
Rsub_60_76 sn_60 sn_76 339059.1742492223
Csub_60_76 sn_60 sn_76 3.107564785869872e-17
Rsub_60_219 sn_60 sn_219 1493952.431980842
Csub_60_219 sn_60 sn_219 7.052757020020781e-18
Rsub_60_230 sn_60 0 210828.2942502394
Csub_60_230 sn_60 0 4.99766103012904e-17
Rsub_60_72 sn_60 sn_72 12071696.38110073
Csub_60_72 sn_60 sn_72 8.728254231713255e-19
Rsub_60_216 sn_60 sn_216 8134698.927089318
Csub_60_216 sn_60 sn_216 1.295251809153319e-18
Rsub_60_177 sn_60 sn_177 7264788.540807347
Csub_60_177 sn_60 sn_177 1.450349647900291e-18
Rsub_60_188 sn_60 sn_188 1053387.051416214
Csub_60_188 sn_60 sn_188 1.000248055837059e-17
Rsub_60_114 sn_60 sn_114 49576.94113766926
Csub_60_114 sn_60 sn_114 2.125279063299093e-16
Rsub_60_134 sn_60 sn_134 5663756.101732083
Csub_60_134 sn_60 sn_134 1.860334963754486e-18
Rsub_60_153 sn_60 sn_153 1152621.240913102
Csub_60_153 sn_60 sn_153 9.141323383805629e-18
Rsub_60_148 sn_60 sn_148 6805813.088118728
Csub_60_148 sn_60 sn_148 1.548159399297066e-18
Rsub_60_99 sn_60 sn_99 190861.8785926675
Csub_60_99 sn_60 sn_99 5.520475633961819e-17
Rsub_60_178 sn_60 sn_178 23889.89795494553
Csub_60_178 sn_60 sn_178 4.410434704284204e-16
Rsub_60_215 sn_60 sn_215 527565.4881483607
Csub_60_215 sn_60 sn_215 1.997189683353009e-17
Rsub_60_201 sn_60 sn_201 89926.2271016078
Csub_60_201 sn_60 sn_201 1.171680814577577e-16
Rsub_60_206 sn_60 sn_206 150869.7893567375
Csub_60_206 sn_60 sn_206 6.983825951606573e-17
Rsub_60_181 sn_60 sn_181 4581061.284972381
Csub_60_181 sn_60 sn_181 2.300009287540786e-18
Rsub_60_70 sn_60 sn_70 71192140.84270191
Csub_60_70 sn_60 sn_70 1.480006553744496e-19
Rsub_60_61 sn_60 sn_61 664946629.7022716
Csub_60_61 sn_60 sn_61 1.58456078000541e-20
Rsub_60_228 sn_60 sn_228 52222490.32102931
Csub_60_228 sn_60 sn_228 2.017614142385527e-19
Rsub_60_144 sn_60 sn_144 10720381.19321454
Csub_60_144 sn_60 sn_144 9.828459746281282e-19
Rsub_60_138 sn_60 sn_138 855821.4520561553
Csub_60_138 sn_60 sn_138 1.231154404568331e-17
Rsub_60_101 sn_60 sn_101 31120.04432297184
Csub_60_101 sn_60 sn_101 3.38575465795603e-16
Rsub_60_182 sn_60 sn_182 27910093.92251061
Csub_60_182 sn_60 sn_182 3.775151574725409e-19
Rsub_60_198 sn_60 sn_198 698425.6580302715
Csub_60_198 sn_60 sn_198 1.508604871697501e-17
Rsub_60_204 sn_60 sn_204 122963.2986929437
Csub_60_204 sn_60 sn_204 8.568803548887425e-17
Rsub_60_125 sn_60 sn_125 19394244.78382137
Csub_60_125 sn_60 sn_125 5.432788757528477e-19
Rsub_60_133 sn_60 sn_133 391552.5230788769
Csub_60_133 sn_60 sn_133 2.690950225369245e-17
Rsub_60_170 sn_60 sn_170 790902.5257584635
Csub_60_170 sn_60 sn_170 1.332210121863712e-17
Rsub_60_97 sn_60 sn_97 2002431.435649293
Csub_60_97 sn_60 sn_97 5.261844832561533e-18
Rsub_60_176 sn_60 sn_176 29579050.47432823
Csub_60_176 sn_60 sn_176 3.562143927295656e-19
Rsub_60_227 sn_60 sn_227 183125.2375569819
Csub_60_227 sn_60 sn_227 5.753703663565997e-17
Rsub_60_160 sn_60 sn_160 2311201.498467384
Csub_60_160 sn_60 sn_160 4.558877064252947e-18
Rsub_60_222 sn_60 sn_222 1172584.870277192
Csub_60_222 sn_60 sn_222 8.985689453539713e-18
Rsub_60_84 sn_60 sn_84 2315064.197929762
Csub_60_84 sn_60 sn_84 4.551270548631962e-18
Rsub_60_131 sn_60 sn_131 3217239.34665477
Csub_60_131 sn_60 sn_131 3.275007659341744e-18
Rsub_60_190 sn_60 sn_190 11742716.74991648
Csub_60_190 sn_60 sn_190 8.972781790299879e-19
Rsub_60_129 sn_60 sn_129 3689481.384199564
Csub_60_129 sn_60 sn_129 2.855816957731012e-18
Rsub_60_79 sn_60 sn_79 28141179.9651595
Csub_60_79 sn_60 sn_79 3.744151281245069e-19
Rsub_60_88 sn_60 sn_88 18370060.39210683
Csub_60_88 sn_60 sn_88 5.735682560280137e-19
Rsub_60_132 sn_60 sn_132 13244092.70941765
Csub_60_132 sn_60 sn_132 7.955609895978522e-19
Rsub_60_196 sn_60 sn_196 3150266.380785637
Csub_60_196 sn_60 sn_196 3.344632557581475e-18
Rsub_60_195 sn_60 sn_195 3168773.883881066
Csub_60_195 sn_60 sn_195 3.32509793640595e-18
Rsub_60_225 sn_60 sn_225 34687613.26716004
Csub_60_225 sn_60 sn_225 3.037534874792108e-19
Rsub_60_105 sn_60 sn_105 5640324.508574696
Csub_60_105 sn_60 sn_105 1.868063351002576e-18
Rsub_60_141 sn_60 sn_141 11266928.46804329
Csub_60_141 sn_60 sn_141 9.351691130475296e-19
Rsub_60_229 sn_60 sn_229 8057283.881481595
Csub_60_229 sn_60 sn_229 1.3076966949677e-18
Rsub_60_62 sn_60 sn_62 8788641.270079736
Csub_60_62 sn_60 sn_62 1.198875136490172e-18
Rsub_60_179 sn_60 sn_179 310441245.8009092
Csub_60_179 sn_60 sn_179 3.394034666703796e-20
Rsub_60_100 sn_60 sn_100 11178387.35868204
Csub_60_100 sn_60 sn_100 9.425763452405789e-19
Rsub_60_183 sn_60 sn_183 15636314.37418392
Csub_60_183 sn_60 sn_183 6.738469980896576e-19
Rsub_60_166 sn_60 sn_166 3840293.61572655
Csub_60_166 sn_60 sn_166 2.743666124663385e-18
Rsub_60_186 sn_60 sn_186 17818112.97481648
Csub_60_186 sn_60 sn_186 5.91335542496667e-19
Rsub_60_95 sn_60 sn_95 25281950.61446708
Csub_60_95 sn_60 sn_95 4.167591204849801e-19
Rsub_60_130 sn_60 sn_130 17053639.04426151
Csub_60_130 sn_60 sn_130 6.178437033223999e-19
Rsub_60_209 sn_60 sn_209 14318610.51382044
Csub_60_209 sn_60 sn_209 7.358593553515617e-19
Rsub_60_110 sn_60 sn_110 3446610.520472026
Csub_60_110 sn_60 sn_110 3.057056618276378e-18
Rsub_60_83 sn_60 sn_83 28464202.00314285
Csub_60_83 sn_60 sn_83 3.701661301120131e-19
Rsub_60_185 sn_60 sn_185 40098299.87124398
Csub_60_185 sn_60 sn_185 2.62766340120722e-19
Rsub_60_191 sn_60 sn_191 12777370.59641596
Csub_60_191 sn_60 sn_191 8.246206387083641e-19
Rsub_60_80 sn_60 sn_80 31751190.28167945
Csub_60_80 sn_60 sn_80 3.318453074910263e-19
Rsub_60_154 sn_60 sn_154 38788489.56764273
Csub_60_154 sn_60 sn_154 2.716394378764238e-19
Rsub_60_197 sn_60 sn_197 23285246.77106234
Csub_60_197 sn_60 sn_197 4.524961064756324e-19
Rsub_26_127 sn_26 sn_127 154321597.7922037
Csub_26_127 sn_26 sn_127 6.827614315150838e-20
Rsub_26_64 sn_26 sn_64 156169791.4193539
Csub_26_64 sn_26 sn_64 6.74681281601829e-20
Rsub_26_229 sn_26 sn_229 248419920.6952571
Csub_26_229 sn_26 sn_229 4.241400396852782e-20
Rsub_26_139 sn_26 sn_139 110390146.687054
Csub_26_139 sn_26 sn_139 9.54476809610551e-20
Rsub_26_165 sn_26 sn_165 211023402.687563
Csub_26_165 sn_26 sn_165 4.99304028275485e-20
Rsub_26_66 sn_26 sn_66 250861161.7938172
Csub_26_66 sn_26 sn_66 4.200125450622739e-20
Rsub_26_128 sn_26 sn_128 66092420.32128421
Csub_26_128 sn_26 sn_128 1.594204517100558e-19
Rsub_26_166 sn_26 sn_166 33969177.1931938
Csub_26_166 sn_26 sn_166 3.101777662233494e-19
Rsub_26_140 sn_26 sn_140 76957095.70242751
Csub_26_140 sn_26 sn_140 1.369137362326115e-19
Rsub_26_159 sn_26 sn_159 216760791.902959
Csub_26_159 sn_26 sn_159 4.860880701592496e-20
Rsub_26_162 sn_26 sn_162 22915676.16997194
Csub_26_162 sn_26 sn_162 4.597936986051807e-19
Rsub_26_217 sn_26 sn_217 103098712.9383032
Csub_26_217 sn_26 sn_217 1.021980120017142e-19
Rsub_26_138 sn_26 sn_138 71375579.72133371
Csub_26_138 sn_26 sn_138 1.476202861450204e-19
Rsub_26_59 sn_26 sn_59 89370213.00390689
Csub_26_59 sn_26 sn_59 1.178970391596738e-19
Rsub_26_226 sn_26 sn_226 64979553.167391
Csub_26_226 sn_26 sn_226 1.621507534083441e-19
Rsub_26_131 sn_26 sn_131 29623570.03659439
Csub_26_131 sn_26 sn_131 3.556790585744439e-19
Rsub_26_52 sn_26 sn_52 2007918.87091934
Csub_26_52 sn_26 sn_52 5.247464753098216e-18
Rsub_26_135 sn_26 sn_135 68924457.95728919
Csub_26_135 sn_26 sn_135 1.528700234212825e-19
Rsub_26_214 sn_26 sn_214 268338052.9961635
Csub_26_214 sn_26 sn_214 3.926570750806127e-20
Rsub_26_141 sn_26 sn_141 45721008.15778314
Csub_26_141 sn_26 sn_141 2.304516878951709e-19
Rsub_26_44 sn_26 sn_44 4473189.667237638
Csub_26_44 sn_26 sn_44 2.355474345163788e-18
Rsub_26_123 sn_26 sn_123 63492.06418461534
Csub_26_123 sn_26 sn_123 1.659496133499953e-16
Rsub_26_192 sn_26 sn_192 225280903.4906839
Csub_26_192 sn_26 sn_192 4.677042456315309e-20
Rsub_26_230 sn_26 0 2015857.041044583
Csub_26_230 sn_26 0 5.226800952497193e-18
Rsub_26_45 sn_26 sn_45 49200130.13247324
Csub_26_45 sn_26 sn_45 2.141556023095898e-19
Rsub_26_42 sn_26 sn_42 33299323.13990146
Csub_26_42 sn_26 sn_42 3.164173475227335e-19
Rsub_26_158 sn_26 sn_158 4587464.403657918
Csub_26_158 sn_26 sn_158 2.296798966729529e-18
Rsub_26_84 sn_26 sn_84 213253.0887936957
Csub_26_84 sn_26 sn_84 4.940835118417984e-17
Rsub_26_86 sn_26 sn_86 267419749.140449
Csub_26_86 sn_26 sn_86 3.940054366252596e-20
Rsub_26_93 sn_26 sn_93 59753.06261508505
Csub_26_93 sn_26 sn_93 1.763337817528034e-16
Rsub_26_184 sn_26 sn_184 3313335.718922794
Csub_26_184 sn_26 sn_184 3.180022912273901e-18
Rsub_26_206 sn_26 sn_206 267419749.140449
Csub_26_206 sn_26 sn_206 3.940054366252596e-20
Rsub_26_74 sn_26 sn_74 621095.8958997165
Csub_26_74 sn_26 sn_74 1.696434249813695e-17
Rsub_26_153 sn_26 sn_153 703384382.7423966
Csub_26_153 sn_26 sn_153 1.497969497296732e-20
Rsub_26_171 sn_26 sn_171 2162406.532381159
Csub_26_171 sn_26 sn_171 4.872572915615285e-18
Rsub_26_164 sn_26 sn_164 113728.4341116203
Csub_26_164 sn_26 sn_164 9.264599116777452e-17
Rsub_26_35 sn_26 sn_35 186686352.5157514
Csub_26_35 sn_26 sn_35 5.643949522952408e-20
Rsub_26_146 sn_26 sn_146 1060299.836976579
Csub_26_146 sn_26 sn_146 9.937267869694804e-18
Rsub_26_116 sn_26 sn_116 4756177.925780625
Csub_26_116 sn_26 sn_116 2.215325765068106e-18
Rsub_26_190 sn_26 sn_190 58158261.93216622
Csub_26_190 sn_26 sn_190 1.811691607035883e-19
Rsub_26_32 sn_26 sn_32 17533630.02894584
Csub_26_32 sn_26 sn_32 6.009299548830206e-19
Rsub_26_29 sn_26 sn_29 188018429.8652295
Csub_26_29 sn_26 sn_29 5.603963137966042e-20
Rsub_26_177 sn_26 sn_177 63386558.71821991
Csub_26_177 sn_26 sn_177 1.66225832657506e-19
Rsub_26_216 sn_26 sn_216 9298182.70706992
Csub_26_216 sn_26 sn_216 1.13317664689666e-18
Rsub_26_137 sn_26 sn_137 61449240.35353884
Csub_26_137 sn_26 sn_137 1.714664565682171e-19
Rsub_26_160 sn_26 sn_160 99895918.82143164
Csub_26_160 sn_26 sn_160 1.054746142438955e-19
Rsub_26_51 sn_26 sn_51 67751026.52023879
Csub_26_51 sn_26 sn_51 1.555176953530366e-19
Rsub_26_218 sn_26 sn_218 78838924.13198492
Csub_26_218 sn_26 sn_218 1.336457037971597e-19
Rsub_26_208 sn_26 sn_208 590147.2912765206
Csub_26_208 sn_26 sn_208 1.785398943277197e-17
Rsub_26_41 sn_26 sn_41 115557575.5747226
Csub_26_41 sn_26 sn_41 9.117951332768167e-20
Rsub_26_120 sn_26 sn_120 87905691.00967506
Csub_26_120 sn_26 sn_120 1.198612215114757e-19
Rsub_26_203 sn_26 sn_203 267419749.140449
Csub_26_203 sn_26 sn_203 3.940054366252596e-20
Rsub_26_36 sn_26 sn_36 15492755.23687948
Csub_26_36 sn_26 sn_36 6.800910064820876e-19
Rsub_26_222 sn_26 sn_222 24682797.12192453
Csub_26_222 sn_26 sn_222 4.268755866761533e-19
Rsub_26_30 sn_26 sn_30 872734523.9346415
Csub_26_30 sn_26 sn_30 1.207295370272194e-20
Rsub_26_148 sn_26 sn_148 267419749.140449
Csub_26_148 sn_26 sn_148 3.940054366252596e-20
Rsub_26_227 sn_26 sn_227 44356198.99563958
Csub_26_227 sn_26 sn_227 2.375425248512792e-19
Rsub_26_77 sn_26 sn_77 171740629.877399
Csub_26_77 sn_26 sn_77 6.135114043631792e-20
Rsub_26_181 sn_26 sn_181 5799647958.348728
Rsub_26_71 sn_26 sn_71 65650403.62422235
Csub_26_71 sn_26 sn_71 1.604938114705279e-19
Rsub_26_221 sn_26 sn_221 267419749.140449
Csub_26_221 sn_26 sn_221 3.940054366252596e-20
Rsub_26_134 sn_26 sn_134 142463356.070264
Csub_26_134 sn_26 sn_134 7.395925375387989e-20
Rsub_26_132 sn_26 sn_132 172664034.8951508
Csub_26_132 sn_26 sn_132 6.102303533349153e-20
Rsub_26_53 sn_26 sn_53 267419749.140449
Csub_26_53 sn_26 sn_53 3.940054366252596e-20
Rsub_26_191 sn_26 sn_191 120172052.0786898
Csub_26_191 sn_26 sn_191 8.767831887676023e-20
Rsub_26_33 sn_26 sn_33 267419749.140449
Csub_26_33 sn_26 sn_33 3.940054366252596e-20
Rsub_26_112 sn_26 sn_112 268338052.9961635
Csub_26_112 sn_26 sn_112 3.926570750806127e-20
Rsub_26_157 sn_26 sn_157 36178087.14640085
Csub_26_157 sn_26 sn_157 2.912393753597947e-19
Rsub_26_215 sn_26 sn_215 27128364.11663274
Csub_26_215 sn_26 sn_215 3.883936184626021e-19
Rsub_26_224 sn_26 sn_224 8884201.654070044
Csub_26_224 sn_26 sn_224 1.185979777643049e-18
Rsub_26_57 sn_26 sn_57 92621809.82473108
Csub_26_57 sn_26 sn_57 1.137581258903088e-19
Rsub_26_169 sn_26 sn_169 163697064.1719424
Csub_26_169 sn_26 sn_169 6.436574507630021e-20
Rsub_26_31 sn_26 sn_31 21994328.34341832
Csub_26_31 sn_26 sn_31 4.790545697833499e-19
Rsub_26_207 sn_26 sn_207 134169026.4980818
Csub_26_207 sn_26 sn_207 7.853141501612254e-20
Rsub_26_40 sn_26 sn_40 848233716.3038617
Csub_26_40 sn_26 sn_40 1.242167494607763e-20
Rsub_26_107 sn_26 sn_107 130018034.4995495
Csub_26_107 sn_26 sn_107 8.103863085444896e-20
Rsub_26_186 sn_26 sn_186 12745686.47570033
Csub_26_186 sn_26 sn_186 8.266705384851431e-19
Rsub_26_126 sn_26 sn_126 134169026.4980818
Csub_26_126 sn_26 sn_126 7.853141501612254e-20
Rsub_26_43 sn_26 sn_43 139552948.9974732
Csub_26_43 sn_26 sn_43 7.550169006045714e-20
Rsub_26_125 sn_26 sn_125 69488277.4939159
Csub_26_125 sn_26 sn_125 1.516296544140489e-19
Rsub_171_182 sn_171 sn_182 13458463.88180712
Csub_171_182 sn_171 sn_182 7.828890127998192e-19
Rsub_171_203 sn_171 sn_203 16940289.54883922
Csub_171_203 sn_171 sn_203 6.219777691433841e-19
Rsub_171_178 sn_171 sn_178 9853130.581504397
Csub_171_178 sn_171 sn_178 1.069353888601491e-18
Rsub_171_183 sn_171 sn_183 6661955.277601616
Csub_171_183 sn_171 sn_183 1.581590248384745e-18
Rsub_171_212 sn_171 sn_212 3699070.043391954
Csub_171_212 sn_171 sn_212 2.848414163190139e-18
Rsub_171_221 sn_171 sn_221 3734802.958183238
Csub_171_221 sn_171 sn_221 2.821161817692085e-18
Rsub_171_184 sn_171 sn_184 245974.3518811608
Csub_171_184 sn_171 sn_184 4.283569982662486e-17
Rsub_171_195 sn_171 sn_195 402628.1549526241
Csub_171_195 sn_171 sn_195 2.616926653693603e-17
Rsub_171_185 sn_171 sn_185 2819646.753221106
Csub_171_185 sn_171 sn_185 3.736809758241291e-18
Rsub_171_222 sn_171 sn_222 353469.3849271319
Csub_171_222 sn_171 sn_222 2.980875841454305e-17
Rsub_171_208 sn_171 sn_208 569224.6983215363
Csub_171_208 sn_171 sn_208 1.851023599871678e-17
Rsub_171_191 sn_171 sn_191 2445544.80024831
Csub_171_191 sn_171 sn_191 4.308440189343565e-18
Rsub_171_216 sn_171 sn_216 23291.63297748356
Csub_171_216 sn_171 sn_216 4.523720390243057e-16
Rsub_171_230 sn_171 0 97462.62781074499
Csub_171_230 sn_171 0 1.081079357175755e-16
Rsub_171_186 sn_171 sn_186 5740579.413233691
Csub_171_186 sn_171 sn_186 1.835439028670236e-18
Rsub_171_224 sn_171 sn_224 689150.1485206627
Csub_171_224 sn_171 sn_224 1.528909704923917e-17
Rsub_171_207 sn_171 sn_207 1347292.747006858
Csub_171_207 sn_171 sn_207 7.820485581650924e-18
Rsub_171_190 sn_171 sn_190 97589.37500410814
Csub_171_190 sn_171 sn_190 1.079675272209342e-16
Rsub_171_227 sn_171 sn_227 4023010.855276035
Csub_171_227 sn_171 sn_227 2.619054206232573e-18
Rsub_171_206 sn_171 sn_206 34095014.53615357
Csub_171_206 sn_171 sn_206 3.090329670062864e-19
Rsub_171_210 sn_171 sn_210 3791979.409908294
Csub_171_210 sn_171 sn_210 2.778623606103604e-18
Rsub_171_213 sn_171 sn_213 18124418.20489217
Csub_171_213 sn_171 sn_213 5.813418882260164e-19
Rsub_171_176 sn_171 sn_176 30328193.12951956
Csub_171_176 sn_171 sn_176 3.474154710514042e-19
Rsub_171_209 sn_171 sn_209 25163152.31625705
Csub_171_209 sn_171 sn_209 4.187266909091808e-19
Rsub_171_172 sn_171 sn_172 13651381.30573071
Csub_171_172 sn_171 sn_172 7.718254487409923e-19
Rsub_171_174 sn_171 sn_174 10332937.16842025
Csub_171_174 sn_171 sn_174 1.019698787526923e-18
Rsub_171_177 sn_171 sn_177 4808803.037890143
Csub_171_177 sn_171 sn_177 2.191082358584782e-18
Rsub_171_218 sn_171 sn_218 4029198.184349095
Csub_171_218 sn_171 sn_218 2.615032326569992e-18
Rsub_171_225 sn_171 sn_225 832567.1531362503
Csub_171_225 sn_171 sn_225 1.265541579743982e-17
Rsub_171_226 sn_171 sn_226 4259874.222120182
Csub_171_226 sn_171 sn_226 2.473425963498493e-18
Rsub_171_196 sn_171 sn_196 4897004.834071872
Csub_171_196 sn_171 sn_196 2.151617950000856e-18
Rsub_171_192 sn_171 sn_192 5883798.917209955
Csub_171_192 sn_171 sn_192 1.790761997560975e-18
Rsub_171_198 sn_171 sn_198 14357020.87765619
Csub_171_198 sn_171 sn_198 7.338906582373167e-19
Rsub_171_180 sn_171 sn_180 17375275.58575663
Csub_171_180 sn_171 sn_180 6.064066984276944e-19
Rsub_184_200 sn_184 sn_200 11105906.96871049
Csub_184_200 sn_184 sn_200 9.48727873546504e-19
Rsub_184_212 sn_184 sn_212 2734059.321385698
Csub_184_212 sn_184 sn_212 3.853787450701624e-18
Rsub_184_201 sn_184 sn_201 27524949.78049624
Csub_184_201 sn_184 sn_201 3.827975558994841e-19
Rsub_184_203 sn_184 sn_203 25698285.18228031
Csub_184_203 sn_184 sn_203 4.10007260309151e-19
Rsub_184_206 sn_184 sn_206 11540566.56380038
Csub_184_206 sn_184 sn_206 9.129953407383037e-19
Rsub_184_191 sn_184 sn_191 2198333.025153529
Csub_184_191 sn_184 sn_191 4.792942371183339e-18
Rsub_184_213 sn_184 sn_213 3191154.642868048
Csub_184_213 sn_184 sn_213 3.301777783091185e-18
Rsub_184_188 sn_184 sn_188 23758886.46086917
Csub_184_188 sn_184 sn_188 4.43475476831945e-19
Rsub_184_197 sn_184 sn_197 11615619.07390965
Csub_184_197 sn_184 sn_197 9.070961638107141e-19
Rsub_184_217 sn_184 sn_217 564623.6216087755
Csub_184_217 sn_184 sn_217 1.866107456186215e-17
Rsub_184_211 sn_184 sn_211 109860395.6167021
Csub_184_211 sn_184 sn_211 9.590793336473419e-20
Rsub_184_210 sn_184 sn_210 4580299.07580325
Csub_184_210 sn_184 sn_210 2.300392032889733e-18
Rsub_184_220 sn_184 sn_220 17810374.8382851
Csub_184_220 sn_184 sn_220 5.915924621407082e-19
Rsub_184_224 sn_184 sn_224 131297.5745756757
Csub_184_224 sn_184 sn_224 8.024888149138743e-17
Rsub_184_227 sn_184 sn_227 8094261.880557702
Csub_184_227 sn_184 sn_227 1.301722585420479e-18
Rsub_184_190 sn_184 sn_190 216018.3711394625
Csub_184_190 sn_184 sn_190 4.877586774982022e-17
Rsub_184_216 sn_184 sn_216 346674.4616456899
Csub_184_216 sn_184 sn_216 3.039301900755111e-17
Rsub_184_208 sn_184 sn_208 377575.091525166
Csub_184_208 sn_184 sn_208 2.790566363811032e-17
Rsub_184_226 sn_184 sn_226 2363950.88736727
Csub_184_226 sn_184 sn_226 4.457149917342181e-18
Rsub_184_192 sn_184 sn_192 15403040.11016888
Csub_184_192 sn_184 sn_192 6.840522018295568e-19
Rsub_184_221 sn_184 sn_221 1984445.482503742
Csub_184_221 sn_184 sn_221 5.309535381610129e-18
Rsub_184_230 sn_184 0 171881.2654803145
Csub_184_230 sn_184 0 6.130094209387085e-17
Rsub_184_186 sn_184 sn_186 20817057.90710159
Csub_184_186 sn_184 sn_186 5.061466202020582e-19
Rsub_184_185 sn_184 sn_185 6565702.641178587
Csub_184_185 sn_184 sn_185 1.604776225494524e-18
Rsub_184_222 sn_184 sn_222 1920788.680885248
Csub_184_222 sn_184 sn_222 5.485498538742938e-18
Rsub_184_219 sn_184 sn_219 4184142.018504527
Csub_184_219 sn_184 sn_219 2.518194520078908e-18
Rsub_184_215 sn_184 sn_215 3698760.28820714
Csub_184_215 sn_184 sn_215 2.848652705562933e-18
Rsub_184_198 sn_184 sn_198 11770183.74086044
Csub_184_198 sn_184 sn_198 8.951842837977437e-19
Rsub_54_91 sn_54 sn_91 49282024.09996454
Csub_54_91 sn_54 sn_91 2.137997311323417e-19
Rsub_54_217 sn_54 sn_217 939475.7087591009
Csub_54_217 sn_54 sn_217 1.121528039947625e-17
Rsub_54_154 sn_54 sn_154 55771158.55310819
Csub_54_154 sn_54 sn_154 1.889235184561679e-19
Rsub_54_131 sn_54 sn_131 8618603.805260122
Csub_54_131 sn_54 sn_131 1.222527887382334e-18
Rsub_54_72 sn_54 sn_72 42641473.71921571
Csub_54_72 sn_54 sn_72 2.470947315660411e-19
Rsub_54_82 sn_54 sn_82 39355879.530623
Csub_54_82 sn_54 sn_82 2.677232379988234e-19
Rsub_54_128 sn_54 sn_128 90036946.50924617
Csub_54_128 sn_54 sn_128 1.17023998599819e-19
Rsub_54_175 sn_54 sn_175 120451673.8746943
Csub_54_175 sn_54 sn_175 8.747477858374215e-20
Rsub_54_145 sn_54 sn_145 119254880.6844272
Csub_54_145 sn_54 sn_145 8.835263967192833e-20
Rsub_54_158 sn_54 sn_158 29438559.00413262
Csub_54_158 sn_54 sn_158 3.579143768807052e-19
Rsub_54_191 sn_54 sn_191 55771158.55310819
Csub_54_191 sn_54 sn_191 1.889235184561679e-19
Rsub_54_107 sn_54 sn_107 59224780.38810699
Csub_54_107 sn_54 sn_107 1.779066707074839e-19
Rsub_54_207 sn_54 sn_207 25424152.37787873
Csub_54_207 sn_54 sn_207 4.144281133005511e-19
Rsub_54_206 sn_54 sn_206 24837123.91125814
Csub_54_206 sn_54 sn_206 4.242231725330338e-19
Rsub_54_108 sn_54 sn_108 55536935.30206853
Csub_54_108 sn_54 sn_108 1.897202905583729e-19
Rsub_54_187 sn_54 sn_187 55536935.30206853
Csub_54_187 sn_54 sn_187 1.897202905583729e-19
Rsub_54_230 sn_54 0 201522.8044926288
Csub_54_230 sn_54 0 5.228432349756923e-17
Rsub_54_212 sn_54 sn_212 490319.6020204551
Csub_54_212 sn_54 sn_212 2.148901136893654e-17
Rsub_54_133 sn_54 sn_133 27156884.71776406
Csub_54_133 sn_54 sn_133 3.87985721180228e-19
Rsub_54_213 sn_54 sn_213 189253.3358565204
Csub_54_213 sn_54 sn_213 5.56739645013078e-17
Rsub_54_203 sn_54 sn_203 91278.09816714766
Csub_54_203 sn_54 sn_203 1.154327677044244e-16
Rsub_54_138 sn_54 sn_138 973149.5677642941
Csub_54_138 sn_54 sn_138 1.082719846080437e-17
Rsub_54_227 sn_54 sn_227 359718.5519681923
Csub_54_227 sn_54 sn_227 2.92909093639454e-17
Rsub_54_148 sn_54 sn_148 354188.7094583859
Csub_54_148 sn_54 sn_148 2.974821958142611e-17
Rsub_54_190 sn_54 sn_190 18975240.97573873
Csub_54_190 sn_54 sn_190 5.552753462104479e-19
Rsub_54_130 sn_54 sn_130 6264130.735241891
Csub_54_130 sn_54 sn_130 1.68203441906982e-18
Rsub_54_172 sn_54 sn_172 1118603.773307268
Csub_54_172 sn_54 sn_172 9.419316967864144e-18
Rsub_54_218 sn_54 sn_218 1359835.739218134
Csub_54_218 sn_54 sn_218 7.748350185507091e-18
Rsub_54_139 sn_54 sn_139 8570407.156170284
Csub_54_139 sn_54 sn_139 1.22940291053083e-18
Rsub_54_144 sn_54 sn_144 167579.224445104
Csub_54_144 sn_54 sn_144 6.287464055952573e-17
Rsub_54_86 sn_54 sn_86 55393798.22222879
Csub_54_86 sn_54 sn_86 1.902105260946315e-19
Rsub_54_165 sn_54 sn_165 24689457.91138487
Csub_54_165 sn_54 sn_165 4.267604230132322e-19
Rsub_54_160 sn_54 sn_160 912353.3435276339
Csub_54_160 sn_54 sn_160 1.154868733367103e-17
Rsub_54_81 sn_54 sn_81 54495943.07522564
Csub_54_81 sn_54 sn_81 1.933443648765845e-19
Rsub_54_182 sn_54 sn_182 474207.6592990784
Csub_54_182 sn_54 sn_182 2.221913395031171e-17
Rsub_54_103 sn_54 sn_103 269557.534359263
Csub_54_103 sn_54 sn_103 3.908806899898077e-17
Rsub_54_142 sn_54 sn_142 618338.2801145478
Csub_54_142 sn_54 sn_142 1.703999872089127e-17
Rsub_54_221 sn_54 sn_221 217518.0363489739
Csub_54_221 sn_54 sn_221 4.843958542052049e-17
Rsub_54_196 sn_54 sn_196 708904.9684385234
Csub_54_196 sn_54 sn_196 1.486304084655845e-17
Rsub_54_88 sn_54 sn_88 16327.59511611224
Csub_54_88 sn_54 sn_88 6.453175392518457e-16
Rsub_54_155 sn_54 sn_155 7161434.720977362
Csub_54_155 sn_54 sn_155 1.471281092790863e-18
Rsub_54_76 sn_54 sn_76 23700713.33602051
Csub_54_76 sn_54 sn_76 4.445639822248127e-19
Rsub_54_192 sn_54 sn_192 305534.8616636801
Csub_54_192 sn_54 sn_192 3.44853724542508e-17
Rsub_54_185 sn_54 sn_185 6411314.400386943
Csub_54_185 sn_54 sn_185 1.643420185663347e-18
Rsub_54_222 sn_54 sn_222 127445.1024734165
Csub_54_222 sn_54 sn_222 8.267468343420875e-17
Rsub_54_64 sn_54 sn_64 12527141.55533073
Csub_54_64 sn_54 sn_64 8.410923957146761e-19
Rsub_54_211 sn_54 sn_211 69022.04089446888
Csub_54_211 sn_54 sn_211 1.526538967217695e-16
Rsub_54_132 sn_54 sn_132 18484876.02053094
Csub_54_132 sn_54 sn_132 5.700056354463645e-19
Rsub_54_174 sn_54 sn_174 267470.9297603271
Csub_54_174 sn_54 sn_174 3.939300436003059e-17
Rsub_54_95 sn_54 sn_95 93882.78376859013
Csub_54_95 sn_54 sn_95 1.122301989702519e-16
Rsub_54_58 sn_54 sn_58 44551.60888541336
Csub_54_58 sn_54 sn_58 2.365006285032223e-16
Rsub_54_216 sn_54 sn_216 2313872.861453425
Csub_54_216 sn_54 sn_216 4.553613847051071e-18
Rsub_54_137 sn_54 sn_137 38692317.94935724
Csub_54_137 sn_54 sn_137 2.723146107715946e-19
Rsub_54_135 sn_54 sn_135 15970558.59114103
Csub_54_135 sn_54 sn_135 6.597442063219163e-19
Rsub_54_56 sn_54 sn_56 55536935.30206853
Csub_54_56 sn_54 sn_56 1.897202905583729e-19
Rsub_54_215 sn_54 sn_215 361632.4840059358
Csub_54_215 sn_54 sn_215 2.913588786470039e-17
Rsub_54_200 sn_54 sn_200 564102.7953480069
Csub_54_200 sn_54 sn_200 1.867830400615161e-17
Rsub_54_170 sn_54 sn_170 896126.2671756312
Csub_54_170 sn_54 sn_170 1.175781124621912e-17
Rsub_54_226 sn_54 sn_226 1420508.739774136
Csub_54_226 sn_54 sn_226 7.417401390930776e-18
Rsub_54_166 sn_54 sn_166 3309880.524982986
Csub_54_166 sn_54 sn_166 3.183342547472816e-18
Rsub_54_105 sn_54 sn_105 41329193.75872336
Csub_54_105 sn_54 sn_105 2.549404559823058e-19
Rsub_54_178 sn_54 sn_178 23127316.56861808
Csub_54_178 sn_54 sn_178 4.555860802514014e-19
Rsub_54_146 sn_54 sn_146 55393798.22222879
Csub_54_146 sn_54 sn_146 1.902105260946315e-19
Rsub_54_181 sn_54 sn_181 10800905.03753004
Csub_54_181 sn_54 sn_181 9.755185760469837e-19
Rsub_54_110 sn_54 sn_110 35355833.05941024
Csub_54_110 sn_54 sn_110 2.980125934106827e-19
Rsub_54_66 sn_54 sn_66 32697555.98636571
Csub_54_66 sn_54 sn_66 3.222407052876835e-19
Rsub_54_57 sn_54 sn_57 4493700.819343762
Csub_54_57 sn_54 sn_57 2.344722963503543e-18
Rsub_54_224 sn_54 sn_224 31456734.18647131
Csub_54_224 sn_54 sn_224 3.349516017705823e-19
Rsub_54_73 sn_54 sn_73 65395111.97273142
Csub_54_73 sn_54 sn_73 1.611203526438417e-19
Rsub_54_125 sn_54 sn_125 23331645.77893114
Csub_54_125 sn_54 sn_125 4.51596239805107e-19
Rsub_54_122 sn_54 sn_122 53637124.48808026
Csub_54_122 sn_54 sn_122 1.96440126177374e-19
Rsub_54_228 sn_54 sn_228 43617953.71948839
Csub_54_228 sn_54 sn_228 2.415629942200229e-19
Rsub_54_70 sn_54 sn_70 21945551.64860804
Csub_54_70 sn_54 sn_70 4.801193276405204e-19
Rsub_54_210 sn_54 sn_210 22959212.55666277
Csub_54_210 sn_54 sn_210 4.589218152071297e-19
Rsub_54_71 sn_54 sn_71 11817621.9542977
Csub_54_71 sn_54 sn_71 8.915908414550533e-19
Rsub_54_179 sn_54 sn_179 54495943.07522564
Csub_54_179 sn_54 sn_179 1.933443648765845e-19
Rsub_54_83 sn_54 sn_83 39152788.32612737
Csub_54_83 sn_54 sn_83 2.691119573519318e-19
Rsub_54_141 sn_54 sn_141 24572616.88330433
Csub_54_141 sn_54 sn_141 4.2878963816788e-19
Rsub_54_98 sn_54 sn_98 54313769.43552813
Csub_54_98 sn_54 sn_98 1.93992860590114e-19
Rsub_54_156 sn_54 sn_156 32628451.4550561
Csub_54_156 sn_54 sn_156 3.229231861261767e-19
Rsub_54_171 sn_54 sn_171 56656001.94592465
Csub_54_171 sn_54 sn_171 1.859729444426127e-19
Rsub_54_129 sn_54 sn_129 26003430.20367314
Csub_54_129 sn_54 sn_129 4.051959076053612e-19
Rsub_54_186 sn_54 sn_186 12425948.45983591
Csub_54_186 sn_54 sn_186 8.47941993022651e-19
Rsub_54_126 sn_54 sn_126 48139026.00970117
Csub_54_126 sn_54 sn_126 2.188761255806598e-19
Rsub_54_79 sn_54 sn_79 14577351.1477093
Csub_54_79 sn_54 sn_79 7.227982227680449e-19
Rsub_146_159 sn_146 sn_159 3932040.069669204
Csub_146_159 sn_146 sn_159 2.679648049241883e-18
Rsub_146_152 sn_146 sn_152 23746705.61359517
Csub_146_152 sn_146 sn_152 4.43702957103986e-19
Rsub_146_214 sn_146 sn_214 21651049.3096329
Csub_146_214 sn_146 sn_214 4.866500164286334e-19
Rsub_146_154 sn_146 sn_154 23962281.5090016
Csub_146_154 sn_146 sn_154 4.397111977117828e-19
Rsub_146_174 sn_146 sn_174 22977192.5662454
Csub_146_174 sn_146 sn_174 4.585627017683875e-19
Rsub_146_220 sn_146 sn_220 7917055.725687952
Csub_146_220 sn_146 sn_220 1.33085882773857e-18
Rsub_146_182 sn_146 sn_182 4382397.871850953
Csub_146_182 sn_146 sn_182 2.404273598686238e-18
Rsub_146_157 sn_146 sn_157 8705356.221880097
Csub_146_157 sn_146 sn_157 1.21034489958579e-18
Rsub_146_200 sn_146 sn_200 23504117.2475085
Csub_146_200 sn_146 sn_200 4.482824601016189e-19
Rsub_146_197 sn_146 sn_197 25492921.69019419
Csub_146_197 sn_146 sn_197 4.133101584147902e-19
Rsub_146_206 sn_146 sn_206 5948687.901460101
Csub_146_206 sn_146 sn_206 1.771228155984419e-18
Rsub_146_212 sn_146 sn_212 25498732.7019989
Csub_146_212 sn_146 sn_212 4.132159674509637e-19
Rsub_146_165 sn_146 sn_165 25498732.7019989
Csub_146_165 sn_146 sn_165 4.132159674509637e-19
Rsub_146_219 sn_146 sn_219 5833575.129471809
Csub_146_219 sn_146 sn_219 1.806179447145307e-18
Rsub_146_170 sn_146 sn_170 22614626.57185737
Csub_146_170 sn_146 sn_170 4.659145473285001e-19
Rsub_146_209 sn_146 sn_209 22614626.57185737
Csub_146_209 sn_146 sn_209 4.659145473285001e-19
Rsub_146_150 sn_146 sn_150 7062876.2353675
Csub_146_150 sn_146 sn_150 1.491811997139117e-18
Rsub_146_218 sn_146 sn_218 6397966.450126975
Csub_146_218 sn_146 sn_218 1.646848820537484e-18
Rsub_146_191 sn_146 sn_191 7297471.190512639
Csub_146_191 sn_146 sn_191 1.44385407316556e-18
Rsub_146_169 sn_146 sn_169 6715607.228488483
Csub_146_169 sn_146 sn_169 1.568954696685188e-18
Rsub_146_153 sn_146 sn_153 6939247.309601016
Csub_146_153 sn_146 sn_153 1.51838996826816e-18
Rsub_146_164 sn_146 sn_164 117279.0912864857
Csub_146_164 sn_146 sn_164 8.984110796434983e-17
Rsub_146_155 sn_146 sn_155 97524.98063515825
Csub_146_155 sn_146 sn_155 1.08038816656084e-16
Rsub_146_158 sn_146 sn_158 23030.79729466571
Csub_146_158 sn_146 sn_158 4.574953861745123e-16
Rsub_146_195 sn_146 sn_195 7170882.686182661
Csub_146_195 sn_146 sn_195 1.469342612804475e-18
Rsub_146_160 sn_146 sn_160 415385.3289867339
Csub_146_160 sn_146 sn_160 2.536556485500359e-17
Rsub_146_208 sn_146 sn_208 221993.0990259576
Csub_146_208 sn_146 sn_208 4.746311281053818e-17
Rsub_146_171 sn_146 sn_171 15695.5288517104
Csub_146_171 sn_146 sn_171 6.713047774163914e-16
Rsub_146_184 sn_146 sn_184 20708.36107033191
Csub_146_184 sn_146 sn_184 5.088033508033247e-16
Rsub_146_221 sn_146 sn_221 3105924.509862276
Csub_146_221 sn_146 sn_221 3.392382354681638e-18
Rsub_146_230 sn_146 0 78361.73662085332
Csub_146_230 sn_146 0 1.344595456480232e-16
Rsub_146_162 sn_146 sn_162 128541.8571059746
Csub_146_162 sn_146 sn_162 8.196928019752616e-17
Rsub_146_216 sn_146 sn_216 70385.15942026229
Csub_146_216 sn_146 sn_216 1.496975156270909e-16
Rsub_146_227 sn_146 sn_227 2317562.797299872
Csub_146_227 sn_146 sn_227 4.546363755280232e-18
Rsub_146_148 sn_146 sn_148 8536328.775449462
Csub_146_148 sn_146 sn_148 1.234310882276816e-18
Rsub_146_222 sn_146 sn_222 468882.2087314738
Csub_146_222 sn_146 sn_222 2.247149349243956e-17
Rsub_146_224 sn_146 sn_224 624561.8115549316
Csub_146_224 sn_146 sn_224 1.687020132722811e-17
Rsub_146_190 sn_146 sn_190 38215.08893815599
Csub_146_190 sn_146 sn_190 2.757152683664125e-16
Rsub_146_226 sn_146 sn_226 1664181.951928071
Csub_146_226 sn_146 sn_226 6.331329029270358e-18
Rsub_146_177 sn_146 sn_177 4009402.127785844
Csub_146_177 sn_146 sn_177 2.627943809679345e-18
Rsub_146_180 sn_146 sn_180 20047252.96419249
Csub_146_180 sn_146 sn_180 5.255824087743992e-19
Rsub_146_186 sn_146 sn_186 5995344.547067799
Csub_146_186 sn_146 sn_186 1.757444200164139e-18
Rsub_146_215 sn_146 sn_215 56172119.96785899
Csub_146_215 sn_146 sn_215 1.875749661621966e-19
Rsub_146_213 sn_146 sn_213 23342391.67011739
Csub_146_213 sn_146 sn_213 4.513883431970112e-19
Rsub_146_202 sn_146 sn_202 12563426.34129739
Csub_146_202 sn_146 sn_202 8.386632130436745e-19
Rsub_146_207 sn_146 sn_207 1777040.70862067
Csub_146_207 sn_146 sn_207 5.929230237166804e-18
Rsub_146_168 sn_146 sn_168 9702125.257967383
Csub_146_168 sn_146 sn_168 1.085997471902091e-18
Rsub_146_210 sn_146 sn_210 24312745.4521058
Csub_146_210 sn_146 sn_210 4.333728382500466e-19
Rsub_146_203 sn_146 sn_203 2487160.784638233
Csub_146_203 sn_146 sn_203 4.23634996470989e-18
Rsub_146_166 sn_146 sn_166 2131292.474773399
Csub_146_166 sn_146 sn_166 4.943706050175141e-18
Rsub_146_163 sn_146 sn_163 13306787.47698297
Csub_146_163 sn_146 sn_163 7.918127136587385e-19
Rsub_146_228 sn_146 sn_228 22042666.09921983
Csub_146_228 sn_146 sn_228 4.780040424693873e-19
Rsub_178_186 sn_178 sn_186 44905636.33240493
Csub_178_186 sn_178 sn_186 2.346361027875389e-19
Rsub_178_183 sn_178 sn_183 22274828.323912
Csub_178_183 sn_178 sn_183 4.730219846821041e-19
Rsub_178_218 sn_178 sn_218 8745484.445035461
Csub_178_218 sn_178 sn_218 1.204791291831893e-18
Rsub_178_217 sn_178 sn_217 11383531.33653834
Csub_178_217 sn_178 sn_217 9.255900643423779e-19
Rsub_178_224 sn_178 sn_224 30046777.43180059
Csub_178_224 sn_178 sn_224 3.506693363754381e-19
Rsub_178_229 sn_178 sn_229 4323638.286725401
Csub_178_229 sn_178 sn_229 2.43694842248472e-18
Rsub_178_201 sn_178 sn_201 155452.6229260298
Csub_178_201 sn_178 sn_201 6.777938708209291e-17
Rsub_178_204 sn_178 sn_204 334532.4806499103
Csub_178_204 sn_178 sn_204 3.149614495357919e-17
Rsub_178_203 sn_178 sn_203 3211762.116613095
Csub_178_203 sn_178 sn_203 3.280592746184159e-18
Rsub_178_227 sn_178 sn_227 3100308.183436791
Csub_178_227 sn_178 sn_227 3.398527784599134e-18
Rsub_178_190 sn_178 sn_190 16000937.98166093
Csub_178_190 sn_178 sn_190 6.584916155731698e-19
Rsub_178_179 sn_178 sn_179 2411520.488202329
Csub_178_179 sn_178 sn_179 4.369228274765535e-18
Rsub_178_216 sn_178 sn_216 11737075.7142434
Csub_178_216 sn_178 sn_216 8.977094259896069e-19
Rsub_178_230 sn_178 0 65060.66259237174
Csub_178_230 sn_178 0 1.619486043086409e-16
Rsub_178_222 sn_178 sn_222 256387.8454544677
Csub_178_222 sn_178 sn_222 4.109587755048705e-17
Rsub_178_185 sn_178 sn_185 9406077.644071437
Csub_178_185 sn_178 sn_185 1.120178240169115e-18
Rsub_178_188 sn_178 sn_188 644887.9336055946
Csub_178_188 sn_178 sn_188 1.633847208664627e-17
Rsub_178_198 sn_178 sn_198 47960.15285381175
Csub_178_198 sn_178 sn_198 2.19692450404536e-16
Rsub_178_215 sn_178 sn_215 61040.06009366451
Csub_178_215 sn_178 sn_215 1.726158769513336e-16
Rsub_178_182 sn_178 sn_182 1438163.874307886
Csub_178_182 sn_178 sn_182 7.326344160397348e-18
Rsub_178_219 sn_178 sn_219 3165723.456212547
Csub_178_219 sn_178 sn_219 3.328301934129075e-18
Rsub_178_199 sn_178 sn_199 15594.56032975884
Csub_178_199 sn_178 sn_199 6.756512065379236e-16
Rsub_178_206 sn_178 sn_206 13246.08276209757
Csub_178_206 sn_178 sn_206 7.954414668447613e-16
Rsub_178_195 sn_178 sn_195 754714.3575542471
Csub_178_195 sn_178 sn_195 1.396088917186482e-17
Rsub_178_181 sn_178 sn_181 4513114.875676498
Csub_178_181 sn_178 sn_181 2.334636673889366e-18
Rsub_178_213 sn_178 sn_213 1063236.440309681
Csub_178_213 sn_178 sn_213 9.909821656565047e-18
Rsub_178_221 sn_178 sn_221 2443893.254596384
Csub_178_221 sn_178 sn_221 4.311351767272721e-18
Rsub_178_214 sn_178 sn_214 2617721.319286569
Csub_178_214 sn_178 sn_214 4.025059285188388e-18
Rsub_178_212 sn_178 sn_212 2914369.447010293
Csub_178_212 sn_178 sn_212 3.615356149522792e-18
Rsub_178_191 sn_178 sn_191 12336494.12386313
Csub_178_191 sn_178 sn_191 8.540905865507383e-19
Rsub_178_208 sn_178 sn_208 4146946.35976454
Csub_178_208 sn_178 sn_208 2.540781237119318e-18
Rsub_178_226 sn_178 sn_226 3846644.051064475
Csub_178_226 sn_178 sn_226 2.739136598644801e-18
Rsub_178_200 sn_178 sn_200 6451815.227290675
Csub_178_200 sn_178 sn_200 1.633103728337026e-18
Rsub_178_220 sn_178 sn_220 9669861.445589984
Csub_178_220 sn_178 sn_220 1.089620938367762e-18
Rsub_178_209 sn_178 sn_209 561748.6603157503
Csub_178_209 sn_178 sn_209 1.87565796708934e-17
Rsub_178_197 sn_178 sn_197 112516038.8205007
Csub_178_197 sn_178 sn_197 9.364428051932297e-20
Rsub_178_210 sn_178 sn_210 14967386.21250935
Csub_178_210 sn_178 sn_210 7.039628264168049e-19
Rsub_178_211 sn_178 sn_211 3201533.725881111
Csub_178_211 sn_178 sn_211 3.291073717903815e-18
Rsub_198_209 sn_198 sn_209 503233.1748661929
Csub_198_209 sn_198 sn_209 2.093757730704379e-17
Rsub_198_229 sn_198 sn_229 2399724.802903405
Csub_198_229 sn_198 sn_229 4.390704921448496e-18
Rsub_198_225 sn_198 sn_225 8648545.910475604
Csub_198_225 sn_198 sn_225 1.218295377199492e-18
Rsub_198_205 sn_198 sn_205 5066307.959391035
Csub_198_205 sn_198 sn_205 2.079716350976911e-18
Rsub_198_218 sn_198 sn_218 1140685.556510045
Csub_198_218 sn_198 sn_218 9.236974591373476e-18
Rsub_198_210 sn_198 sn_210 4823250.319759262
Csub_198_210 sn_198 sn_210 2.184519318656449e-18
Rsub_198_219 sn_198 sn_219 1991869.261470028
Csub_198_219 sn_198 sn_219 5.289746524053453e-18
Rsub_198_208 sn_198 sn_208 1122737.821948707
Csub_198_208 sn_198 sn_208 9.384633969079351e-18
Rsub_198_224 sn_198 sn_224 4580147.094600986
Csub_198_224 sn_198 sn_224 2.300468365885074e-18
Rsub_198_204 sn_198 sn_204 538990.1130414514
Csub_198_204 sn_198 sn_204 1.954856545099499e-17
Rsub_198_216 sn_198 sn_216 589790.1573194844
Csub_198_216 sn_198 sn_216 1.78648005082297e-17
Rsub_198_220 sn_198 sn_220 4067065.185179232
Csub_198_220 sn_198 sn_220 2.590684688464286e-18
Rsub_198_221 sn_198 sn_221 434398.3253681393
Csub_198_221 sn_198 sn_221 2.425535018649221e-17
Rsub_198_215 sn_198 sn_215 12452.47015994701
Csub_198_215 sn_198 sn_215 8.46136016942267e-16
Rsub_198_230 sn_198 0 15741.49532314644
Csub_198_230 sn_198 0 6.69344511809946e-16
Rsub_198_213 sn_198 sn_213 26593.13292941161
Csub_198_213 sn_198 sn_213 3.962106883080635e-16
Rsub_198_199 sn_198 sn_199 27318.99272008883
Csub_198_199 sn_198 sn_199 3.856834551034552e-16
Rsub_198_212 sn_198 sn_212 281631.0708651124
Csub_198_212 sn_198 sn_212 3.741236174639433e-17
Rsub_198_214 sn_198 sn_214 81239.8501256201
Csub_198_214 sn_198 sn_214 1.296959987732323e-16
Rsub_198_211 sn_198 sn_211 350357.6178899511
Csub_198_211 sn_198 sn_211 3.007351050531335e-17
Rsub_198_206 sn_198 sn_206 89129.8592932981
Csub_198_206 sn_198 sn_206 1.182149684266613e-16
Rsub_198_222 sn_198 sn_222 42391.65897753045
Csub_198_222 sn_198 sn_222 2.485508648721398e-16
Rsub_198_226 sn_198 sn_226 141220.4403343119
Csub_198_226 sn_198 sn_226 7.461018728795158e-17
Rsub_198_200 sn_198 sn_200 228524.4992848215
Csub_198_200 sn_198 sn_200 4.610658172407963e-17
Rsub_198_227 sn_198 sn_227 85253.44545792199
Csub_198_227 sn_198 sn_227 1.235901193862062e-16
Rsub_198_201 sn_198 sn_201 497698.1254005663
Csub_198_201 sn_198 sn_201 2.117043035625228e-17
Rsub_198_207 sn_198 sn_207 2949193.531794549
Csub_198_207 sn_198 sn_207 3.572666014840564e-18
Rsub_198_203 sn_198 sn_203 467594.8747163172
Csub_198_203 sn_198 sn_203 2.253335969223856e-17
Rsub_218_228 sn_218 sn_228 8357704.243730657
Csub_218_228 sn_218 sn_228 1.260691117436192e-18
Rsub_218_225 sn_218 sn_225 5459780.492871942
Csub_218_225 sn_218 sn_225 1.929836467965331e-18
Rsub_218_227 sn_218 sn_227 235332.7398369894
Csub_218_227 sn_218 sn_227 4.477270569971873e-17
Rsub_218_224 sn_218 sn_224 221071.3275801539
Csub_218_224 sn_218 sn_224 4.766101338225233e-17
Rsub_218_226 sn_218 sn_226 2468.2831620692
Csub_218_226 sn_218 sn_226 4.268749900395181e-15
Rsub_218_219 sn_218 sn_219 1794731.283395989
Csub_218_219 sn_218 sn_219 5.870786116957229e-18
Rsub_218_230 sn_218 0 21773.21886137598
Csub_218_230 sn_218 0 4.839194227235236e-16
Rsub_218_222 sn_218 sn_222 66656.13040021488
Csub_218_222 sn_218 sn_222 1.580722349012332e-16
Rsub_218_221 sn_218 sn_221 49549.96478209129
Csub_218_221 sn_218 sn_221 2.126436123328623e-16
Rsub_142_220 sn_142 sn_220 4453534.075665907
Csub_142_220 sn_142 sn_220 2.365870188307598e-18
Rsub_142_154 sn_142 sn_154 13398353.67885587
Csub_142_154 sn_142 sn_154 7.864013560753939e-19
Rsub_142_190 sn_142 sn_190 13041743.50489393
Csub_142_190 sn_142 sn_190 8.079045181555804e-19
Rsub_142_217 sn_142 sn_217 1726759.123063321
Csub_142_217 sn_142 sn_217 6.1018837899857e-18
Rsub_142_185 sn_142 sn_185 9579922.071345212
Csub_142_185 sn_142 sn_185 1.099850648445877e-18
Rsub_142_229 sn_142 sn_229 13398353.67885587
Csub_142_229 sn_142 sn_229 7.864013560753939e-19
Rsub_142_150 sn_142 sn_150 2411132.407481938
Csub_142_150 sn_142 sn_150 4.369931518291757e-18
Rsub_142_152 sn_142 sn_152 6969121.258781949
Csub_142_152 sn_142 sn_152 1.511881212994068e-18
Rsub_142_181 sn_142 sn_181 13386937.62638402
Csub_142_181 sn_142 sn_181 7.870719798876092e-19
Rsub_142_208 sn_142 sn_208 3214295.374366423
Csub_142_208 sn_142 sn_208 3.27800723799594e-18
Rsub_142_168 sn_142 sn_168 12812494.10734697
Csub_142_168 sn_142 sn_168 8.223600661941493e-19
Rsub_142_225 sn_142 sn_225 11854431.41066186
Csub_142_225 sn_142 sn_225 8.88822343073621e-19
Rsub_142_177 sn_142 sn_177 1401921.124678534
Csub_142_177 sn_142 sn_177 7.515746297528726e-18
Rsub_142_175 sn_142 sn_175 13895060.87700452
Csub_142_175 sn_142 sn_175 7.582898409367345e-19
Rsub_142_207 sn_142 sn_207 2169522.049817868
Csub_142_207 sn_142 sn_207 4.856592032846378e-18
Rsub_142_199 sn_142 sn_199 28620470.20052518
Csub_142_199 sn_142 sn_199 3.681450174790161e-19
Rsub_142_216 sn_142 sn_216 2593714.19670128
Csub_142_216 sn_142 sn_216 4.062314774553974e-18
Rsub_142_184 sn_142 sn_184 32006926.77029979
Csub_142_184 sn_142 sn_184 3.291938516261151e-19
Rsub_142_210 sn_142 sn_210 2621271.297332796
Csub_142_210 sn_142 sn_210 4.019608162249789e-18
Rsub_142_164 sn_142 sn_164 4175695.370380889
Csub_142_164 sn_142 sn_164 2.523288355028856e-18
Rsub_142_155 sn_142 sn_155 7887913.382013268
Csub_142_155 sn_142 sn_155 1.335775761211608e-18
Rsub_142_159 sn_142 sn_159 10741581.51725381
Csub_142_159 sn_142 sn_159 9.809061622169538e-19
Rsub_142_166 sn_142 sn_166 32822.65749032121
Csub_142_166 sn_142 sn_166 3.21012505015385e-16
Rsub_142_203 sn_142 sn_203 8142.519229670372
Csub_142_203 sn_142 sn_203 1.294007813188369e-15
Rsub_142_156 sn_142 sn_156 17765967.77548505
Csub_142_156 sn_142 sn_156 5.930711816763011e-19
Rsub_142_218 sn_142 sn_218 56746.19471209163
Csub_142_218 sn_142 sn_218 1.856773578508315e-16
Rsub_142_223 sn_142 sn_223 10131650.96071032
Csub_142_223 sn_142 sn_223 1.039957213596243e-18
Rsub_142_144 sn_142 sn_144 445740.9754749672
Csub_142_144 sn_142 sn_144 2.36381308471869e-17
Rsub_142_214 sn_142 sn_214 3000968.839280601
Csub_142_214 sn_142 sn_214 3.511027293690871e-18
Rsub_142_196 sn_142 sn_196 266143.6283421203
Csub_142_196 sn_142 sn_196 3.95894636586439e-17
Rsub_142_222 sn_142 sn_222 96380.19704049897
Csub_142_222 sn_142 sn_222 1.093220788685726e-16
Rsub_142_186 sn_142 sn_186 5001871.022227407
Csub_142_186 sn_142 sn_186 2.106508435624945e-18
Rsub_142_178 sn_142 sn_178 16000937.98166093
Csub_142_178 sn_142 sn_178 6.584916155731698e-19
Rsub_142_215 sn_142 sn_215 434722.3661989468
Csub_142_215 sn_142 sn_215 2.423727031658655e-17
Rsub_142_192 sn_142 sn_192 12925.74762560567
Csub_142_192 sn_142 sn_192 8.151546670582846e-16
Rsub_142_226 sn_142 sn_226 90263.000711813
Csub_142_226 sn_142 sn_226 1.167309242894587e-16
Rsub_142_198 sn_142 sn_198 937495.6500921955
Csub_142_198 sn_142 sn_198 1.123896788341772e-17
Rsub_142_221 sn_142 sn_221 62190.75539926277
Csub_142_221 sn_142 sn_221 1.694220215623061e-16
Rsub_142_160 sn_142 sn_160 48624.92112576171
Csub_142_160 sn_142 sn_160 2.166889582191574e-16
Rsub_142_197 sn_142 sn_197 9400586.108059175
Csub_142_197 sn_142 sn_197 1.120832614170409e-18
Rsub_142_183 sn_142 sn_183 10482083.97588938
Csub_142_183 sn_142 sn_183 1.005189762500067e-18
Rsub_142_200 sn_142 sn_200 1326878.548303512
Csub_142_200 sn_142 sn_200 7.940804767475881e-18
Rsub_142_206 sn_142 sn_206 3829837.516698733
Csub_142_206 sn_142 sn_206 2.751156793542589e-18
Rsub_142_148 sn_142 sn_148 1887624.59871017
Csub_142_148 sn_142 sn_148 5.5818744412579e-18
Rsub_142_227 sn_142 sn_227 290475.7101036669
Csub_142_227 sn_142 sn_227 3.627319991220494e-17
Rsub_142_174 sn_142 sn_174 1726900.845315558
Csub_142_174 sn_142 sn_174 6.101383024283982e-18
Rsub_142_211 sn_142 sn_211 564703.2370829907
Csub_142_211 sn_142 sn_211 1.865844360421387e-17
Rsub_142_162 sn_142 sn_162 11568257.5427774
Csub_142_162 sn_142 sn_162 9.108099005634968e-19
Rsub_142_212 sn_142 sn_212 155614.3695725884
Csub_142_212 sn_142 sn_212 6.770893672075135e-17
Rsub_142_213 sn_142 sn_213 671044.3796453538
Csub_142_213 sn_142 sn_213 1.570161947828029e-17
Rsub_142_195 sn_142 sn_195 8284810.751611183
Csub_142_195 sn_142 sn_195 1.27178324504044e-18
Rsub_142_182 sn_142 sn_182 772515.6873363857
Csub_142_182 sn_142 sn_182 1.363918387024544e-17
Rsub_142_170 sn_142 sn_170 1468673.748496732
Csub_142_170 sn_142 sn_170 7.174148454014837e-18
Rsub_142_165 sn_142 sn_165 1304400.853553677
Csub_142_165 sn_142 sn_165 8.077642293413614e-18
Rsub_142_230 sn_142 0 59456.1432447382
Csub_142_230 sn_142 0 1.772143789895499e-16
Rsub_142_151 sn_142 sn_151 9791336.007636229
Csub_142_151 sn_142 sn_151 1.076102739606999e-18
Rsub_142_157 sn_142 sn_157 6138391.183267991
Csub_142_157 sn_142 sn_157 1.716489416795449e-18
Rsub_226_229 sn_226 sn_229 1582696.465473441
Csub_226_229 sn_226 sn_229 6.657298940184443e-18
Rsub_226_228 sn_226 sn_228 2677923.351935717
Csub_226_228 sn_226 sn_228 3.934572471842326e-18
Rsub_226_230 sn_226 0 10737.45909912115
Csub_226_230 sn_226 0 9.812827601915993e-16
Rsub_226_227 sn_226 sn_227 65055.25274553666
Csub_226_227 sn_226 sn_227 1.619620715861855e-16
Rsub_14_20 sn_14 sn_20 51191633.4745377
Csub_14_20 sn_14 sn_20 2.058243268887046e-19
Rsub_14_40 sn_14 sn_40 1799730561.854852
Rsub_14_127 sn_14 sn_127 225357757.5700021
Csub_14_127 sn_14 sn_127 4.675447437817662e-20
Rsub_14_85 sn_14 sn_85 278082547.8932219
Csub_14_85 sn_14 sn_85 3.788976899864928e-20
Rsub_14_196 sn_14 sn_196 300527019.728052
Csub_14_196 sn_14 sn_196 3.506002059902801e-20
Rsub_14_93 sn_14 sn_93 232143379.6622032
Csub_14_93 sn_14 sn_93 4.538782677137666e-20
Rsub_14_182 sn_14 sn_182 93912310.7837867
Csub_14_182 sn_14 sn_182 1.121949126189434e-19
Rsub_14_125 sn_14 sn_125 34977184.11404783
Csub_14_125 sn_14 sn_125 3.012387580393658e-19
Rsub_14_209 sn_14 sn_209 173866343.5487121
Csub_14_209 sn_14 sn_209 6.060105301103313e-20
Rsub_14_134 sn_14 sn_134 300527019.728052
Csub_14_134 sn_14 sn_134 3.506002059902801e-20
Rsub_14_154 sn_14 sn_154 32552311.17614122
Csub_14_154 sn_14 sn_154 3.23678507655474e-19
Rsub_14_95 sn_14 sn_95 42851653.99551328
Csub_14_95 sn_14 sn_95 2.458827727707596e-19
Rsub_14_229 sn_14 sn_229 275548114.4149042
Csub_14_229 sn_14 sn_229 3.823827110776299e-20
Rsub_14_107 sn_14 sn_107 57427094.10051807
Csub_14_107 sn_14 sn_107 1.834758256057213e-19
Rsub_14_128 sn_14 sn_128 179481305.7065872
Csub_14_128 sn_14 sn_128 5.870518637442306e-20
Rsub_14_84 sn_14 sn_84 229763620.740556
Csub_14_84 sn_14 sn_84 4.585792767484094e-20
Rsub_14_22 sn_14 sn_22 75003567.97054107
Csub_14_22 sn_14 sn_22 1.404797636609552e-19
Rsub_14_33 sn_14 sn_33 292208096.9965847
Csub_14_33 sn_14 sn_33 3.605815037477608e-20
Rsub_14_200 sn_14 sn_200 151826744.7711036
Csub_14_200 sn_14 sn_200 6.939807290286683e-20
Rsub_14_159 sn_14 sn_159 302339461.5485412
Csub_14_159 sn_14 sn_159 3.484984542958295e-20
Rsub_14_230 sn_14 0 1042985.087279869
Csub_14_230 sn_14 0 1.010223792337186e-17
Rsub_14_221 sn_14 sn_221 278561322.958802
Csub_14_221 sn_14 sn_221 3.782464625854861e-20
Rsub_14_192 sn_14 sn_192 216743019.5535182
Csub_14_192 sn_14 sn_192 4.861279280843612e-20
Rsub_14_145 sn_14 sn_145 133732600.194673
Csub_14_145 sn_14 sn_145 7.878769639483692e-20
Rsub_14_117 sn_14 sn_117 66992330.56585576
Csub_14_117 sn_14 sn_117 1.572789513849242e-19
Rsub_14_169 sn_14 sn_169 215367769.937621
Csub_14_169 sn_14 sn_169 4.892321402260785e-20
Rsub_14_155 sn_14 sn_155 37282153.33005648
Csub_14_155 sn_14 sn_155 2.826146711256508e-19
Rsub_14_160 sn_14 sn_160 89242850.70184521
Csub_14_160 sn_14 sn_160 1.180652950837679e-19
Rsub_14_186 sn_14 sn_186 302339461.5485412
Csub_14_186 sn_14 sn_186 3.484984542958295e-20
Rsub_14_50 sn_14 sn_50 19410703.72059546
Csub_14_50 sn_14 sn_50 5.42818212770432e-19
Rsub_14_172 sn_14 sn_172 176215824.2859536
Csub_14_172 sn_14 sn_172 5.979306083846341e-20
Rsub_14_30 sn_14 sn_30 64702302.73507361
Csub_14_30 sn_14 sn_30 1.62845572055945e-19
Rsub_14_24 sn_14 sn_24 34538546.84704183
Csub_14_24 sn_14 sn_24 3.050644703985985e-19
Rsub_14_75 sn_14 sn_75 302339461.5485412
Csub_14_75 sn_14 sn_75 3.484984542958295e-20
Rsub_14_132 sn_14 sn_132 54067749.29085024
Csub_14_132 sn_14 sn_132 1.948755707501415e-19
Rsub_14_122 sn_14 sn_122 302339461.5485412
Csub_14_122 sn_14 sn_122 3.484984542958295e-20
Rsub_14_137 sn_14 sn_137 127860384.3720825
Csub_14_137 sn_14 sn_137 8.240616164243735e-20
Rsub_14_225 sn_14 sn_225 110764752.5688787
Csub_14_225 sn_14 sn_225 9.512487734469435e-20
Rsub_14_58 sn_14 sn_58 100611434.6975497
Csub_14_58 sn_14 sn_58 1.047245130128992e-19
Rsub_14_222 sn_14 sn_222 10595343.226852
Csub_14_222 sn_14 sn_222 9.944447552701424e-19
Rsub_14_72 sn_14 sn_72 67767433.53281176
Csub_14_72 sn_14 sn_72 1.554800433327378e-19
Rsub_14_151 sn_14 sn_151 86600292.27997048
Csub_14_151 sn_14 sn_151 1.216679900821415e-19
Rsub_14_139 sn_14 sn_139 26308156.1468679
Csub_14_139 sn_14 sn_139 4.005025454238995e-19
Rsub_14_227 sn_14 sn_227 200019884.488757
Csub_14_227 sn_14 sn_227 5.267718021716113e-20
Rsub_14_60 sn_14 sn_60 2636193.816495638
Csub_14_60 sn_14 sn_60 3.996854645625573e-18
Rsub_14_89 sn_14 sn_89 177264245.9767039
Csub_14_89 sn_14 sn_89 5.943941737475197e-20
Rsub_14_43 sn_14 sn_43 50403046.07898624
Csub_14_43 sn_14 sn_43 2.090445780939182e-19
Rsub_14_210 sn_14 sn_210 94257319.49234369
Csub_14_210 sn_14 sn_210 1.11784247196695e-19
Rsub_14_131 sn_14 sn_131 11913492.31226241
Csub_14_131 sn_14 sn_131 8.844160239550358e-19
Rsub_14_177 sn_14 sn_177 14454020.9158751
Csub_14_177 sn_14 sn_177 7.28965563531017e-19
Rsub_14_97 sn_14 sn_97 22459881.87730263
Csub_14_97 sn_14 sn_97 4.691246178314899e-19
Rsub_14_185 sn_14 sn_185 297217305.2763146
Csub_14_185 sn_14 sn_185 3.545043749197082e-20
Rsub_14_171 sn_14 sn_171 202288292.32809
Csub_14_171 sn_14 sn_171 5.208647213819449e-20
Rsub_14_157 sn_14 sn_157 283239629.4636717
Csub_14_157 sn_14 sn_157 3.719989156242491e-20
Rsub_14_78 sn_14 sn_78 7478178.891450416
Csub_14_78 sn_14 sn_78 1.408963820626978e-18
Rsub_14_46 sn_14 sn_46 202505.4967554767
Csub_14_46 sn_14 sn_46 5.203060495169026e-17
Rsub_14_204 sn_14 sn_204 835078.0831151026
Csub_14_204 sn_14 sn_204 1.261736323258014e-17
Rsub_14_41 sn_14 sn_41 1371482.287373591
Csub_14_41 sn_14 sn_41 7.682551644474773e-18
Rsub_14_199 sn_14 sn_199 3175941.853501094
Csub_14_199 sn_14 sn_199 3.317593327665869e-18
Rsub_14_224 sn_14 sn_224 191931786.2966354
Csub_14_224 sn_14 sn_224 5.489702203857781e-20
Rsub_14_76 sn_14 sn_76 56845.63865023866
Csub_14_76 sn_14 sn_76 1.853525398326361e-16
Rsub_14_178 sn_14 sn_178 3131815.873701361
Csub_14_178 sn_14 sn_178 3.36433683432908e-18
Rsub_14_99 sn_14 sn_99 181342.7420749124
Csub_14_99 sn_14 sn_99 5.810259281221963e-17
Rsub_14_195 sn_14 sn_195 1258712.551138544
Csub_14_195 sn_14 sn_195 8.370841692727565e-18
Rsub_14_130 sn_14 sn_130 302339461.5485412
Csub_14_130 sn_14 sn_130 3.484984542958296e-20
Rsub_14_218 sn_14 sn_218 302339461.5485412
Csub_14_218 sn_14 sn_218 3.484984542958295e-20
Rsub_14_51 sn_14 sn_51 709338.6512201377
Csub_14_51 sn_14 sn_51 1.485395372732915e-17
Rsub_14_133 sn_14 sn_133 9789500.319973053
Csub_14_133 sn_14 sn_133 1.07630452605767e-18
Rsub_14_77 sn_14 sn_77 61657116.99145299
Csub_14_77 sn_14 sn_77 1.708883583332413e-19
Rsub_14_114 sn_14 sn_114 15880679.55222571
Csub_14_114 sn_14 sn_114 6.634781255789075e-19
Rsub_14_202 sn_14 sn_202 302339461.5485412
Csub_14_202 sn_14 sn_202 3.484984542958295e-20
Rsub_14_35 sn_14 sn_35 137906461.6580597
Csub_14_35 sn_14 sn_35 7.640311683404153e-20
Rsub_14_101 sn_14 sn_101 231793.3104476545
Csub_14_101 sn_14 sn_101 4.545637439614306e-17
Rsub_14_138 sn_14 sn_138 1804384.580083352
Csub_14_138 sn_14 sn_138 5.83937793446632e-18
Rsub_14_216 sn_14 sn_216 302339461.5485412
Csub_14_216 sn_14 sn_216 3.484984542958295e-20
Rsub_14_49 sn_14 sn_49 24608170.07306704
Csub_14_49 sn_14 sn_49 4.281701349976401e-19
Rsub_14_188 sn_14 sn_188 3096305.523921902
Csub_14_188 sn_14 sn_188 3.40292113321042e-18
Rsub_14_21 sn_14 sn_21 301747792.103284
Csub_14_21 sn_14 sn_21 3.491817928074022e-20
Rsub_14_67 sn_14 sn_67 20619718.88559434
Csub_14_67 sn_14 sn_67 5.109906473841968e-19
Rsub_14_48 sn_14 sn_48 854853.9430350908
Csub_14_48 sn_14 sn_48 1.2325478039934e-17
Rsub_14_215 sn_14 sn_215 3072045.320123466
Csub_14_215 sn_14 sn_215 3.429794291513427e-18
Rsub_14_170 sn_14 sn_170 17047273.44059695
Csub_14_170 sn_14 sn_170 6.180744116615192e-19
Rsub_14_52 sn_14 sn_52 1838155.869744783
Csub_14_52 sn_14 sn_52 5.732094691019282e-18
Rsub_14_219 sn_14 sn_219 1787755.411789331
Csub_14_219 sn_14 sn_219 5.893694088546615e-18
Rsub_14_61 sn_14 sn_61 24010755.81097968
Csub_14_61 sn_14 sn_61 4.388234833245799e-19
Rsub_14_45 sn_14 sn_45 28779420.95426001
Csub_14_45 sn_14 sn_45 3.661117268125703e-19
Rsub_14_198 sn_14 sn_198 12555375.8967849
Csub_14_198 sn_14 sn_198 8.392009597202194e-19
Rsub_14_31 sn_14 sn_31 169903222.8788489
Csub_14_31 sn_14 sn_31 6.201461822618362e-20
Rsub_14_110 sn_14 sn_110 34791016.38852499
Csub_14_110 sn_14 sn_110 3.028506952646895e-19
Rsub_14_165 sn_14 sn_165 302339461.5485412
Csub_14_165 sn_14 sn_165 3.484984542958295e-20
Rsub_14_206 sn_14 sn_206 6267895.930539011
Csub_14_206 sn_14 sn_206 1.681024002152491e-18
Rsub_14_39 sn_14 sn_39 40440102.24333742
Csub_14_39 sn_14 sn_39 2.605454219385884e-19
Rsub_14_17 sn_14 sn_17 32231517.95486446
Csub_14_17 sn_14 sn_17 3.269000087735493e-19
Rsub_14_141 sn_14 sn_141 58652556.25117481
Csub_14_141 sn_14 sn_141 1.796423579069319e-19
Rsub_14_53 sn_14 sn_53 220071997.8556126
Csub_14_53 sn_14 sn_53 4.787743831517766e-20
Rsub_14_148 sn_14 sn_148 100571671.6121189
Csub_14_148 sn_14 sn_148 1.047659180098618e-19
Rsub_14_105 sn_14 sn_105 10700906.32670016
Csub_14_105 sn_14 sn_105 9.846346823857432e-19
Rsub_14_211 sn_14 sn_211 302339461.5485412
Csub_14_211 sn_14 sn_211 3.484984542958295e-20
Rsub_14_44 sn_14 sn_44 55790195.57124386
Csub_14_44 sn_14 sn_44 1.888590529992847e-19
Rsub_14_142 sn_14 sn_142 66912014.48209184
Csub_14_142 sn_14 sn_142 1.574677370541573e-19
Rsub_14_129 sn_14 sn_129 16464152.81379624
Csub_14_129 sn_14 sn_129 6.399651182416679e-19
Rsub_14_201 sn_14 sn_201 1521501.553105002
Csub_14_201 sn_14 sn_201 6.925056028189841e-18
Rsub_14_23 sn_14 sn_23 302339461.5485412
Csub_14_23 sn_14 sn_23 3.484984542958295e-20
Rsub_14_190 sn_14 sn_190 100540671.2619268
Csub_14_190 sn_14 sn_190 1.04798221157491e-19
Rsub_14_79 sn_14 sn_79 48928673.30328328
Csub_14_79 sn_14 sn_79 2.153437399971964e-19
Rsub_14_106 sn_14 sn_106 115979939.2351664
Csub_14_106 sn_14 sn_106 9.084746527471215e-20
Rsub_14_166 sn_14 sn_166 302339461.5485412
Csub_14_166 sn_14 sn_166 3.484984542958295e-20
Rsub_14_181 sn_14 sn_181 27932197.26970444
Csub_14_181 sn_14 sn_181 3.772164216260202e-19
Rsub_14_223 sn_14 sn_223 251658857.7723648
Csub_14_223 sn_14 sn_223 4.186812097732979e-20
Rsub_14_150 sn_14 sn_150 284526799.3372387
Csub_14_150 sn_14 sn_150 3.703160309247887e-20
Rsub_118_178 sn_118 sn_178 14022740.28902723
Csub_118_178 sn_118 sn_178 7.513854842248475e-19
Rsub_118_163 sn_118 sn_163 4465767.849265235
Csub_118_163 sn_118 sn_163 2.359388991517684e-18
Rsub_118_142 sn_118 sn_142 11182856.19101754
Csub_118_142 sn_118 sn_142 9.421996779940055e-19
Rsub_118_221 sn_118 sn_221 8546907.016228562
Csub_118_221 sn_118 sn_221 1.23278321411754e-18
Rsub_118_146 sn_118 sn_146 13190518.90603566
Csub_118_146 sn_118 sn_146 7.98792191367753e-19
Rsub_118_154 sn_118 sn_154 6378811.629567578
Csub_118_154 sn_118 sn_154 1.651794113717114e-18
Rsub_118_123 sn_118 sn_123 12069428.74488699
Csub_118_123 sn_118 sn_123 8.729894119217209e-19
Rsub_118_122 sn_118 sn_122 697952.1245347913
Csub_118_122 sn_118 sn_122 1.509628401697742e-17
Rsub_118_184 sn_118 sn_184 4327191.345203885
Csub_118_184 sn_118 sn_184 2.434947443197373e-18
Rsub_118_182 sn_118 sn_182 1906692.655980542
Csub_118_182 sn_118 sn_182 5.526052386671346e-18
Rsub_118_134 sn_118 sn_134 2150698.3601984
Csub_118_134 sn_118 sn_134 4.899098682187129e-18
Rsub_118_171 sn_118 sn_171 2962900.952599824
Csub_118_171 sn_118 sn_171 3.556137606619845e-18
Rsub_118_130 sn_118 sn_130 9038043.211506229
Csub_118_130 sn_118 sn_130 1.165792556602974e-18
Rsub_118_157 sn_118 sn_157 6333048.845924844
Csub_118_157 sn_118 sn_157 1.663730023022002e-18
Rsub_118_215 sn_118 sn_215 1923168.974216521
Csub_118_215 sn_118 sn_215 5.478709174019644e-18
Rsub_118_212 sn_118 sn_212 15457315.35903735
Csub_118_212 sn_118 sn_212 6.816502903312825e-19
Rsub_118_198 sn_118 sn_198 4217482.139674746
Csub_118_198 sn_118 sn_198 2.498287640180161e-18
Rsub_118_119 sn_118 sn_119 2932153.590429439
Csub_118_119 sn_118 sn_119 3.59342823534931e-18
Rsub_118_125 sn_118 sn_125 3430165.882809231
Csub_118_125 sn_118 sn_125 3.071712524177067e-18
Rsub_118_191 sn_118 sn_191 2265578.78446731
Csub_118_191 sn_118 sn_191 4.650680688955769e-18
Rsub_118_186 sn_118 sn_186 45724708.63359889
Csub_118_186 sn_118 sn_186 2.304330375653331e-19
Rsub_118_153 sn_118 sn_153 4418983.386029319
Csub_118_153 sn_118 sn_153 2.384368209109192e-18
Rsub_118_185 sn_118 sn_185 1413620.606002311
Csub_118_185 sn_118 sn_185 7.453544082118999e-18
Rsub_118_165 sn_118 sn_165 1302089.815736567
Csub_118_165 sn_118 sn_165 8.09197904391082e-18
Rsub_118_156 sn_118 sn_156 907389.014667969
Csub_118_156 sn_118 sn_156 1.161187024738833e-17
Rsub_118_183 sn_118 sn_183 1268993.461391831
Csub_118_183 sn_118 sn_183 8.303024265131826e-18
Rsub_118_222 sn_118 sn_222 98863.99364330481
Csub_118_222 sn_118 sn_222 1.065755399305938e-16
Rsub_118_168 sn_118 sn_168 167779.6043548182
Csub_118_168 sn_118 sn_168 6.27995491034034e-17
Rsub_118_210 sn_118 sn_210 17264.00678011191
Csub_118_210 sn_118 sn_210 6.103150697535637e-16
Rsub_118_131 sn_118 sn_131 954458.627672537
Csub_118_131 sn_118 sn_131 1.103922495616535e-17
Rsub_118_230 sn_118 0 104567.0856825329
Csub_118_230 sn_118 0 1.007629067354799e-16
Rsub_118_207 sn_118 sn_207 17592768.60421533
Csub_118_207 sn_118 sn_207 5.989099123207588e-19
Rsub_118_128 sn_118 sn_128 2193233.452643666
Csub_118_128 sn_118 sn_128 4.80408662813783e-18
Rsub_118_135 sn_118 sn_135 53615.1978109913
Csub_118_135 sn_118 sn_135 1.965204630853751e-16
Rsub_118_172 sn_118 sn_172 1109274.233567805
Csub_118_172 sn_118 sn_172 9.498538038101784e-18
Rsub_118_197 sn_118 sn_197 12332308.64347046
Csub_118_197 sn_118 sn_197 8.543804576127531e-19
Rsub_118_155 sn_118 sn_155 70333.63375508216
Csub_118_155 sn_118 sn_155 1.498071824202977e-16
Rsub_118_166 sn_118 sn_166 3492765.602169777
Csub_118_166 sn_118 sn_166 3.016659204294879e-18
Rsub_118_211 sn_118 sn_211 24063545.30525736
Csub_118_211 sn_118 sn_211 4.378608126346207e-19
Rsub_118_132 sn_118 sn_132 756609.5408126753
Csub_118_132 sn_118 sn_132 1.392591942590725e-17
Rsub_118_129 sn_118 sn_129 12584144.26138834
Csub_118_129 sn_118 sn_129 8.372824789174473e-19
Rsub_118_208 sn_118 sn_208 3364314.094804201
Csub_118_208 sn_118 sn_208 3.131837041762063e-18
Rsub_118_219 sn_118 sn_219 348594.4676288376
Csub_118_219 sn_118 sn_219 3.022561882263896e-17
Rsub_118_140 sn_118 sn_140 9697.050872071384
Csub_118_140 sn_118 sn_140 1.0865657653273e-15
Rsub_118_177 sn_118 sn_177 1038231.24544864
Csub_118_177 sn_118 sn_177 1.014849393949513e-17
Rsub_118_158 sn_118 sn_158 64958.68823118526
Csub_118_158 sn_118 sn_158 1.622028367434252e-16
Rsub_118_195 sn_118 sn_195 1500273.195999955
Csub_118_195 sn_118 sn_195 7.02304322327593e-18
Rsub_118_190 sn_118 sn_190 45066.06058534792
Csub_118_190 sn_118 sn_190 2.338008551307826e-16
Rsub_118_148 sn_118 sn_148 7035149.302598058
Csub_118_148 sn_118 sn_148 1.497691527078027e-18
Rsub_118_227 sn_118 sn_227 3323348.107575077
Csub_118_227 sn_118 sn_227 3.170442325380738e-18
Rsub_118_126 sn_118 sn_126 343781.4558209179
Csub_118_126 sn_118 sn_126 3.064878376604075e-17
Rsub_118_160 sn_118 sn_160 2585885.951669723
Csub_118_160 sn_118 sn_160 4.074612608273201e-18
Rsub_118_228 sn_118 sn_228 1054428.207502194
Csub_118_228 sn_118 sn_228 9.99260397935445e-18
Rsub_118_150 sn_118 sn_150 398817.4702225351
Csub_118_150 sn_118 sn_150 2.641931281583722e-17
Rsub_118_176 sn_118 sn_176 621046.3054360513
Csub_118_176 sn_118 sn_176 1.696569709859571e-17
Rsub_118_181 sn_118 sn_181 654646.6700442649
Csub_118_181 sn_118 sn_181 1.609491651659598e-17
Rsub_118_196 sn_118 sn_196 2520771.920056118
Csub_118_196 sn_118 sn_196 4.179863881534921e-18
Rsub_118_216 sn_118 sn_216 51151.75441656057
Csub_118_216 sn_118 sn_216 2.059847921622563e-16
Rsub_118_137 sn_118 sn_137 1614794.846164927
Csub_118_137 sn_118 sn_137 6.524967259620455e-18
Rsub_118_141 sn_118 sn_141 189303.7411194344
Csub_118_141 sn_118 sn_141 5.565914038424831e-17
Rsub_118_217 sn_118 sn_217 8458061.828949679
Csub_118_217 sn_118 sn_217 1.245732617627178e-18
Rsub_118_138 sn_118 sn_138 4891529.978639478
Csub_118_138 sn_118 sn_138 2.15402615301166e-18
Rsub_118_206 sn_118 sn_206 34649356.41554309
Csub_118_206 sn_118 sn_206 3.040888660634262e-19
Rsub_118_226 sn_118 sn_226 8956807.333276646
Csub_118_226 sn_118 sn_226 1.176365987362984e-18
Rsub_118_162 sn_118 sn_162 1928111.818198232
Csub_118_162 sn_118 sn_162 5.46466413554586e-18
Rsub_64_66 sn_64 sn_66 30594017.92985798
Csub_64_66 sn_64 sn_66 3.443968532144648e-19
Rsub_64_172 sn_64 sn_172 21980281.42695845
Csub_64_172 sn_64 sn_172 4.793607187079588e-19
Rsub_64_96 sn_64 sn_96 14574602.34857669
Csub_64_96 sn_64 sn_96 7.229345439574867e-19
Rsub_64_82 sn_64 sn_82 17518407.84475999
Csub_64_82 sn_64 sn_82 6.014521180006444e-19
Rsub_64_211 sn_64 sn_211 34557224.0439944
Csub_64_211 sn_64 sn_211 3.048995917269317e-19
Rsub_64_182 sn_64 sn_182 28080765.27211294
Csub_64_182 sn_64 sn_182 3.752206679599934e-19
Rsub_64_134 sn_64 sn_134 29530718.72850431
Csub_64_134 sn_64 sn_134 3.56797394574069e-19
Rsub_64_196 sn_64 sn_196 2281910.37218233
Csub_64_196 sn_64 sn_196 4.617395858608294e-18
Rsub_64_228 sn_64 sn_228 36178122.924114
Csub_64_228 sn_64 sn_228 2.912390873437788e-19
Rsub_64_70 sn_64 sn_70 192964424.1379926
Csub_64_70 sn_64 sn_70 5.460324383263082e-20
Rsub_64_155 sn_64 sn_155 1601145.779052478
Csub_64_155 sn_64 sn_155 6.580589750213283e-18
Rsub_64_192 sn_64 sn_192 3402648.896920428
Csub_64_192 sn_64 sn_192 3.09655325054726e-18
Rsub_64_230 sn_64 0 240773.1542414803
Csub_64_230 sn_64 0 4.376103945401893e-17
Rsub_64_151 sn_64 sn_151 30086534.220121
Csub_64_151 sn_64 sn_151 3.502059567626605e-19
Rsub_64_139 sn_64 sn_139 3795691.136329989
Csub_64_139 sn_64 sn_139 2.7759064485994e-18
Rsub_64_218 sn_64 sn_218 819074.6755175211
Csub_64_218 sn_64 sn_218 1.286388630630372e-17
Rsub_64_95 sn_64 sn_95 15422132.26970214
Csub_64_95 sn_64 sn_95 6.832053647296011e-19
Rsub_64_116 sn_64 sn_116 10648579.37110412
Csub_64_116 sn_64 sn_116 9.894731621028908e-19
Rsub_64_195 sn_64 sn_195 1976192.502787115
Csub_64_195 sn_64 sn_195 5.331709075593555e-18
Rsub_64_227 sn_64 sn_227 3409915.574439399
Csub_64_227 sn_64 sn_227 3.08995436168892e-18
Rsub_64_148 sn_64 sn_148 107054896.8635631
Csub_64_148 sn_64 sn_148 9.842131290508178e-20
Rsub_64_141 sn_64 sn_141 3124345.493885279
Csub_64_141 sn_64 sn_141 3.372381038797141e-18
Rsub_64_225 sn_64 sn_225 3563607.985985612
Csub_64_225 sn_64 sn_225 2.956689833356025e-18
Rsub_64_146 sn_64 sn_146 5341855.231009474
Csub_64_146 sn_64 sn_146 1.972438983569923e-18
Rsub_64_222 sn_64 sn_222 267453.3069196905
Csub_64_222 sn_64 sn_222 3.93956000154967e-17
Rsub_64_168 sn_64 sn_168 3120352.433221601
Csub_64_168 sn_64 sn_168 3.376696616077957e-18
Rsub_64_226 sn_64 sn_226 759452.7918189059
Csub_64_226 sn_64 sn_226 1.387378335524305e-17
Rsub_64_162 sn_64 sn_162 3667524.670909645
Csub_64_162 sn_64 sn_162 2.872914144464819e-18
Rsub_64_83 sn_64 sn_83 12908237.73612209
Csub_64_83 sn_64 sn_83 8.162604158385593e-19
Rsub_64_126 sn_64 sn_126 10738147.79328096
Csub_64_126 sn_64 sn_126 9.812198253429574e-19
Rsub_64_120 sn_64 sn_120 1273693.427227161
Csub_64_120 sn_64 sn_120 8.272385863816534e-18
Rsub_64_186 sn_64 sn_186 92900.52654662875
Csub_64_186 sn_64 sn_186 1.1341683297071e-16
Rsub_64_107 sn_64 sn_107 12945674.90828297
Csub_64_107 sn_64 sn_107 8.138998991461226e-19
Rsub_64_184 sn_64 sn_184 6658123.938468484
Csub_64_184 sn_64 sn_184 1.582500355896593e-18
Rsub_64_93 sn_64 sn_93 14504.76890303662
Csub_64_93 sn_64 sn_93 7.264151240647588e-16
Rsub_64_84 sn_64 sn_84 311942.0270066102
Csub_64_84 sn_64 sn_84 3.377705660034943e-17
Rsub_64_166 sn_64 sn_166 401240.1242010813
Csub_64_166 sn_64 sn_166 2.625979523660412e-17
Rsub_64_127 sn_64 sn_127 30086534.220121
Csub_64_127 sn_64 sn_127 3.502059567626605e-19
Rsub_64_206 sn_64 sn_206 22372129.32083771
Csub_64_206 sn_64 sn_206 4.709647146736351e-19
Rsub_64_90 sn_64 sn_90 162090116.2759137
Csub_64_90 sn_64 sn_90 6.500386170551289e-20
Rsub_64_208 sn_64 sn_208 358380.1508644058
Csub_64_208 sn_64 sn_208 2.940029875208269e-17
Rsub_64_129 sn_64 sn_129 19748232.41788971
Csub_64_129 sn_64 sn_129 5.335405862797684e-19
Rsub_64_197 sn_64 sn_197 1734761.562141081
Csub_64_197 sn_64 sn_197 6.073735856370739e-18
Rsub_64_118 sn_64 sn_118 21166280.62832569
Csub_64_118 sn_64 sn_118 4.977957009664511e-19
Rsub_64_160 sn_64 sn_160 202262.0034536112
Csub_64_160 sn_64 sn_160 5.209324204408241e-17
Rsub_64_123 sn_64 sn_123 7052946.319754364
Csub_64_123 sn_64 sn_123 1.4939123345826e-18
Rsub_64_133 sn_64 sn_133 55336184.15107946
Csub_64_133 sn_64 sn_133 1.904085665441473e-19
Rsub_64_212 sn_64 sn_212 3135358.544381915
Csub_64_212 sn_64 sn_212 3.360535438956343e-18
Rsub_64_207 sn_64 sn_207 6867763.934067847
Csub_64_207 sn_64 sn_207 1.534194186547867e-18
Rsub_64_128 sn_64 sn_128 36546798.01084626
Csub_64_128 sn_64 sn_128 2.883011392435258e-19
Rsub_64_216 sn_64 sn_216 7945428.371183223
Csub_64_216 sn_64 sn_216 1.326106411133743e-18
Rsub_64_137 sn_64 sn_137 121946745.9962878
Csub_64_137 sn_64 sn_137 8.640233420046114e-20
Rsub_64_224 sn_64 sn_224 1848930.398635398
Csub_64_224 sn_64 sn_224 5.698691259555495e-18
Rsub_64_145 sn_64 sn_145 28249926.50869193
Csub_64_145 sn_64 sn_145 3.729738376129276e-19
Rsub_64_153 sn_64 sn_153 19672266.8394157
Csub_64_153 sn_64 sn_153 5.356008836317185e-19
Rsub_64_74 sn_64 sn_74 4715514.950498535
Csub_64_74 sn_64 sn_74 2.234429031153015e-18
Rsub_64_171 sn_64 sn_171 4801524.409988171
Csub_64_171 sn_64 sn_171 2.19440381898547e-18
Rsub_64_167 sn_64 sn_167 23629139.69266875
Csub_64_167 sn_64 sn_167 4.459105849502883e-19
Rsub_64_215 sn_64 sn_215 1201344.429729057
Csub_64_215 sn_64 sn_215 8.770576731775691e-18
Rsub_64_158 sn_64 sn_158 3069058.550171845
Csub_64_158 sn_64 sn_158 3.433132125042071e-18
Rsub_64_79 sn_64 sn_79 20204867.09029378
Csub_64_79 sn_64 sn_79 5.214824455485592e-19
Rsub_64_221 sn_64 sn_221 5690435.518802493
Csub_64_221 sn_64 sn_221 1.851612845346382e-18
Rsub_64_164 sn_64 sn_164 8189007.749130333
Csub_64_164 sn_64 sn_164 1.286661806291363e-18
Rsub_64_198 sn_64 sn_198 4273098.127365165
Csub_64_198 sn_64 sn_198 2.465771481996577e-18
Rsub_64_150 sn_64 sn_150 12051705.86769073
Csub_64_150 sn_64 sn_150 8.742732039683384e-19
Rsub_64_203 sn_64 sn_203 20456528.37664844
Csub_64_203 sn_64 sn_203 5.150670391491069e-19
Rsub_64_112 sn_64 sn_112 28926571.4550079
Csub_64_112 sn_64 sn_112 3.642493033997597e-19
Rsub_64_191 sn_64 sn_191 8723997.716405097
Csub_64_191 sn_64 sn_191 1.207758626806677e-18
Rsub_64_214 sn_64 sn_214 14192483.78196771
Csub_64_214 sn_64 sn_214 7.423988404071425e-19
Rsub_64_138 sn_64 sn_138 7933720.175460575
Csub_64_138 sn_64 sn_138 1.328063414036194e-18
Rsub_64_103 sn_64 sn_103 8331068.226298114
Csub_64_103 sn_64 sn_103 1.264721787893922e-18
Rsub_64_132 sn_64 sn_132 9918952.247940326
Csub_64_132 sn_64 sn_132 1.062257710174772e-18
Rsub_64_181 sn_64 sn_181 7631375.777549384
Csub_64_181 sn_64 sn_181 1.380679422605175e-18
Rsub_64_213 sn_64 sn_213 4781227.886179395
Csub_64_213 sn_64 sn_213 2.203719160236376e-18
Rsub_64_219 sn_64 sn_219 13385267.29519446
Csub_64_219 sn_64 sn_219 7.871701976405643e-19
Rsub_64_209 sn_64 sn_209 28083172.40900067
Csub_64_209 sn_64 sn_209 3.751885060839157e-19
Rsub_64_125 sn_64 sn_125 60973372.99814388
Csub_64_125 sn_64 sn_125 1.728046684009223e-19
Rsub_64_154 sn_64 sn_154 47547337.32064284
Csub_64_154 sn_64 sn_154 2.215998643872651e-19
Rsub_64_190 sn_64 sn_190 4813477.990993174
Csub_64_190 sn_64 sn_190 2.188954332386174e-18
Rsub_64_109 sn_64 sn_109 19708579.59661873
Csub_64_109 sn_64 sn_109 5.346140471755597e-19
Rsub_64_185 sn_64 sn_185 5784263.700065453
Csub_64_185 sn_64 sn_185 1.821577308467243e-18
Rsub_124_195 sn_124 sn_195 1664168.643769567
Csub_124_195 sn_124 sn_195 6.331379660154779e-18
Rsub_124_172 sn_124 sn_172 10538494.03764435
Csub_124_172 sn_124 sn_172 9.998092198555912e-19
Rsub_124_209 sn_124 sn_209 770377.9476196432
Csub_124_209 sn_124 sn_209 1.36770315593615e-17
Rsub_124_181 sn_124 sn_181 5886289.471312829
Csub_124_181 sn_124 sn_181 1.790004306376735e-18
Rsub_124_151 sn_124 sn_151 7950578.119212699
Csub_124_151 sn_124 sn_151 1.325247465560828e-18
Rsub_124_159 sn_124 sn_159 3380624.119675142
Csub_124_159 sn_124 sn_159 3.116727305146984e-18
Rsub_124_157 sn_124 sn_157 991010.5082625463
Csub_124_157 sn_124 sn_157 1.063206032063446e-17
Rsub_124_191 sn_124 sn_191 5812565.310522733
Csub_124_191 sn_124 sn_191 1.812707976485935e-18
Rsub_124_130 sn_124 sn_130 332222.0366205706
Csub_124_130 sn_124 sn_130 3.171518545069806e-17
Rsub_124_205 sn_124 sn_205 10689.37938478832
Csub_124_205 sn_124 sn_205 9.8569646776913e-16
Rsub_124_161 sn_124 sn_161 8240568.810490973
Csub_124_161 sn_124 sn_161 1.278611191112939e-18
Rsub_124_141 sn_124 sn_141 2093942.264039374
Csub_124_141 sn_124 sn_141 5.031888263196102e-18
Rsub_124_229 sn_124 sn_229 5042.349736025067
Csub_124_229 sn_124 sn_229 2.089597916414265e-15
Rsub_124_223 sn_124 sn_223 165338.9079118761
Csub_124_223 sn_124 sn_223 6.372658217777655e-17
Rsub_124_186 sn_124 sn_186 46236456.91153509
Csub_124_186 sn_124 sn_186 2.278825888927781e-19
Rsub_124_189 sn_124 sn_189 16481137.62098195
Csub_124_189 sn_124 sn_189 6.393055955564697e-19
Rsub_124_152 sn_124 sn_152 9137275.192480059
Csub_124_152 sn_124 sn_152 1.153131899858011e-18
Rsub_124_139 sn_124 sn_139 2959888.837957701
Csub_124_139 sn_124 sn_139 3.55975649055121e-18
Rsub_124_176 sn_124 sn_176 7491426.19135543
Csub_124_176 sn_124 sn_176 1.406472310224233e-18
Rsub_124_202 sn_124 sn_202 1161831.047373267
Csub_124_202 sn_124 sn_202 9.068860335632684e-18
Rsub_124_128 sn_124 sn_128 3993240.179339494
Csub_124_128 sn_124 sn_128 2.638579957385083e-18
Rsub_124_193 sn_124 sn_193 1250516.732127352
Csub_124_193 sn_124 sn_193 8.425703736331109e-18
Rsub_124_230 sn_124 0 461205.336175666
Csub_124_230 sn_124 0 2.284553684829184e-17
Rsub_124_217 sn_124 sn_217 882670.3355218549
Csub_124_217 sn_124 sn_217 1.193705404861101e-17
Rsub_124_132 sn_124 sn_132 3517716.24682716
Csub_124_132 sn_124 sn_132 2.995262483645032e-18
Rsub_124_177 sn_124 sn_177 989803.5424175153
Csub_124_177 sn_124 sn_177 1.064502504860256e-17
Rsub_164_228 sn_164 sn_228 13600296.49496602
Csub_164_228 sn_164 sn_228 7.747245441398978e-19
Rsub_164_180 sn_164 sn_180 7671401.043949654
Csub_164_180 sn_164 sn_180 1.373475776050061e-18
Rsub_164_227 sn_164 sn_227 187335.8011391097
Csub_164_227 sn_164 sn_227 5.62438329361612e-17
Rsub_164_189 sn_164 sn_189 62039883.51534589
Csub_164_189 sn_164 sn_189 1.698340310330168e-19
Rsub_164_202 sn_164 sn_202 14580532.65907658
Csub_164_202 sn_164 sn_202 7.226405062555036e-19
Rsub_164_194 sn_164 sn_194 29507684.37058476
Csub_164_194 sn_164 sn_194 3.57075918594733e-19
Rsub_164_223 sn_164 sn_223 31767574.00862475
Csub_164_223 sn_164 sn_223 3.316741624453096e-19
Rsub_164_178 sn_164 sn_178 32433646.37765454
Csub_164_178 sn_164 sn_178 3.248627483800035e-19
Rsub_164_215 sn_164 sn_215 29684276.03728528
Csub_164_215 sn_164 sn_215 3.5495167505502e-19
Rsub_164_195 sn_164 sn_195 140060835.370793
Csub_164_195 sn_164 sn_195 7.522790703294054e-20
Rsub_164_230 sn_164 0 194089.5743609901
Csub_164_230 sn_164 0 5.428670518197459e-17
Rsub_164_219 sn_164 sn_219 12782124.90346337
Csub_164_219 sn_164 sn_219 8.243139213398777e-19
Rsub_164_186 sn_164 sn_186 8608297.824011352
Csub_164_186 sn_164 sn_186 1.223991515818645e-18
Rsub_164_216 sn_164 sn_216 1287438.619172283
Csub_164_216 sn_164 sn_216 8.184066677294562e-18
Rsub_164_218 sn_164 sn_218 3790447.094227762
Csub_164_218 sn_164 sn_218 2.779746884813499e-18
Rsub_164_181 sn_164 sn_181 12332255.90352737
Csub_164_181 sn_164 sn_181 8.543841114435743e-19
Rsub_164_184 sn_164 sn_184 86819.90712559878
Csub_164_184 sn_164 sn_184 1.213602254490702e-16
Rsub_164_221 sn_164 sn_221 26440593.45207116
Csub_164_221 sn_164 sn_221 3.984964831190145e-19
Rsub_164_191 sn_164 sn_191 18323424.65239308
Csub_164_191 sn_164 sn_191 5.75028069376426e-19
Rsub_164_208 sn_164 sn_208 31902.63498615335
Csub_164_208 sn_164 sn_208 3.302700076906856e-16
Rsub_164_171 sn_164 sn_171 249181.2094591031
Csub_164_171 sn_164 sn_171 4.228442234910696e-17
Rsub_164_206 sn_164 sn_206 7499663.826261654
Csub_164_206 sn_164 sn_206 1.404927440258626e-18
Rsub_164_169 sn_164 sn_169 10431384.39969995
Csub_164_169 sn_164 sn_169 1.010075278458061e-18
Rsub_164_222 sn_164 sn_222 640870.2917498952
Csub_164_222 sn_164 sn_222 1.644089863092288e-17
Rsub_164_224 sn_164 sn_224 125245.6024509371
Csub_164_224 sn_164 sn_224 8.412657447480041e-17
Rsub_164_190 sn_164 sn_190 1135573.5683298
Csub_164_190 sn_164 sn_190 9.278556489939302e-18
Rsub_164_197 sn_164 sn_197 9279919.717414059
Csub_164_197 sn_164 sn_197 1.135406751683203e-18
Rsub_164_192 sn_164 sn_192 7651184.516485945
Csub_164_192 sn_164 sn_192 1.37710487566038e-18
Rsub_164_226 sn_164 sn_226 10978955.30699883
Csub_164_226 sn_164 sn_226 9.596981869042889e-19
Rsub_164_166 sn_164 sn_166 3667884.343110783
Csub_164_166 sn_164 sn_166 2.872632426924854e-18
Rsub_164_217 sn_164 sn_217 31318994.65805367
Csub_164_217 sn_164 sn_217 3.364247038345003e-19
Rsub_164_207 sn_164 sn_207 2251712.207577234
Csub_164_207 sn_164 sn_207 4.679320681734412e-18
Rsub_164_183 sn_164 sn_183 5752530.56018986
Csub_164_183 sn_164 sn_183 1.831625819625763e-18
Rsub_164_198 sn_164 sn_198 32841445.78726461
Csub_164_198 sn_164 sn_198 3.208288566368744e-19
Rsub_164_214 sn_164 sn_214 32841445.78726461
Csub_164_214 sn_164 sn_214 3.208288566368744e-19
Rsub_164_177 sn_164 sn_177 17943022.30649174
Csub_164_177 sn_164 sn_177 5.872189936707557e-19
Rsub_164_210 sn_164 sn_210 4273858.69911638
Csub_164_210 sn_164 sn_210 2.465332675693845e-18
Rsub_164_165 sn_164 sn_165 32433646.37765454
Csub_164_165 sn_164 sn_165 3.248627483800035e-19
Rsub_164_209 sn_164 sn_209 29290341.22997679
Csub_164_209 sn_164 sn_209 3.597255292965513e-19
Rsub_123_203 sn_123 sn_203 7206268.678265126
Csub_123_203 sn_123 sn_203 1.462127485477909e-18
Rsub_123_179 sn_123 sn_179 230008747.5860789
Csub_123_179 sn_123 sn_179 4.580905558075267e-20
Rsub_123_168 sn_123 sn_168 21653394.79415204
Csub_123_168 sn_123 sn_168 4.865973027506801e-19
Rsub_123_183 sn_123 sn_183 93060649.33721521
Csub_123_183 sn_123 sn_183 1.132216847536699e-19
Rsub_123_177 sn_123 sn_177 73710361.34471777
Csub_123_177 sn_123 sn_177 1.429444017097478e-19
Rsub_123_156 sn_123 sn_156 9556074.304248674
Csub_123_156 sn_123 sn_156 1.102595392916256e-18
Rsub_123_153 sn_123 sn_153 44342213.08362492
Csub_123_153 sn_123 sn_153 2.376174477886176e-19
Rsub_123_134 sn_123 sn_134 46530324.66860761
Csub_123_134 sn_123 sn_134 2.264433695073398e-19
Rsub_123_213 sn_123 sn_213 44500389.17340238
Csub_123_213 sn_123 sn_213 2.367728394727747e-19
Rsub_123_200 sn_123 sn_200 28952915.73781622
Csub_123_200 sn_123 sn_200 3.639178726468644e-19
Rsub_123_126 sn_123 sn_126 32762300.38536309
Csub_123_126 sn_123 sn_126 3.216038977207257e-19
Rsub_123_127 sn_123 sn_127 8422392.172798671
Csub_123_127 sn_123 sn_127 1.251008417330541e-18
Rsub_123_210 sn_123 sn_210 15289766.38250268
Csub_123_210 sn_123 sn_210 6.891199799028814e-19
Rsub_123_159 sn_123 sn_159 12202194.59504965
Csub_123_159 sn_123 sn_159 8.634908597921055e-19
Rsub_123_181 sn_123 sn_181 14068692.6033454
Csub_123_181 sn_123 sn_181 7.489312475079971e-19
Rsub_123_198 sn_123 sn_198 58345700.58638156
Csub_123_198 sn_123 sn_198 1.805871451767144e-19
Rsub_123_221 sn_123 sn_221 44500389.17340238
Csub_123_221 sn_123 sn_221 2.367728394727747e-19
Rsub_123_170 sn_123 sn_170 38256773.50415865
Csub_123_170 sn_123 sn_170 2.754148491138347e-19
Rsub_123_157 sn_123 sn_157 11559260.4081892
Csub_123_157 sn_123 sn_157 9.115188282085411e-19
Rsub_123_223 sn_123 sn_223 87957583.22462603
Csub_123_223 sn_123 sn_223 1.197905071507244e-19
Rsub_123_204 sn_123 sn_204 22725680.30916053
Csub_123_204 sn_123 sn_204 4.636377595254138e-19
Rsub_123_140 sn_123 sn_140 940747.2185994383
Csub_123_140 sn_123 sn_140 1.120012187537101e-17
Rsub_123_197 sn_123 sn_197 17002553.05574
Csub_123_197 sn_123 sn_197 6.19700080787157e-19
Rsub_123_158 sn_123 sn_158 885526.6906623383
Csub_123_158 sn_123 sn_158 1.189854988374109e-17
Rsub_123_195 sn_123 sn_195 884457.6709513555
Csub_123_195 sn_123 sn_195 1.191293133440357e-17
Rsub_123_164 sn_123 sn_164 59519.43210418896
Csub_123_164 sn_123 sn_164 1.770259414401981e-16
Rsub_123_224 sn_123 sn_224 286063.3502723847
Csub_123_224 sn_123 sn_224 3.683269280107829e-17
Rsub_123_162 sn_123 sn_162 311654.1663187391
Csub_123_162 sn_123 sn_162 3.380825492143105e-17
Rsub_123_217 sn_123 sn_217 44500389.17340238
Csub_123_217 sn_123 sn_217 2.367728394727747e-19
Rsub_123_212 sn_123 sn_212 2376335.267171996
Csub_123_212 sn_123 sn_212 4.433921276928718e-18
Rsub_123_155 sn_123 sn_155 3004001.378170209
Csub_123_155 sn_123 sn_155 3.507482912224216e-18
Rsub_123_229 sn_123 sn_229 17565335.78251562
Csub_123_229 sn_123 sn_229 5.998452652819723e-19
Rsub_123_146 sn_123 sn_146 26561.75831555886
Csub_123_146 sn_123 sn_146 3.966786903583161e-16
Rsub_123_208 sn_123 sn_208 104600.4427799343
Csub_123_208 sn_123 sn_208 1.007307734289174e-16
Rsub_123_171 sn_123 sn_171 55101.0187613126
Csub_123_171 sn_123 sn_171 1.912212104075987e-16
Rsub_123_184 sn_123 sn_184 80405.9217209924
Csub_123_184 sn_123 sn_184 1.310411382235188e-16
Rsub_123_216 sn_123 sn_216 725004.3814503344
Csub_123_216 sn_123 sn_216 1.453299286433594e-17
Rsub_123_137 sn_123 sn_137 7054557.873035624
Csub_123_137 sn_123 sn_137 1.493571063114134e-18
Rsub_123_190 sn_123 sn_190 1131026.172207857
Csub_123_190 sn_123 sn_190 9.315861790945041e-18
Rsub_123_227 sn_123 sn_227 37347593.30714832
Csub_123_227 sn_123 sn_227 2.821194773001162e-19
Rsub_123_230 sn_123 0 345477.1357017332
Csub_123_230 sn_123 0 3.049835260683256e-17
Rsub_123_211 sn_123 sn_211 1316485843.0962
Rsub_123_132 sn_123 sn_132 3760315.845284703
Csub_123_132 sn_123 sn_132 2.802020876901169e-18
Rsub_123_186 sn_123 sn_186 12534351.86142821
Csub_123_186 sn_123 sn_186 8.406085626695848e-19
Rsub_123_166 sn_123 sn_166 6309415.616815464
Csub_123_166 sn_123 sn_166 1.669961870026254e-18
Rsub_123_139 sn_123 sn_139 4879236.576834813
Csub_123_139 sn_123 sn_139 2.159453294856442e-18
Rsub_123_218 sn_123 sn_218 4958089.679057975
Csub_123_218 sn_123 sn_218 2.125109504721969e-18
Rsub_123_141 sn_123 sn_141 3157501.976144979
Csub_123_141 sn_123 sn_141 3.336968141851833e-18
Rsub_123_128 sn_123 sn_128 23441760.4178085
Csub_123_128 sn_123 sn_128 4.494749248535757e-19
Rsub_123_207 sn_123 sn_207 2592228.103128248
Csub_123_207 sn_123 sn_207 4.064643651349505e-18
Rsub_123_222 sn_123 sn_222 1161402.403331743
Csub_123_222 sn_123 sn_222 9.072207420962572e-18
Rsub_123_226 sn_123 sn_226 8544559.892851524
Csub_123_226 sn_123 sn_226 1.233121849967363e-18
Rsub_123_135 sn_123 sn_135 23093772.97631043
Csub_123_135 sn_123 sn_135 4.56247816804916e-19
Rsub_133_180 sn_133 sn_180 62923641.59902257
Csub_133_180 sn_133 sn_180 1.674487241118872e-19
Rsub_133_224 sn_133 sn_224 22115505.79140786
Csub_133_224 sn_133 sn_224 4.764296870082687e-19
Rsub_133_200 sn_133 sn_200 11938562.99628377
Csub_133_200 sn_133 sn_200 8.825587724008151e-19
Rsub_133_217 sn_133 sn_217 773754.2412559597
Csub_133_217 sn_133 sn_217 1.361735153157565e-17
Rsub_133_138 sn_133 sn_138 41293.04385066411
Csub_133_138 sn_133 sn_138 2.551636430662533e-16
Rsub_133_184 sn_133 sn_184 17023723.64340125
Csub_133_184 sn_133 sn_184 6.189294259551823e-19
Rsub_133_139 sn_133 sn_139 6359589.452031378
Csub_133_139 sn_133 sn_139 1.656786744129284e-18
Rsub_133_218 sn_133 sn_218 1258706.308770629
Csub_133_218 sn_133 sn_218 8.370883206679819e-18
Rsub_133_213 sn_133 sn_213 3594796.850114336
Csub_133_213 sn_133 sn_213 2.931037257889797e-18
Rsub_133_165 sn_133 sn_165 101868606.9032621
Csub_133_165 sn_133 sn_165 1.034320957410933e-19
Rsub_133_202 sn_133 sn_202 6340566.969911991
Csub_133_202 sn_133 sn_202 1.661757308491334e-18
Rsub_133_144 sn_133 sn_144 11849741.04893722
Csub_133_144 sn_133 sn_144 8.89174156525133e-19
Rsub_133_181 sn_133 sn_181 13056619.41691654
Csub_133_181 sn_133 sn_181 8.069840412579248e-19
Rsub_133_230 sn_133 0 130796.5361302377
Csub_133_230 sn_133 0 8.055628852233925e-17
Rsub_133_151 sn_133 sn_151 66986245.39904355
Csub_133_151 sn_133 sn_151 1.572932389248442e-19
Rsub_133_190 sn_133 sn_190 7686348.392973205
Csub_133_190 sn_133 sn_190 1.370804830010355e-18
Rsub_133_227 sn_133 sn_227 14902220.41443494
Csub_133_227 sn_133 sn_227 7.070411797173462e-19
Rsub_133_148 sn_133 sn_148 1777461.830198085
Csub_133_148 sn_133 sn_148 5.927825466190623e-18
Rsub_133_153 sn_133 sn_153 2768188.203913568
Csub_133_153 sn_133 sn_153 3.806274258135299e-18
Rsub_133_204 sn_133 sn_204 5333081.700722998
Csub_133_204 sn_133 sn_204 1.975683871634966e-18
Rsub_133_229 sn_133 sn_229 13194874.34023693
Csub_133_229 sn_133 sn_229 7.985285217987765e-19
Rsub_133_150 sn_133 sn_150 4618053.009967646
Csub_133_150 sn_133 sn_150 2.281585655142538e-18
Rsub_133_198 sn_133 sn_198 57975.60610041497
Csub_133_198 sn_133 sn_198 1.817399456588792e-16
Rsub_133_199 sn_133 sn_199 58683.91747889206
Csub_133_199 sn_133 sn_199 1.79546355371041e-16
Rsub_133_206 sn_133 sn_206 293769.6789111298
Csub_133_206 sn_133 sn_206 3.586647723918935e-17
Rsub_133_141 sn_133 sn_141 5389261.268463904
Csub_133_141 sn_133 sn_141 1.955088643389005e-18
Rsub_133_220 sn_133 sn_220 26991203.55248591
Csub_133_220 sn_133 sn_220 3.903673091769034e-19
Rsub_133_215 sn_133 sn_215 178642.560212011
Csub_133_215 sn_133 sn_215 5.898081336119132e-17
Rsub_133_178 sn_133 sn_178 252235.4340700978
Csub_133_178 sn_133 sn_178 4.177241608053311e-17
Rsub_133_188 sn_133 sn_188 59800.80237162325
Csub_133_188 sn_133 sn_188 1.761930122066353e-16
Rsub_133_222 sn_133 sn_222 476167.9768225772
Csub_133_222 sn_133 sn_222 2.212766085728598e-17
Rsub_133_177 sn_133 sn_177 2773548.641819006
Csub_133_177 sn_133 sn_177 3.798917871265365e-18
Rsub_133_201 sn_133 sn_201 61090.52552851006
Csub_133_201 sn_133 sn_201 1.724732830676465e-16
Rsub_133_170 sn_133 sn_170 307003.295459523
Csub_133_170 sn_133 sn_170 3.432042475784821e-17
Rsub_133_212 sn_133 sn_212 7500579.723536898
Csub_133_212 sn_133 sn_212 1.404755884290704e-18
Rsub_133_226 sn_133 sn_226 5207316.104401017
Csub_133_226 sn_133 sn_226 2.02340001854794e-18
Rsub_133_219 sn_133 sn_219 1456746.887758522
Csub_133_219 sn_133 sn_219 7.23288554159354e-18
Rsub_133_140 sn_133 sn_140 68244476.01415399
Csub_133_140 sn_133 sn_140 1.543932068588925e-19
Rsub_133_186 sn_133 sn_186 26617591.27018061
Csub_133_186 sn_133 sn_186 3.958466186996382e-19
Rsub_133_211 sn_133 sn_211 5576734.635333114
Csub_133_211 sn_133 sn_211 1.889364330781113e-18
Rsub_133_214 sn_133 sn_214 2722259.242129528
Csub_133_214 sn_133 sn_214 3.870492324598621e-18
Rsub_133_135 sn_133 sn_135 27481504.41638166
Csub_133_135 sn_133 sn_135 3.834027185189043e-19
Rsub_133_159 sn_133 sn_159 10367697.00244327
Csub_133_159 sn_133 sn_159 1.016280037866361e-18
Rsub_133_189 sn_133 sn_189 20735394.00488653
Csub_133_189 sn_133 sn_189 5.081400189331806e-19
Rsub_133_160 sn_133 sn_160 2516626.251975816
Csub_133_160 sn_133 sn_160 4.186749420561658e-18
Rsub_133_192 sn_133 sn_192 7194164.009740622
Csub_133_192 sn_133 sn_192 1.464587614066625e-18
Rsub_133_155 sn_133 sn_155 10874820.22278012
Csub_133_155 sn_133 sn_155 9.688880631018262e-19
Rsub_133_168 sn_133 sn_168 2551312.129154009
Csub_133_168 sn_133 sn_168 4.129829267783005e-18
Rsub_133_216 sn_133 sn_216 88807930.76835391
Csub_133_216 sn_133 sn_216 1.186434973889134e-19
Rsub_133_137 sn_133 sn_137 14730035.4538066
Csub_133_137 sn_133 sn_137 7.153060517248868e-19
Rsub_133_175 sn_133 sn_175 66371948.77534524
Csub_133_175 sn_133 sn_175 1.587490452916145e-19
Rsub_133_221 sn_133 sn_221 2060770.496553601
Csub_133_221 sn_133 sn_221 5.112885457090466e-18
Rsub_133_142 sn_133 sn_142 67326172.15843944
Csub_133_142 sn_133 sn_142 1.564990725662284e-19
Rsub_133_179 sn_133 sn_179 30841344.44543551
Csub_133_179 sn_133 sn_179 3.416350256997111e-19
Rsub_133_203 sn_133 sn_203 12523495.28672687
Csub_133_203 sn_133 sn_203 8.413372833219476e-19
Rsub_133_157 sn_133 sn_157 6581698.769141836
Csub_133_157 sn_133 sn_157 1.60087598533529e-18
Rsub_133_225 sn_133 sn_225 3430051225.271049
Rsub_133_210 sn_133 sn_210 59204711.32136022
Csub_133_210 sn_133 sn_210 1.779669770711066e-19
Rsub_133_197 sn_133 sn_197 136488952.028308
Csub_133_197 sn_133 sn_197 7.719660342944624e-20
Rsub_133_169 sn_133 sn_169 9340894.492201736
Csub_133_169 sn_133 sn_169 1.127995130554831e-18
Rsub_133_149 sn_133 sn_149 58311938.61558271
Csub_133_149 sn_133 sn_149 1.806917031466063e-19
Rsub_133_182 sn_133 sn_182 26535408.36357202
Csub_133_182 sn_133 sn_182 3.970725966552132e-19
Rsub_133_196 sn_133 sn_196 3975462.665405889
Csub_133_196 sn_133 sn_196 2.650379185778177e-18
Rsub_133_205 sn_133 sn_205 27469289.45946896
Csub_133_205 sn_133 sn_205 3.835732088293228e-19
Rsub_133_158 sn_133 sn_158 3058645.93293918
Csub_133_158 sn_133 sn_158 3.44481961405224e-18
Rsub_133_154 sn_133 sn_154 36303085.41628689
Csub_133_154 sn_133 sn_154 2.902365840646413e-19
Rsub_133_166 sn_133 sn_166 28462126.03937161
Csub_133_166 sn_133 sn_166 3.701931292010618e-19
Rsub_113_182 sn_113 sn_182 2258673.320854522
Csub_113_182 sn_113 sn_182 4.664899259643153e-18
Rsub_113_227 sn_113 sn_227 661786.5711016851
Csub_113_227 sn_113 sn_227 1.592127124110387e-17
Rsub_113_165 sn_113 sn_165 1837771.823942357
Csub_113_165 sn_113 sn_165 5.733292547508599e-18
Rsub_113_148 sn_113 sn_148 20415344.66599054
Csub_113_148 sn_113 sn_148 5.161060797461083e-19
Rsub_113_223 sn_113 sn_223 1236650.828058624
Csub_113_223 sn_113 sn_223 8.520176644179236e-18
Rsub_113_130 sn_113 sn_130 1672864.293464639
Csub_113_130 sn_113 sn_130 6.298468766051598e-18
Rsub_113_167 sn_113 sn_167 487851.8814057347
Csub_113_167 sn_113 sn_167 2.159771009157401e-17
Rsub_113_226 sn_113 sn_226 4771447.390305178
Csub_113_226 sn_113 sn_226 2.208236335925752e-18
Rsub_113_115 sn_113 sn_115 261108.0595317912
Csub_113_115 sn_113 sn_115 4.035296160954823e-17
Rsub_113_163 sn_113 sn_163 1093489.334496931
Csub_113_163 sn_113 sn_163 9.635652740113282e-18
Rsub_113_200 sn_113 sn_200 13492198.47842078
Csub_113_200 sn_113 sn_200 7.809315523398128e-19
Rsub_113_217 sn_113 sn_217 614314.1404461442
Csub_113_217 sn_113 sn_217 1.715162130986909e-17
Rsub_113_143 sn_113 sn_143 215429.5992773453
Csub_113_143 sn_113 sn_143 4.890917282292892e-17
Rsub_113_198 sn_113 sn_198 1549674.287287093
Csub_113_198 sn_113 sn_198 6.799160048448303e-18
Rsub_113_119 sn_113 sn_119 3793.557673182434
Csub_113_119 sn_113 sn_119 2.777467593735275e-15
Rsub_113_230 sn_113 0 212770.1609775198
Csub_113_230 sn_113 0 4.952049410416733e-17
Rsub_113_179 sn_113 sn_179 132183.8135070748
Csub_113_179 sn_113 sn_179 7.971084524404391e-17
Rsub_113_173 sn_113 sn_173 25332753.19726316
Csub_113_173 sn_113 sn_173 4.159233471460306e-19
Rsub_113_159 sn_113 sn_159 2132015.092645574
Csub_113_159 sn_113 sn_159 4.942030447427786e-18
Rsub_113_122 sn_113 sn_122 759959.6253396991
Csub_113_122 sn_113 sn_122 1.386453062887418e-17
Rsub_113_175 sn_113 sn_175 148832.2472107624
Csub_113_175 sn_113 sn_175 7.079435874746426e-17
Rsub_113_209 sn_113 sn_209 1029266.720175745
Csub_113_209 sn_113 sn_209 1.023688349743876e-17
Rsub_113_220 sn_113 sn_220 942757.9828140006
Csub_113_220 sn_113 sn_220 1.117623366155975e-17
Rsub_113_157 sn_113 sn_157 5420815.970050854
Csub_113_157 sn_113 sn_157 1.943708024851313e-18
Rsub_119_187 sn_119 sn_187 306355.3505020904
Csub_119_187 sn_119 sn_187 3.439301283611205e-17
Rsub_119_196 sn_119 sn_196 9445651.494929524
Csub_119_196 sn_119 sn_196 1.11548509998342e-18
Rsub_119_226 sn_119 sn_226 4387578.753005924
Csub_119_226 sn_119 sn_226 2.401434616988122e-18
Rsub_119_178 sn_119 sn_178 12990038.86623867
Csub_119_178 sn_119 sn_178 8.111202445755952e-19
Rsub_119_220 sn_119 sn_220 2170758.945504222
Csub_119_220 sn_119 sn_220 4.853824752882729e-18
Rsub_119_141 sn_119 sn_141 1344904.224882211
Csub_119_141 sn_119 sn_141 7.834374602513277e-18
Rsub_119_191 sn_119 sn_191 8203993.407987406
Csub_119_191 sn_119 sn_191 1.284311551490483e-18
Rsub_119_154 sn_119 sn_154 2125152.001534431
Csub_119_154 sn_119 sn_154 4.957990531793636e-18
Rsub_119_181 sn_119 sn_181 4101996.703993703
Csub_119_181 sn_119 sn_181 2.568623102980966e-18
Rsub_119_169 sn_119 sn_169 2050998.351996852
Csub_119_169 sn_119 sn_169 5.137246205961932e-18
Rsub_119_121 sn_119 sn_121 328090.1908232649
Csub_119_121 sn_119 sn_121 3.21145946966326e-17
Rsub_119_223 sn_119 sn_223 183530.6919119802
Csub_119_223 sn_119 sn_223 5.740992633146727e-17
Rsub_119_175 sn_119 sn_175 126765.6628726336
Csub_119_175 sn_119 sn_175 8.311780385526336e-17
Rsub_119_124 sn_119 sn_124 9550510.700733017
Csub_119_124 sn_119 sn_124 1.10323770449483e-18
Rsub_119_151 sn_119 sn_151 724384.8269650331
Csub_119_151 sn_119 sn_151 1.454542269524733e-17
Rsub_119_230 sn_119 0 38139.4335159394
Csub_119_230 sn_119 0 2.762621919338825e-16
Rsub_119_156 sn_119 sn_156 768615.7142813861
Csub_119_156 sn_119 sn_156 1.370838938946368e-17
Rsub_119_143 sn_119 sn_143 3620129.224650178
Csub_119_143 sn_119 sn_143 2.910526903427921e-18
Rsub_119_167 sn_119 sn_167 65224.01083580554
Csub_119_167 sn_119 sn_167 1.615430171682399e-16
Rsub_119_204 sn_119 sn_204 26956794.25946346
Csub_119_204 sn_119 sn_204 3.908655977715549e-19
Rsub_119_202 sn_119 sn_202 76201.32437114829
Csub_119_202 sn_119 sn_202 1.382716585201421e-16
Rsub_119_122 sn_119 sn_122 377845.5132815246
Csub_119_122 sn_119 sn_122 2.788569172284836e-17
Rsub_119_173 sn_119 sn_173 32035.20455726838
Csub_119_173 sn_119 sn_173 3.289032690081389e-16
Rsub_119_225 sn_119 sn_225 465522.8501435288
Csub_119_225 sn_119 sn_225 2.263365482270402e-17
Rsub_119_209 sn_119 sn_209 635257.4275244988
Csub_119_209 sn_119 sn_209 1.6586163412979e-17
Rsub_119_172 sn_119 sn_172 1971580.728120326
Csub_119_172 sn_119 sn_172 5.344180612008375e-18
Rsub_119_229 sn_119 sn_229 279279.7351198817
Csub_119_229 sn_119 sn_229 3.772734709056918e-17
Rsub_119_133 sn_119 sn_133 68244476.01415399
Csub_119_133 sn_119 sn_133 1.543932068588925e-19
Rsub_119_157 sn_119 sn_157 1549458.031446645
Csub_119_157 sn_119 sn_157 6.800108998365488e-18
Rsub_119_120 sn_119 sn_120 12720046.48810411
Csub_119_120 sn_119 sn_120 8.283368706304499e-19
Rsub_119_194 sn_119 sn_194 317596.3493903932
Csub_119_194 sn_119 sn_194 3.317570722224654e-17
Rsub_119_183 sn_119 sn_183 1967333.546933621
Csub_119_183 sn_119 sn_183 5.35571790490365e-18
Rsub_119_134 sn_119 sn_134 2232732.383186446
Csub_119_134 sn_119 sn_134 4.719098258965032e-18
Rsub_91_110 sn_91 sn_110 35499693.7906488
Csub_91_110 sn_91 sn_110 2.96804912300553e-19
Rsub_91_223 sn_91 sn_223 87679.346889778
Csub_91_223 sn_91 sn_223 1.201706430988298e-16
Rsub_91_121 sn_91 sn_121 4070095.251600788
Csub_91_121 sn_91 sn_121 2.588755999773212e-18
Rsub_91_149 sn_91 sn_149 632321.456291944
Csub_91_149 sn_91 sn_149 1.666317566387513e-17
Rsub_91_219 sn_91 sn_219 383104065.7834148
Csub_91_219 sn_91 sn_219 2.750292790728753e-20
Rsub_91_95 sn_91 sn_95 24041955.56993398
Csub_91_95 sn_91 sn_95 4.382540127229317e-19
Rsub_91_224 sn_91 sn_224 41439722.81368968
Csub_91_224 sn_91 sn_224 2.542604724843684e-19
Rsub_91_169 sn_91 sn_169 1665029.94532684
Csub_91_169 sn_91 sn_169 6.328104507550898e-18
Rsub_91_127 sn_91 sn_127 832514.97266342
Csub_91_127 sn_91 sn_127 1.26562090151018e-17
Rsub_91_146 sn_91 sn_146 23746705.61359517
Csub_91_146 sn_91 sn_146 4.43702957103986e-19
Rsub_91_132 sn_91 sn_132 25308455.16896797
Csub_91_132 sn_91 sn_132 4.163226649704538e-19
Rsub_91_129 sn_91 sn_129 7458285.737959084
Csub_91_129 sn_91 sn_129 1.412721887095901e-18
Rsub_91_215 sn_91 sn_215 5003587.528745659
Csub_91_215 sn_91 sn_215 2.105785787037361e-18
Rsub_91_124 sn_91 sn_124 15021298.36399347
Csub_91_124 sn_91 sn_124 7.014362704815376e-19
Rsub_91_226 sn_91 sn_226 771386.3411707886
Csub_91_226 sn_91 sn_226 1.365915228190069e-17
Rsub_91_173 sn_91 sn_173 10325588.9827525
Csub_91_173 sn_91 sn_173 1.020424454220458e-18
Rsub_91_157 sn_91 sn_157 169537.9458023344
Csub_91_157 sn_91 sn_157 6.214823149098766e-17
Rsub_91_98 sn_91 sn_98 29559.83760160589
Csub_91_98 sn_91 sn_98 3.564459197724953e-16
Rsub_91_119 sn_91 sn_119 35482.08524651283
Csub_91_119 sn_91 sn_119 2.969522064170544e-16
Rsub_91_193 sn_91 sn_193 108579832.4016479
Csub_91_193 sn_91 sn_193 9.703904739191775e-20
Rsub_91_230 sn_91 0 15500.18638174599
Csub_91_230 sn_91 0 6.797649552548888e-16
Rsub_91_181 sn_91 sn_181 25308455.16896797
Csub_91_181 sn_91 sn_181 4.163226649704538e-19
Rsub_91_102 sn_91 sn_102 15119.34493637242
Csub_91_102 sn_91 sn_102 6.968875666618674e-16
Rsub_91_187 sn_91 sn_187 516470.4912704629
Csub_91_187 sn_91 sn_187 2.040093999622585e-17
Rsub_91_108 sn_91 sn_108 1857.397349709278
Csub_91_108 sn_91 sn_108 5.672713759325211e-15
Rsub_91_202 sn_91 sn_202 97379.87812192574
Csub_91_202 sn_91 sn_202 1.08199801698639e-16
Rsub_91_128 sn_91 sn_128 169844.7826045142
Csub_91_128 sn_91 sn_128 6.203595624579381e-17
Rsub_91_222 sn_91 sn_222 1073468166.70647
Rsub_91_143 sn_91 sn_143 3898796.792450296
Csub_91_143 sn_91 sn_143 2.702496196424765e-18
Rsub_91_106 sn_91 sn_106 149367.6227159179
Csub_91_106 sn_91 sn_106 7.054061188527668e-17
Rsub_91_92 sn_91 sn_92 1117.255162690123
Csub_91_92 sn_91 sn_92 9.430686788558032e-15
Rsub_91_111 sn_91 sn_111 8194.711809844761
Csub_91_111 sn_91 sn_111 1.285766204684824e-15
Rsub_91_179 sn_91 sn_179 27495.47838274188
Csub_91_179 sn_91 sn_179 3.832078626005448e-16
Rsub_91_209 sn_91 sn_209 32247.73557770808
Csub_91_209 sn_91 sn_209 3.267356083604694e-16
Rsub_91_167 sn_91 sn_167 166035.3400781382
Csub_91_167 sn_91 sn_167 6.345928220625445e-17
Rsub_91_122 sn_91 sn_122 118393.2016038876
Csub_91_122 sn_91 sn_122 8.899568015300655e-17
Rsub_91_194 sn_91 sn_194 7088538.796315433
Csub_91_194 sn_91 sn_194 1.486411206172249e-18
Rsub_91_109 sn_91 sn_109 111472.4234300113
Csub_91_109 sn_91 sn_109 9.452098714661392e-17
Rsub_91_188 sn_91 sn_188 31340855.26656299
Csub_91_188 sn_91 sn_188 3.361900437181494e-19
Rsub_91_131 sn_91 sn_131 6207181.705277247
Csub_91_131 sn_91 sn_131 1.697466580247208e-18
Rsub_91_196 sn_91 sn_196 13194576.43741977
Csub_91_196 sn_91 sn_196 7.985465507137137e-19
Rsub_91_117 sn_91 sn_117 417782.3364349143
Csub_91_117 sn_91 sn_117 2.522003106244647e-17
Rsub_91_175 sn_91 sn_175 38181.52811443726
Csub_91_175 sn_91 sn_175 2.759576167472964e-16
Rsub_91_155 sn_91 sn_155 2928412.089167461
Csub_91_155 sn_91 sn_155 3.598019398023143e-18
Rsub_91_150 sn_91 sn_150 11454632.30549185
Csub_91_150 sn_91 sn_150 9.198447598512917e-19
Rsub_91_229 sn_91 sn_229 532809.5535108629
Csub_91_229 sn_91 sn_229 1.977532766220414e-17
Rsub_91_113 sn_91 sn_113 72923.76024667961
Csub_91_113 sn_91 sn_113 1.444862890584383e-16
Rsub_91_192 sn_91 sn_192 4492032.134334196
Csub_91_192 sn_91 sn_192 2.345593973314643e-18
Rsub_91_195 sn_91 sn_195 756363.7463310205
Csub_91_195 sn_91 sn_195 1.393044491270307e-17
Rsub_91_139 sn_91 sn_139 150023.8531589709
Csub_91_139 sn_91 sn_139 7.023205497238595e-17
Rsub_91_218 sn_91 sn_218 3096151.319887273
Csub_91_218 sn_91 sn_218 3.403090615937215e-18
Rsub_143_223 sn_143 sn_223 21953287.2563518
Csub_143_223 sn_143 sn_223 4.799501495695801e-19
Rsub_143_181 sn_143 sn_181 26964752.7729451
Csub_143_181 sn_143 sn_181 3.907502357226026e-19
Rsub_143_205 sn_143 sn_205 24686259.4817815
Csub_143_205 sn_143 sn_205 4.268157154390256e-19
Rsub_143_161 sn_143 sn_161 55412387.92509034
Csub_143_161 sn_143 sn_161 1.901467144219417e-19
Rsub_143_197 sn_143 sn_197 152321426.2609043
Csub_143_197 sn_143 sn_197 6.91726946160716e-20
Rsub_143_226 sn_143 sn_226 4306129.407183378
Csub_143_226 sn_143 sn_226 2.446857143831605e-18
Rsub_143_152 sn_143 sn_152 53503282.54084169
Csub_143_152 sn_143 sn_152 1.969315339519026e-19
Rsub_143_177 sn_143 sn_177 31913825.4549596
Csub_143_177 sn_143 sn_177 3.301541996931794e-19
Rsub_143_209 sn_143 sn_209 14927166.61967242
Csub_143_209 sn_143 sn_209 7.058595760794976e-19
Rsub_143_179 sn_143 sn_179 88669.74520204593
Csub_143_179 sn_143 sn_179 1.1882839494149e-16
Rsub_143_230 sn_143 0 599681.1051149353
Csub_143_230 sn_143 0 1.757014421891877e-17
Rsub_143_202 sn_143 sn_202 2438811.320706376
Csub_143_202 sn_143 sn_202 4.320335654001401e-18
Rsub_143_225 sn_143 sn_225 56049185.10046483
Csub_143_225 sn_143 sn_225 1.879863816636046e-19
Rsub_143_167 sn_143 sn_167 18260.57982503333
Csub_143_167 sn_143 sn_167 5.770070612864981e-16
Rsub_143_212 sn_143 sn_212 9378695.847521221
Csub_143_212 sn_143 sn_212 1.123448683434465e-18
Rsub_143_175 sn_143 sn_175 51258.91839986946
Csub_143_175 sn_143 sn_175 2.055541519630823e-16
Rsub_143_159 sn_143 sn_159 53696609.66836054
Csub_143_159 sn_143 sn_159 1.962225095272333e-19
Rsub_143_217 sn_143 sn_217 17259727.23904543
Csub_143_217 sn_143 sn_217 6.104663970815297e-19
Rsub_143_163 sn_143 sn_163 285242.0166907828
Csub_143_163 sn_143 sn_163 3.693874985343445e-17
Rsub_143_157 sn_143 sn_157 12008181.37238767
Csub_143_157 sn_143 sn_157 8.774420684932538e-19
Rsub_143_153 sn_143 sn_153 53696609.66836054
Csub_143_153 sn_143 sn_153 1.962225095272333e-19
Rsub_143_173 sn_143 sn_173 2760611.863201826
Csub_143_173 sn_143 sn_173 3.816720359235697e-18
Rsub_172_187 sn_172 sn_187 869960.589211521
Csub_172_187 sn_172 sn_187 1.211144922298104e-17
Rsub_172_176 sn_172 sn_176 7588089.755114855
Csub_172_176 sn_172 sn_176 1.388555465508001e-18
Rsub_172_179 sn_172 sn_179 2657761.009798568
Csub_172_179 sn_172 sn_179 3.964420978178381e-18
Rsub_172_204 sn_172 sn_204 12872690.22340357
Csub_172_204 sn_172 sn_204 8.185144922600435e-19
Rsub_172_215 sn_172 sn_215 1794499.958013074
Csub_172_215 sn_172 sn_215 5.871542908196177e-18
Rsub_172_178 sn_172 sn_178 7491426.19135543
Csub_172_178 sn_172 sn_178 1.406472310224233e-18
Rsub_172_228 sn_172 sn_228 4903498.230817624
Csub_172_228 sn_172 sn_228 2.148768696603184e-18
Rsub_172_185 sn_172 sn_185 7080606.045377874
Csub_172_185 sn_172 sn_185 1.488076505697994e-18
Rsub_172_222 sn_172 sn_222 1285000.665078554
Csub_172_222 sn_172 sn_222 8.199593812339303e-18
Rsub_172_223 sn_172 sn_223 586772.1825573596
Csub_172_223 sn_172 sn_223 1.795668543165815e-17
Rsub_172_202 sn_172 sn_202 1290200.069334143
Csub_172_202 sn_172 sn_202 8.166550097666444e-18
Rsub_172_198 sn_172 sn_198 2129896.101672908
Csub_172_198 sn_172 sn_198 4.946947174537864e-18
Rsub_172_220 sn_172 sn_220 3039775.975107677
Csub_172_220 sn_172 sn_220 3.466203953354414e-18
Rsub_172_188 sn_172 sn_188 39133932.8787592
Csub_172_188 sn_172 sn_188 2.692416204339357e-19
Rsub_172_225 sn_172 sn_225 137631.7424514297
Csub_172_225 sn_172 sn_225 7.655562092406358e-17
Rsub_172_195 sn_172 sn_195 816979.3456366463
Csub_172_195 sn_172 sn_195 1.289687867692573e-17
Rsub_172_229 sn_172 sn_229 7794.862685482208
Csub_172_229 sn_172 sn_229 1.351721502657643e-15
Rsub_172_230 sn_172 0 32917.19085716699
Csub_172_230 sn_172 0 3.200906039628201e-16
Rsub_172_205 sn_172 sn_205 596601.7195781869
Csub_172_205 sn_172 sn_205 1.766083327698012e-17
Rsub_172_214 sn_172 sn_214 3720566.446176989
Csub_172_214 sn_172 sn_214 2.831956814816896e-18
Rsub_172_177 sn_172 sn_177 513757.6627607464
Csub_172_177 sn_172 sn_177 2.0508664426747e-17
Rsub_172_194 sn_172 sn_194 404272.6558141508
Csub_172_194 sn_172 sn_194 2.606281515877184e-17
Rsub_172_209 sn_172 sn_209 484749.6755060915
Csub_172_209 sn_172 sn_209 2.173592688067224e-17
Rsub_172_189 sn_172 sn_189 2557106.929117699
Csub_172_189 sn_172 sn_189 4.120470435651863e-18
Rsub_172_226 sn_172 sn_226 885216.3410834512
Csub_172_226 sn_172 sn_226 1.190272141760734e-17
Rsub_172_212 sn_172 sn_212 6154661.513315662
Csub_172_212 sn_172 sn_212 1.711951742501879e-18
Rsub_172_217 sn_172 sn_217 1284487.321630954
Csub_172_217 sn_172 sn_217 8.20287076781069e-18
Rsub_172_182 sn_172 sn_182 15539766.32391573
Csub_172_182 sn_172 sn_182 6.780335870311212e-19
Rsub_172_219 sn_172 sn_219 2583698.448754078
Csub_172_219 sn_172 sn_219 4.078062402100736e-18
Rsub_172_190 sn_172 sn_190 3779630.809952759
Csub_172_190 sn_172 sn_190 2.787701770893781e-18
Rsub_5_65 sn_5 sn_65 251095074.7676869
Csub_5_65 sn_5 sn_65 4.196212734151935e-20
Rsub_5_99 sn_5 sn_99 459633769.285924
Csub_5_99 sn_5 sn_99 2.292364966699298e-20
Rsub_5_228 sn_5 sn_228 250568341.1455137
Csub_5_228 sn_5 sn_228 4.205033825925799e-20
Rsub_5_55 sn_5 sn_55 285989966.2205878
Csub_5_55 sn_5 sn_55 3.684214394466928e-20
Rsub_5_151 sn_5 sn_151 791352253.6597954
Csub_5_151 sn_5 sn_151 1.331453022784928e-20
Rsub_5_15 sn_5 sn_15 4510031894.323488
Rsub_5_70 sn_5 sn_70 1669283082.561509
Rsub_5_172 sn_5 sn_172 297789422.5190203
Csub_5_172 sn_5 sn_172 3.538232961097542e-20
Rsub_5_205 sn_5 sn_205 322185389.4627393
Csub_5_205 sn_5 sn_205 3.270316981102132e-20
Rsub_5_75 sn_5 sn_75 329486559.3565911
Csub_5_75 sn_5 sn_75 3.197849260620903e-20
Rsub_5_108 sn_5 sn_108 650645316.670337
Csub_5_108 sn_5 sn_108 1.619389740043042e-20
Rsub_5_9 sn_5 sn_9 510848853.8258195
Csub_5_9 sn_5 sn_9 2.062544218964334e-20
Rsub_5_24 sn_5 sn_24 373279867.6671302
Csub_5_24 sn_5 sn_24 2.822676606718539e-20
Rsub_5_37 sn_5 sn_37 710206595.4788126
Csub_5_37 sn_5 sn_37 1.483580069420002e-20
Rsub_5_118 sn_5 sn_118 199088739.9386212
Csub_5_118 sn_5 sn_118 5.292355311243813e-20
Rsub_5_194 sn_5 sn_194 699503284.1342587
Csub_5_194 sn_5 sn_194 1.506280776833021e-20
Rsub_5_60 sn_5 sn_60 783471718.3932047
Csub_5_60 sn_5 sn_60 1.344845417501338e-20
Rsub_5_20 sn_5 sn_20 1290675757.638674
Rsub_5_61 sn_5 sn_61 444658966.1070644
Csub_5_61 sn_5 sn_61 2.369565061169382e-20
Rsub_5_29 sn_5 sn_29 156021983.3782466
Csub_5_29 sn_5 sn_29 6.753204435740464e-20
Rsub_5_89 sn_5 sn_89 1298731351.502136
Rsub_5_204 sn_5 sn_204 243312072.3318366
Csub_5_204 sn_5 sn_204 4.330440081024841e-20
Rsub_5_83 sn_5 sn_83 695532054.9893483
Csub_5_83 sn_5 sn_83 1.51488107940494e-20
Rsub_5_110 sn_5 sn_110 4590931242.408671
Rsub_5_112 sn_5 sn_112 549329873.755182
Csub_5_112 sn_5 sn_112 1.918061260750905e-20
Rsub_5_114 sn_5 sn_114 834641541.2807543
Csub_5_114 sn_5 sn_114 1.262396248102126e-20
Rsub_5_230 sn_5 0 598165.5017749068
Csub_5_230 sn_5 0 1.761466261589078e-17
Rsub_5_219 sn_5 sn_219 293923980.8520432
Csub_5_219 sn_5 sn_219 3.584764833303583e-20
Rsub_5_116 sn_5 sn_116 117012535.9029211
Csub_5_116 sn_5 sn_116 9.00457666430847e-20
Rsub_5_178 sn_5 sn_178 206849782.3468315
Csub_5_178 sn_5 sn_178 5.093785153016575e-20
Rsub_5_174 sn_5 sn_174 43751562.26150527
Csub_5_174 sn_5 sn_174 2.408253090313191e-19
Rsub_5_95 sn_5 sn_95 251106514.6720454
Csub_5_95 sn_5 sn_95 4.196021563196418e-20
Rsub_5_184 sn_5 sn_184 21875141.1697744
Csub_5_184 sn_5 sn_184 4.8166470883345e-19
Rsub_5_17 sn_5 sn_17 192531626.7457974
Csub_5_17 sn_5 sn_17 5.472598803801461e-20
Rsub_5_31 sn_5 sn_31 108462392.8152533
Csub_5_31 sn_5 sn_31 9.714411814772568e-20
Rsub_5_198 sn_5 sn_198 36782544.1622268
Csub_5_198 sn_5 sn_198 2.864533637412243e-19
Rsub_5_66 sn_5 sn_66 128191581.0356983
Csub_5_66 sn_5 sn_66 8.21932565079749e-20
Rsub_5_190 sn_5 sn_190 44758195.06705631
Csub_5_190 sn_5 sn_190 2.354090348470116e-19
Rsub_5_23 sn_5 sn_23 42504720.33435595
Csub_5_23 sn_5 sn_23 2.478897265844028e-19
Rsub_5_57 sn_5 sn_57 81334267.30478367
Csub_5_57 sn_5 sn_57 1.295454407027073e-19
Rsub_5_224 sn_5 sn_224 22688976.44047022
Csub_5_224 sn_5 sn_224 4.643877845205977e-19
Rsub_5_215 sn_5 sn_215 19028751.21544801
Csub_5_215 sn_5 sn_215 5.537138713378218e-19
Rsub_5_48 sn_5 sn_48 27729929.58890747
Csub_5_48 sn_5 sn_48 3.799679140348342e-19
Rsub_5_229 sn_5 sn_229 48625725.44308814
Csub_5_229 sn_5 sn_229 2.166853739706561e-19
Rsub_5_150 sn_5 sn_150 686578023.6870724
Csub_5_150 sn_5 sn_150 1.534637453970171e-20
Rsub_5_209 sn_5 sn_209 378877318.5495576
Csub_5_209 sn_5 sn_209 2.780974998072316e-20
Rsub_5_42 sn_5 sn_42 45940793.45543369
Csub_5_42 sn_5 sn_42 2.29349184237561e-19
Rsub_5_84 sn_5 sn_84 43425706.55016747
Csub_5_84 sn_5 sn_84 2.426324023089353e-19
Rsub_5_162 sn_5 sn_162 13163010.49400817
Csub_5_162 sn_5 sn_162 8.004615286925607e-19
Rsub_5_154 sn_5 sn_154 149120530.4817723
Csub_5_154 sn_5 sn_154 7.065749744980906e-20
Rsub_5_125 sn_5 sn_125 70727482.27739848
Csub_5_125 sn_5 sn_125 1.489729757508563e-19
Rsub_5_196 sn_5 sn_196 29610071.54560133
Csub_5_196 sn_5 sn_196 3.558412037607937e-19
Rsub_5_117 sn_5 sn_117 122085282.4823525
Csub_5_117 sn_5 sn_117 8.630428900185455e-20
Rsub_5_195 sn_5 sn_195 76260702.70300782
Csub_5_195 sn_5 sn_195 1.381639970361095e-19
Rsub_5_101 sn_5 sn_101 108138701.5957884
Csub_5_101 sn_5 sn_101 9.743489931675264e-20
Rsub_5_180 sn_5 sn_180 2548780221.998164
Rsub_5_185 sn_5 sn_185 599805496.2460308
Csub_5_185 sn_5 sn_185 1.756650042084326e-20
Rsub_5_27 sn_5 sn_27 834641541.2807543
Csub_5_27 sn_5 sn_27 1.262396248102126e-20
Rsub_5_86 sn_5 sn_86 10358529.0003592
Csub_5_86 sn_5 sn_86 1.017179514761665e-18
Rsub_5_132 sn_5 sn_132 24583825.27638059
Csub_5_132 sn_5 sn_132 4.285941420334265e-19
Rsub_5_53 sn_5 sn_53 45894886.41181639
Csub_5_53 sn_5 sn_53 2.295785941746488e-19
Rsub_5_220 sn_5 sn_220 394377620.9048316
Csub_5_220 sn_5 sn_220 2.671673782618763e-20
Rsub_5_44 sn_5 sn_44 1305565.4174054
Csub_5_44 sn_5 sn_44 8.070437039585162e-18
Rsub_5_181 sn_5 sn_181 24429619.86015267
Csub_5_181 sn_5 sn_181 4.312995274812333e-19
Rsub_5_208 sn_5 sn_208 25339502.35887127
Csub_5_208 sn_5 sn_208 4.158125662061874e-19
Rsub_5_41 sn_5 sn_41 207269151.0796878
Csub_5_41 sn_5 sn_41 5.083478871479088e-20
Rsub_5_146 sn_5 sn_146 82709892.36606218
Csub_5_146 sn_5 sn_146 1.273908501246384e-19
Rsub_5_223 sn_5 sn_223 181422396.3873671
Csub_5_223 sn_5 sn_223 5.807708260965117e-20
Rsub_5_186 sn_5 sn_186 368098524.4299262
Csub_5_186 sn_5 sn_186 2.862408513739043e-20
Rsub_5_100 sn_5 sn_100 729410878.3412154
Csub_5_100 sn_5 sn_100 1.444519654846863e-20
Rsub_5_21 sn_5 sn_21 18978129.56686636
Csub_5_21 sn_5 sn_21 5.551908297973419e-19
Rsub_5_188 sn_5 sn_188 311876135.3261362
Csub_5_188 sn_5 sn_188 3.378419285339596e-20
Rsub_5_166 sn_5 sn_166 207071.06734222
Csub_5_166 sn_5 sn_166 5.0883417164295e-17
Rsub_5_206 sn_5 sn_206 157653657.1336671
Csub_5_206 sn_5 sn_206 6.683310551620513e-20
Rsub_5_197 sn_5 sn_197 9823294.655033302
Csub_5_197 sn_5 sn_197 1.072601797283081e-18
Rsub_5_30 sn_5 sn_30 278008786.542963
Csub_5_30 sn_5 sn_30 3.789982192020292e-20
Rsub_5_160 sn_5 sn_160 33824875.11662755
Csub_5_160 sn_5 sn_160 3.115010318855693e-19
Rsub_5_25 sn_5 sn_25 4556428.840526939
Csub_5_25 sn_5 sn_25 2.312443334682142e-18
Rsub_5_155 sn_5 sn_155 30604908.81317176
Csub_5_155 sn_5 sn_155 3.442742981706028e-19
Rsub_5_177 sn_5 sn_177 23738567.85506475
Csub_5_177 sn_5 sn_177 4.438550617948078e-19
Rsub_5_10 sn_5 sn_10 326902400.3967355
Csub_5_10 sn_5 sn_10 3.223128214856394e-20
Rsub_5_93 sn_5 sn_93 19340674.59404252
Csub_5_93 sn_5 sn_93 5.447836605180018e-19
Rsub_5_226 sn_5 sn_226 72261.67092980129
Csub_5_226 sn_5 sn_226 1.458101282001309e-16
Rsub_5_59 sn_5 sn_59 12177515.8728437
Csub_5_59 sn_5 sn_59 8.652407939559119e-19
Rsub_5_144 sn_5 sn_144 26385883.65998999
Csub_5_144 sn_5 sn_144 3.993227453741452e-19
Rsub_5_64 sn_5 sn_64 89454321.26095067
Csub_5_64 sn_5 sn_64 1.177861880086666e-19
Rsub_5_222 sn_5 sn_222 470582.2541746927
Csub_5_222 sn_5 sn_222 2.239031202039033e-17
Rsub_5_35 sn_5 sn_35 200828.3072464773
Csub_5_35 sn_5 sn_35 5.246513126906228e-17
Rsub_5_202 sn_5 sn_202 103908013.7466826
Csub_5_202 sn_5 sn_202 1.014020297598691e-19
Rsub_5_6 sn_5 sn_6 47357223.28160217
Csub_5_6 sn_5 sn_6 2.224894698655891e-19
Rsub_5_191 sn_5 sn_191 91483505.6190678
Csub_5_191 sn_5 sn_191 1.151735870956162e-19
Rsub_5_138 sn_5 sn_138 4382343.88297865
Csub_5_138 sn_5 sn_138 2.404303218456792e-18
Rsub_5_212 sn_5 sn_212 9226270.041696152
Csub_5_212 sn_5 sn_212 1.142009008473914e-18
Rsub_5_45 sn_5 sn_45 441100.1929752775
Csub_5_45 sn_5 sn_45 2.388682587318782e-17
Rsub_5_54 sn_5 sn_54 115908313.1794361
Csub_5_54 sn_5 sn_54 9.090360486843263e-20
Rsub_5_158 sn_5 sn_158 30690369.60560463
Csub_5_158 sn_5 sn_158 3.433156275936751e-19
Rsub_5_43 sn_5 sn_43 16596980.00149305
Csub_5_43 sn_5 sn_43 6.348434173736515e-19
Rsub_5_210 sn_5 sn_210 228328548.8567595
Csub_5_210 sn_5 sn_210 4.614615016381503e-20
Rsub_5_122 sn_5 sn_122 354211675.563281
Csub_5_122 sn_5 sn_122 2.974629078918553e-20
Rsub_5_52 sn_5 sn_52 217401.4040375489
Csub_5_52 sn_5 sn_52 4.84655724689348e-17
Rsub_5_137 sn_5 sn_137 54942117.31317069
Csub_5_137 sn_5 sn_137 1.917742529318978e-19
Rsub_5_225 sn_5 sn_225 1122043813.198287
Rsub_5_216 sn_5 sn_216 2427260.378715768
Csub_5_216 sn_5 sn_216 4.340895436938957e-18
Rsub_5_49 sn_5 sn_49 54778405.15901548
Csub_5_49 sn_5 sn_49 1.923473944092346e-19
Rsub_5_141 sn_5 sn_141 15729639.60729479
Csub_5_141 sn_5 sn_141 6.698490089590861e-19
Rsub_5_218 sn_5 sn_218 165806.1805070025
Csub_5_218 sn_5 sn_218 6.354698883968934e-17
Rsub_5_51 sn_5 sn_51 142460007.0989084
Csub_5_51 sn_5 sn_51 7.39609923991836e-20
Rsub_5_139 sn_5 sn_139 46676420.87652465
Csub_5_139 sn_5 sn_139 2.257346065608299e-19
Rsub_5_120 sn_5 sn_120 49342599.63418363
Csub_5_120 sn_5 sn_120 2.135372594947455e-19
Rsub_5_77 sn_5 sn_77 163169785.9086532
Csub_5_77 sn_5 sn_77 6.457374104865596e-20
Rsub_5_98 sn_5 sn_98 141269799.9479091
Csub_5_98 sn_5 sn_98 7.458411851729918e-20
Rsub_5_175 sn_5 sn_175 100144951.2307738
Csub_5_175 sn_5 sn_175 1.052123284572754e-19
Rsub_5_153 sn_5 sn_153 83673134.4876096
Csub_5_153 sn_5 sn_153 1.259243312295209e-19
Rsub_5_179 sn_5 sn_179 137837603.3472036
Csub_5_179 sn_5 sn_179 7.644128486251544e-20
Rsub_5_12 sn_5 sn_12 2318555309.390486
Rsub_5_33 sn_5 sn_33 45383809.86076632
Csub_5_33 sn_5 sn_33 2.321639266195376e-19
Rsub_5_200 sn_5 sn_200 44751757.51140855
Csub_5_200 sn_5 sn_200 2.354428985173138e-19
Rsub_5_170 sn_5 sn_170 64067495.14331846
Csub_5_170 sn_5 sn_170 1.644591142303905e-19
Rsub_5_130 sn_5 sn_130 81699657.98613799
Csub_5_130 sn_5 sn_130 1.289660662229177e-19
Rsub_5_71 sn_5 sn_71 114618341.5746706
Csub_5_71 sn_5 sn_71 9.192667907662741e-20
Rsub_5_46 sn_5 sn_46 158672172.0777462
Csub_5_46 sn_5 sn_46 6.640410453993998e-20
Rsub_5_213 sn_5 sn_213 57680027.12245082
Csub_5_213 sn_5 sn_213 1.826712646972539e-19
Rsub_5_142 sn_5 sn_142 23097630.69617768
Csub_5_142 sn_5 sn_142 4.561716152113228e-19
Rsub_5_214 sn_5 sn_214 114887083.9119625
Csub_5_214 sn_5 sn_214 9.171164541267372e-20
Rsub_5_47 sn_5 sn_47 926550899.3908793
Csub_5_47 sn_5 sn_47 1.137172659284747e-20
Rsub_5_156 sn_5 sn_156 93545246.39579514
Csub_5_156 sn_5 sn_156 1.126351568699659e-19
Rsub_5_103 sn_5 sn_103 21577882.71087481
Csub_5_103 sn_5 sn_103 4.883001563874397e-19
Rsub_5_88 sn_5 sn_88 412216564.7896593
Csub_5_88 sn_5 sn_88 2.55605533649683e-20
Rsub_5_111 sn_5 sn_111 686703199.4535779
Csub_5_111 sn_5 sn_111 1.534357712416961e-20
Rsub_5_176 sn_5 sn_176 836082959.64153
Csub_5_176 sn_5 sn_176 1.260219859850691e-20
Rsub_5_183 sn_5 sn_183 179807708.2017922
Csub_5_183 sn_5 sn_183 5.859861964541173e-20
Rsub_5_16 sn_5 sn_16 988195394.7611325
Csub_5_16 sn_5 sn_16 1.066234831500798e-20
Rsub_5_203 sn_5 sn_203 13392773.65080974
Csub_5_203 sn_5 sn_203 7.86729006025795e-19
Rsub_5_36 sn_5 sn_36 276796870.1017768
Csub_5_36 sn_5 sn_36 3.806576099778797e-20
Rsub_5_107 sn_5 sn_107 307708224.5746088
Csub_5_107 sn_5 sn_107 3.424180005846826e-20
Rsub_5_129 sn_5 sn_129 160629362.6200754
Csub_5_129 sn_5 sn_129 6.559500287099536e-20
Rsub_5_127 sn_5 sn_127 188891431.645619
Csub_5_127 sn_5 sn_127 5.578063234756777e-20
Rsub_5_207 sn_5 sn_207 2780727.58495391
Csub_5_207 sn_5 sn_207 3.789110288703323e-18
Rsub_5_26 sn_5 sn_26 1669283082.561509
Rsub_5_123 sn_5 sn_123 591333579.2899029
Csub_5_123 sn_5 sn_123 1.781817213032724e-20
Rsub_5_79 sn_5 sn_79 440086022.2932805
Csub_5_79 sn_5 sn_79 2.394187265327031e-20
Rsub_5_80 sn_5 sn_80 154687356.0760538
Csub_5_80 sn_5 sn_80 6.811470419760502e-20
Rsub_5_163 sn_5 sn_163 818542169.5831996
Csub_5_163 sn_5 sn_163 1.28722549598088e-20
Rsub_5_157 sn_5 sn_157 89821799.15882723
Csub_5_157 sn_5 sn_157 1.173043025290429e-19
Rsub_5_217 sn_5 sn_217 5005045860.041533
Rsub_5_136 sn_5 sn_136 148971642.2744327
Csub_5_136 sn_5 sn_136 7.072811537393065e-20
Rsub_5_147 sn_5 sn_147 691691191.4097013
Csub_5_147 sn_5 sn_147 1.523293000270268e-20
Rsub_5_161 sn_5 sn_161 1050298690.383731
Csub_5_161 sn_5 sn_161 1.003189244992818e-20
Rsub_5_171 sn_5 sn_171 132877071.8737429
Csub_5_171 sn_5 sn_171 7.929497055926666e-20
Rsub_5_182 sn_5 sn_182 6690140.490845651
Csub_5_182 sn_5 sn_182 1.574927091089856e-18
Rsub_5_34 sn_5 sn_34 10028326.67297972
Csub_5_34 sn_5 sn_34 1.050672145595283e-18
Rsub_5_169 sn_5 sn_169 223888577.3269609
Csub_5_169 sn_5 sn_169 4.706128212536186e-20
Rsub_5_32 sn_5 sn_32 77138975.98846769
Csub_5_32 sn_5 sn_32 1.365909174605223e-19
Rsub_5_67 sn_5 sn_67 241795894.2116182
Csub_5_67 sn_5 sn_67 4.357594051207725e-20
Rsub_5_97 sn_5 sn_97 112613221.1424563
Csub_5_97 sn_5 sn_97 9.356346790667946e-20
Rsub_5_159 sn_5 sn_159 332663168.5172828
Csub_5_159 sn_5 sn_159 3.167312915701577e-20
Rsub_5_165 sn_5 sn_165 216789229.9398264
Csub_5_165 sn_5 sn_165 4.860243059655033e-20
Rsub_5_85 sn_5 sn_85 836082959.64153
Csub_5_85 sn_5 sn_85 1.260219859850691e-20
Rsub_5_189 sn_5 sn_189 556427694.1871696
Csub_5_189 sn_5 sn_189 1.89359437215319e-20
Rsub_5_134 sn_5 sn_134 1756449401.347003
Rsub_5_168 sn_5 sn_168 329070204.811754
Csub_5_168 sn_5 sn_168 3.201895324512118e-20
Rsub_5_133 sn_5 sn_133 59700039.19862802
Csub_5_133 sn_5 sn_133 1.764903950426911e-19
Rsub_5_69 sn_5 sn_69 935968187.4078786
Csub_5_69 sn_5 sn_69 1.12573094299394e-20
Rsub_5_92 sn_5 sn_92 1524021669.462974
Rsub_5_87 sn_5 sn_87 259900481.1389984
Csub_5_87 sn_5 sn_87 4.054045400783597e-20
Rsub_5_128 sn_5 sn_128 58112855.20790831
Csub_5_128 sn_5 sn_128 1.813107179906063e-19
Rsub_5_96 sn_5 sn_96 613612972.1856942
Csub_5_96 sn_5 sn_96 1.717122026397024e-20
Rsub_5_91 sn_5 sn_91 200311712.6322319
Csub_5_91 sn_5 sn_91 5.26004364087025e-20
Rsub_5_149 sn_5 sn_149 1669283082.561509
Rsub_5_115 sn_5 sn_115 1852106993.772846
Rsub_5_145 sn_5 sn_145 763530891.9713926
Csub_5_145 sn_5 sn_145 1.379968199456267e-20
Rsub_5_140 sn_5 sn_140 524656558.1085606
Csub_5_140 sn_5 sn_140 2.008262994027003e-20
Rsub_87_214 sn_87 sn_214 8793215.004935225
Csub_87_214 sn_87 sn_214 1.198251549213383e-18
Rsub_87_183 sn_87 sn_183 1085944.614550326
Csub_87_183 sn_87 sn_183 9.702597499959061e-18
Rsub_87_226 sn_87 sn_226 749082.7862976177
Csub_87_226 sn_87 sn_226 1.406584651919068e-17
Rsub_87_190 sn_87 sn_190 428596.0847860604
Csub_87_190 sn_87 sn_190 2.458371384211182e-17
Rsub_87_111 sn_87 sn_111 146899.8976620775
Csub_87_111 sn_87 sn_111 7.172560137834607e-17
Rsub_87_222 sn_87 sn_222 1076990.014945956
Csub_87_222 sn_87 sn_222 9.783269441693688e-18
Rsub_87_193 sn_87 sn_193 31200.13900200547
Csub_87_193 sn_87 sn_193 3.377063000120846e-16
Rsub_87_225 sn_87 sn_225 84880.26971337255
Csub_87_225 sn_87 sn_225 1.241334828200955e-16
Rsub_87_122 sn_87 sn_122 734393.5726161255
Csub_87_122 sn_87 sn_122 1.434718915730152e-17
Rsub_87_145 sn_87 sn_145 186379.2189432138
Csub_87_145 sn_87 sn_145 5.653250164891113e-17
Rsub_87_209 sn_87 sn_209 3914.091839153682
Csub_87_209 sn_87 sn_209 2.6919356865444e-15
Rsub_87_230 sn_87 0 21325.97267987084
Csub_87_230 sn_87 0 4.940681328066774e-16
Rsub_87_151 sn_87 sn_151 542972.3072751631
Csub_87_151 sn_87 sn_151 1.940519499991812e-17
Rsub_87_179 sn_87 sn_179 304781.8961256388
Csub_87_179 sn_87 sn_179 3.457056877776821e-17
Rsub_87_100 sn_87 sn_100 27739.73624527071
Csub_87_100 sn_87 sn_100 3.798335863422763e-16
Rsub_87_117 sn_87 sn_117 3808.127222519246
Csub_87_117 sn_87 sn_117 2.766841254652109e-15
Rsub_87_172 sn_87 sn_172 436014.4509133886
Csub_87_172 sn_87 sn_172 2.416544561804673e-17
Rsub_87_98 sn_87 sn_98 412917.1903125111
Csub_87_98 sn_87 sn_98 2.551718298348296e-17
Rsub_87_124 sn_87 sn_124 1841448.570716925
Csub_87_124 sn_87 sn_124 5.721845111388511e-18
Rsub_87_166 sn_87 sn_166 5077089.753537376
Csub_87_166 sn_87 sn_166 2.075299829964378e-18
Rsub_87_121 sn_87 sn_121 1454650.697046645
Csub_87_121 sn_87 sn_121 7.243308323862258e-18
Rsub_87_200 sn_87 sn_200 6878805.741654105
Csub_87_200 sn_87 sn_200 1.531731509501293e-18
Rsub_87_94 sn_87 sn_94 73289.65162496074
Csub_87_94 sn_87 sn_94 1.437649554693956e-16
Rsub_87_205 sn_87 sn_205 765.4344665668004
Csub_87_205 sn_87 sn_205 1.37653632837952e-14
Rsub_87_229 sn_87 sn_229 3680.163800877092
Csub_87_229 sn_87 sn_229 2.863047427323437e-15
Rsub_87_150 sn_87 sn_150 7164130.967237622
Csub_87_150 sn_87 sn_150 1.470727370900187e-18
Rsub_87_202 sn_87 sn_202 2069505798.362089
Rsub_87_91 sn_87 sn_91 203089.6130232518
Csub_87_91 sn_87 sn_91 5.188095710746012e-17
Rsub_87_128 sn_87 sn_128 16780.03638507639
Csub_87_128 sn_87 sn_128 6.279177982951694e-16
Rsub_87_207 sn_87 sn_207 10168661.68047807
Csub_87_207 sn_87 sn_207 1.036172097500114e-18
Rsub_87_220 sn_87 sn_220 41318.93856751295
Csub_87_220 sn_87 sn_220 2.550037311586295e-16
Rsub_87_141 sn_87 sn_141 325548.0294300687
Csub_87_141 sn_87 sn_141 3.236537330812919e-17
Rsub_87_109 sn_87 sn_109 711902.687289138
Csub_87_109 sn_87 sn_109 1.480045473961054e-17
Rsub_87_188 sn_87 sn_188 31630609.76653964
Csub_87_188 sn_87 sn_188 3.331103503852144e-19
Rsub_87_96 sn_87 sn_96 309521.2875795516
Csub_87_96 sn_87 sn_96 3.404122406127549e-17
Rsub_87_187 sn_87 sn_187 318058.6318865863
Csub_87_187 sn_87 sn_187 3.312748797205136e-17
Rsub_87_199 sn_87 sn_199 8819889.724990236
Csub_87_199 sn_87 sn_199 1.194627578208373e-18
Rsub_87_217 sn_87 sn_217 1042.573594453467
Csub_87_217 sn_87 sn_217 1.010622517037119e-14
Rsub_87_138 sn_87 sn_138 63260408.42841522
Csub_87_138 sn_87 sn_138 1.665573107096356e-19
Rsub_87_106 sn_87 sn_106 87568.77203286
Csub_87_106 sn_87 sn_106 1.203223849967453e-16
Rsub_87_163 sn_87 sn_163 3542035.94837225
Csub_87_163 sn_87 sn_163 2.974696941478548e-18
Rsub_87_227 sn_87 sn_227 514101.018551334
Csub_87_227 sn_87 sn_227 2.049496717964178e-17
Rsub_87_148 sn_87 sn_148 8446851.649053553
Csub_87_148 sn_87 sn_148 1.247385882929598e-18
Rsub_87_115 sn_87 sn_115 201437.3758329495
Csub_87_115 sn_87 sn_115 5.230649703741091e-17
Rsub_87_195 sn_87 sn_195 1865470.760906128
Csub_87_195 sn_87 sn_195 5.648163307106483e-18
Rsub_87_216 sn_87 sn_216 2286276.218535622
Csub_87_216 sn_87 sn_216 4.60857853342791e-18
Rsub_87_88 sn_87 sn_88 15085657.57237882
Csub_87_88 sn_87 sn_88 6.984437669804887e-19
Rsub_87_131 sn_87 sn_131 3110296.686436762
Csub_87_131 sn_87 sn_131 3.387613647333713e-18
Rsub_87_153 sn_87 sn_153 748871.1206274214
Csub_87_153 sn_87 sn_153 1.406982217901833e-17
Rsub_87_218 sn_87 sn_218 1580180.593597492
Csub_87_218 sn_87 sn_218 6.667898305371725e-18
Rsub_87_139 sn_87 sn_139 290240.1313559671
Csub_87_139 sn_87 sn_139 3.630264172292374e-17
Rsub_87_223 sn_87 sn_223 466616.8265645934
Csub_87_223 sn_87 sn_223 2.258059054535927e-17
Rsub_87_112 sn_87 sn_112 137308428.3474437
Csub_87_112 sn_87 sn_112 7.673588307025555e-20
Rsub_87_191 sn_87 sn_191 206266.6216699005
Csub_87_191 sn_87 sn_191 5.108186393381715e-17
Rsub_87_197 sn_87 sn_197 39861001.16079443
Csub_87_197 sn_87 sn_197 2.643306288200617e-19
Rsub_87_152 sn_87 sn_152 437674.7467034397
Csub_87_152 sn_87 sn_152 2.407377528996281e-17
Rsub_87_92 sn_87 sn_92 234305.4725820255
Csub_87_92 sn_87 sn_92 4.496900301183275e-17
Rsub_87_99 sn_87 sn_99 16424018.26051919
Csub_87_99 sn_87 sn_99 6.415289690439572e-19
Rsub_87_182 sn_87 sn_182 15178376.40940606
Csub_87_182 sn_87 sn_182 6.941772438651955e-19
Rsub_87_119 sn_87 sn_119 1697205.927066248
Csub_87_119 sn_87 sn_119 6.208134990692102e-18
Rsub_87_95 sn_87 sn_95 6733720.580026373
Csub_87_95 sn_87 sn_95 1.564734291690603e-18
Rsub_87_110 sn_87 sn_110 34895546.51715239
Csub_87_110 sn_87 sn_110 3.019435015024324e-19
Rsub_87_213 sn_87 sn_213 16788787.99601845
Csub_87_213 sn_87 sn_213 6.275904791178961e-19
Rsub_87_157 sn_87 sn_157 554284.2303433958
Csub_87_157 sn_87 sn_157 1.900917061216469e-17
Rsub_87_101 sn_87 sn_101 1708298.199771573
Csub_87_101 sn_87 sn_101 6.167824507242879e-18
Rsub_87_212 sn_87 sn_212 1699706.071745409
Csub_87_212 sn_87 sn_212 6.19900327320135e-18
Rsub_225_229 sn_225 sn_229 1301345.658093233
Csub_225_229 sn_225 sn_229 8.096606337218923e-18
Rsub_225_228 sn_225 sn_228 25638985.30485035
Csub_225_228 sn_225 sn_228 4.109555575991037e-19
Rsub_225_226 sn_225 sn_226 2932070.796074845
Csub_225_226 sn_225 sn_226 3.593529704785833e-18
Rsub_225_230 sn_225 0 33136.85273860296
Csub_225_230 sn_225 0 3.179687457148116e-16
Rsub_100_101 sn_100 sn_101 9765956.668774134
Csub_100_101 sn_100 sn_101 1.078899268099311e-18
Rsub_100_210 sn_100 sn_210 31991773.06181926
Csub_100_210 sn_100 sn_210 3.293497825790975e-19
Rsub_100_105 sn_100 sn_105 14063442.29741329
Csub_100_105 sn_100 sn_105 7.49210846064906e-19
Rsub_100_104 sn_100 sn_104 1208519.416938013
Csub_100_104 sn_100 sn_104 8.71850576379315e-18
Rsub_100_189 sn_100 sn_189 23326706.36969449
Csub_100_189 sn_100 sn_189 4.516918649054866e-19
Rsub_100_110 sn_100 sn_110 21575979.69981173
Csub_100_110 sn_100 sn_110 4.88343224679709e-19
Rsub_100_213 sn_100 sn_213 530789.0809477376
Csub_100_213 sn_100 sn_213 1.985060333836717e-17
Rsub_100_107 sn_100 sn_107 16771128.31226022
Csub_100_107 sn_100 sn_107 6.282513201289804e-19
Rsub_100_155 sn_100 sn_155 3460432.705175853
Csub_100_155 sn_100 sn_155 3.044845659466323e-18
Rsub_100_219 sn_100 sn_219 205823089.934378
Csub_100_219 sn_100 sn_219 5.119194112569837e-20
Rsub_100_140 sn_100 sn_140 6594994.696845024
Csub_100_140 sn_100 sn_140 1.597648517787368e-18
Rsub_100_161 sn_100 sn_161 1386341.722229905
Csub_100_161 sn_100 sn_161 7.600206596453189e-18
Rsub_100_152 sn_100 sn_152 883962.0446714355
Csub_100_152 sn_100 sn_152 1.1919610763544e-17
Rsub_100_201 sn_100 sn_201 8946051.107831703
Csub_100_201 sn_100 sn_201 1.177780383235903e-18
Rsub_100_148 sn_100 sn_148 5084489.811956443
Csub_100_148 sn_100 sn_148 2.072279401062602e-18
Rsub_100_211 sn_100 sn_211 27962254.54245896
Csub_100_211 sn_100 sn_211 3.768109429885562e-19
Rsub_100_118 sn_100 sn_118 8917213.756806947
Csub_100_118 sn_100 sn_118 1.181589203711415e-18
Rsub_100_204 sn_100 sn_204 6408441.855232321
Csub_100_204 sn_100 sn_204 1.644156838784024e-18
Rsub_100_194 sn_100 sn_194 4137159.546356646
Csub_100_194 sn_100 sn_194 2.54679167776086e-18
Rsub_100_115 sn_100 sn_115 407761.037452175
Csub_100_115 sn_100 sn_115 2.583984867231409e-17
Rsub_100_214 sn_100 sn_214 2693281.917136672
Csub_100_214 sn_100 sn_214 3.912135389611099e-18
Rsub_100_217 sn_100 sn_217 49067.86058950552
Csub_100_217 sn_100 sn_217 2.147328898314249e-16
Rsub_100_106 sn_100 sn_106 29522.70589677123
Csub_100_106 sn_100 sn_106 3.568942338507777e-16
Rsub_100_111 sn_100 sn_111 103045.6226151608
Csub_100_111 sn_100 sn_111 1.022506656258467e-16
Rsub_100_143 sn_100 sn_143 23331610.11862009
Csub_100_143 sn_100 sn_143 4.515969300301837e-19
Rsub_100_222 sn_100 sn_222 1404972.588532989
Csub_100_222 sn_100 sn_222 7.499422827339097e-18
Rsub_100_109 sn_100 sn_109 47944.82955835286
Csub_100_109 sn_100 sn_109 2.197626646978946e-16
Rsub_100_225 sn_100 sn_225 1084716.0623718
Csub_100_225 sn_100 sn_225 9.713586686631442e-18
Rsub_100_146 sn_100 sn_146 400926.8109619848
Csub_100_146 sn_100 sn_146 2.628031654193626e-17
Rsub_100_139 sn_100 sn_139 23933.06341941329
Csub_100_139 sn_100 sn_139 4.402480082714082e-16
Rsub_100_202 sn_100 sn_202 88178.89182600258
Csub_100_202 sn_100 sn_202 1.194898607142958e-16
Rsub_100_117 sn_100 sn_117 58519.74815147053
Csub_100_117 sn_100 sn_117 1.800500486597742e-16
Rsub_100_137 sn_100 sn_137 399985.3282042961
Csub_100_137 sn_100 sn_137 2.634217497309901e-17
Rsub_100_127 sn_100 sn_127 393397.0777490654
Csub_100_127 sn_100 sn_127 2.6783329359022e-17
Rsub_100_206 sn_100 sn_206 6851938.254598249
Csub_100_206 sn_100 sn_206 1.537737660604151e-18
Rsub_100_144 sn_100 sn_144 55378677.98799336
Csub_100_144 sn_100 sn_144 1.902624599401671e-19
Rsub_100_223 sn_100 sn_223 34111.50344833898
Csub_100_223 sn_100 sn_223 3.088835858022864e-16
Rsub_100_116 sn_100 sn_116 18090854.4674757
Csub_100_116 sn_100 sn_116 5.824204446049143e-19
Rsub_100_195 sn_100 sn_195 1084995.700054288
Csub_100_195 sn_100 sn_195 9.711083188350702e-18
Rsub_100_205 sn_100 sn_205 4602.213051777973
Csub_100_205 sn_100 sn_205 2.289438447044393e-15
Rsub_100_229 sn_100 sn_229 1234.2012634843
Csub_100_229 sn_100 sn_229 8.537086951672883e-15
Rsub_100_220 sn_100 sn_220 156213.1222106135
Csub_100_220 sn_100 sn_220 6.744941368001237e-17
Rsub_100_141 sn_100 sn_141 48787.0969476774
Csub_100_141 sn_100 sn_141 2.159686507588275e-16
Rsub_100_136 sn_100 sn_136 242040.3404217295
Csub_100_136 sn_100 sn_136 4.353193142874985e-17
Rsub_100_215 sn_100 sn_215 508226.6777596631
Csub_100_215 sn_100 sn_215 2.073185836815247e-17
Rsub_100_124 sn_100 sn_124 18925.63762671084
Csub_100_124 sn_100 sn_124 5.567307009703736e-16
Rsub_100_166 sn_100 sn_166 1807703.154676946
Csub_100_166 sn_100 sn_166 5.828658026606683e-18
Rsub_100_129 sn_100 sn_129 10788831.69534657
Csub_100_129 sn_100 sn_129 9.766102391582016e-19
Rsub_100_108 sn_100 sn_108 10842472.02227735
Csub_100_108 sn_100 sn_108 9.717787125095961e-19
Rsub_100_230 sn_100 0 30036.35391867279
Csub_100_230 sn_100 0 3.507910291228708e-16
Rsub_100_193 sn_100 sn_193 3334342.167402239
Csub_100_193 sn_100 sn_193 3.15998867939786e-18
Rsub_100_119 sn_100 sn_119 984177.8758346109
Csub_100_119 sn_100 sn_119 1.070587315661284e-17
Rsub_100_167 sn_100 sn_167 36789706.77533745
Csub_100_167 sn_100 sn_167 2.863975939404142e-19
Rsub_100_209 sn_100 sn_209 383183.7911015192
Csub_100_209 sn_100 sn_209 2.749720564103534e-17
Rsub_100_130 sn_100 sn_130 6311430.07092143
Csub_100_130 sn_100 sn_130 1.66942885904331e-18
Rsub_100_173 sn_100 sn_173 25698189.27000143
Csub_100_173 sn_100 sn_173 4.100087905621304e-19
Rsub_100_163 sn_100 sn_163 489580.4576324685
Csub_100_163 sn_100 sn_163 2.15214544166708e-17
Rsub_100_226 sn_100 sn_226 109023.198638003
Csub_100_226 sn_100 sn_226 9.664441727870223e-17
Rsub_65_170 sn_65 sn_170 1840068.305172417
Csub_65_170 sn_65 sn_170 5.726137161654288e-18
Rsub_65_219 sn_65 sn_219 3891508.491818585
Csub_65_219 sn_65 sn_219 2.707557628200389e-18
Rsub_65_81 sn_65 sn_81 1564040.790914276
Csub_65_81 sn_65 sn_81 6.736706333644145e-18
Rsub_65_181 sn_65 sn_181 365054.9191064278
Csub_65_181 sn_65 sn_181 2.88627353057478e-17
Rsub_65_141 sn_65 sn_141 164525.5616429991
Csub_65_141 sn_65 sn_141 6.404162001946491e-17
Rsub_65_92 sn_65 sn_92 1213889.469528338
Csub_65_92 sn_65 sn_92 8.679936490695479e-18
Rsub_65_211 sn_65 sn_211 1931042.865823317
Csub_65_211 sn_65 sn_211 5.45636955487142e-18
Rsub_65_163 sn_65 sn_163 195904.5262128515
Csub_65_163 sn_65 sn_163 5.378376756227698e-17
Rsub_65_134 sn_65 sn_134 1128497.386910778
Csub_65_134 sn_65 sn_134 9.336737173200958e-18
Rsub_65_173 sn_65 sn_173 1550935.752604685
Csub_65_173 sn_65 sn_173 6.793629900229418e-18
Rsub_65_94 sn_65 sn_94 32146.16884832347
Csub_65_94 sn_65 sn_94 3.277679387532837e-16
Rsub_65_209 sn_65 sn_209 179866.9787552593
Csub_65_209 sn_65 sn_209 5.857930997199181e-17
Rsub_65_172 sn_65 sn_172 962339.5199355183
Csub_65_172 sn_65 sn_172 1.094882137121003e-17
Rsub_65_111 sn_65 sn_111 22019.2597929317
Csub_65_111 sn_65 sn_111 4.785121571440049e-16
Rsub_65_190 sn_65 sn_190 2868400.323139624
Csub_65_190 sn_65 sn_190 3.673296024000316e-18
Rsub_65_117 sn_65 sn_117 283103.6243654689
Csub_65_117 sn_65 sn_117 3.721776266851344e-17
Rsub_65_124 sn_65 sn_124 223005.2213179804
Csub_65_124 sn_65 sn_124 4.724769868597004e-17
Rsub_65_109 sn_65 sn_109 246649.8398377088
Csub_65_109 sn_65 sn_109 4.271838777257191e-17
Rsub_65_66 sn_65 sn_66 29993.35929867169
Csub_65_66 sn_65 sn_66 3.512938779984084e-16
Rsub_65_96 sn_65 sn_96 150898.1191301083
Csub_65_96 sn_65 sn_96 6.982514800694878e-17
Rsub_65_79 sn_65 sn_79 408961.7820163641
Csub_65_79 sn_65 sn_79 2.576398080593359e-17
Rsub_65_167 sn_65 sn_167 523130.8063729082
Csub_65_167 sn_65 sn_167 2.014120249442771e-17
Rsub_65_156 sn_65 sn_156 284703.2275145598
Csub_65_156 sn_65 sn_156 3.700865492187357e-17
Rsub_65_139 sn_65 sn_139 202559.9199989321
Csub_65_139 sn_65 sn_139 5.201662551153037e-17
Rsub_65_223 sn_65 sn_223 4166.434557121584
Csub_65_223 sn_65 sn_223 2.528896916002257e-15
Rsub_65_121 sn_65 sn_121 42134.99881489347
Csub_65_121 sn_65 sn_121 2.500648818935214e-16
Rsub_65_75 sn_65 sn_75 80037.4209720489
Csub_65_75 sn_65 sn_75 1.316444654795862e-16
Rsub_65_154 sn_65 sn_154 2107649.228001279
Csub_65_154 sn_65 sn_154 4.999163694910437e-18
Rsub_65_68 sn_65 sn_68 56244.98944032797
Csub_65_68 sn_65 sn_68 1.873319491580397e-16
Rsub_65_179 sn_65 sn_179 190136.4856926831
Csub_65_179 sn_65 sn_179 5.541536893271541e-17
Rsub_65_100 sn_65 sn_100 241564.9051865083
Csub_65_100 sn_65 sn_100 4.361760866751302e-17
Rsub_65_230 sn_65 0 52045.66917285662
Csub_65_230 sn_65 0 2.02446883087154e-16
Rsub_65_151 sn_65 sn_151 961191.2136164805
Csub_65_151 sn_65 sn_151 1.096190159977274e-17
Rsub_65_119 sn_65 sn_119 6553.004574066196
Csub_65_119 sn_65 sn_119 1.607885876339626e-15
Rsub_65_106 sn_65 sn_106 112506.9982024916
Csub_65_106 sn_65 sn_106 9.365180540384075e-17
Rsub_65_217 sn_65 sn_217 301515.5959507167
Csub_65_217 sn_65 sn_217 3.494506965388354e-17
Rsub_65_69 sn_65 sn_69 16430.11823840174
Csub_65_69 sn_65 sn_69 6.412907898376116e-16
Rsub_65_205 sn_65 sn_205 165488.5614872373
Csub_65_205 sn_65 sn_205 6.366895335568308e-17
Rsub_65_126 sn_65 sn_126 7935256.80599263
Csub_65_126 sn_65 sn_126 1.32780623990303e-18
Rsub_65_202 sn_65 sn_202 45656.57442619212
Csub_65_202 sn_65 sn_202 2.30776917336695e-16
Rsub_65_123 sn_65 sn_123 43978791.61231302
Csub_65_123 sn_65 sn_123 2.395810143014488e-19
Rsub_65_91 sn_65 sn_91 31096.58098296039
Csub_65_91 sn_65 sn_91 3.388309315420736e-16
Rsub_65_71 sn_65 sn_71 18580.61908743072
Csub_65_71 sn_65 sn_71 5.670684842442976e-16
Rsub_65_229 sn_65 sn_229 198458.4839740181
Csub_65_229 sn_65 sn_229 5.309162546867698e-17
Rsub_65_108 sn_65 sn_108 120759.6808026897
Csub_65_108 sn_65 sn_108 8.725166737932718e-17
Rsub_65_113 sn_65 sn_113 147570.2175487009
Csub_65_113 sn_65 sn_113 7.139979649859072e-17
Rsub_65_83 sn_65 sn_83 930.5611930616873
Csub_65_83 sn_65 sn_83 1.132271964572622e-14
Rsub_65_115 sn_65 sn_115 115647.0835675117
Csub_65_115 sn_65 sn_115 9.11089426313036e-17
Rsub_65_87 sn_65 sn_87 215338.1685864526
Csub_65_87 sn_65 sn_87 4.892993922719223e-17
Rsub_65_112 sn_65 sn_112 5023003.009584391
Csub_65_112 sn_65 sn_112 2.097646265018225e-18
Rsub_65_193 sn_65 sn_193 5553618.41045802
Csub_65_193 sn_65 sn_193 1.897228567664777e-18
Rsub_65_114 sn_65 sn_114 6287889.598372047
Csub_65_114 sn_65 sn_114 1.675678832681466e-18
Rsub_65_220 sn_65 sn_220 812207.0134034412
Csub_65_220 sn_65 sn_220 1.297265762096577e-17
Rsub_65_195 sn_65 sn_195 1438942.382629213
Csub_65_195 sn_65 sn_195 7.32238040204077e-18
Rsub_65_122 sn_65 sn_122 345388.4451658403
Csub_65_122 sn_65 sn_122 3.050618412312793e-17
Rsub_65_157 sn_65 sn_157 2188595.395411618
Csub_65_157 sn_65 sn_157 4.814267417504259e-18
Rsub_65_225 sn_65 sn_225 96569.36093183275
Csub_65_225 sn_65 sn_225 1.091079344479414e-16
Rsub_65_98 sn_65 sn_98 587744.3924263394
Csub_65_98 sn_65 sn_98 1.792698261013271e-17
Rsub_65_102 sn_65 sn_102 66314.46646383397
Csub_65_102 sn_65 sn_102 1.58886651195125e-16
Rsub_65_222 sn_65 sn_222 277142.6666602099
Csub_65_222 sn_65 sn_222 3.801826557131396e-17
Rsub_65_143 sn_65 sn_143 5733312.727246341
Csub_65_143 sn_65 sn_143 1.837765355473742e-18
Rsub_65_132 sn_65 sn_132 1544890.867349377
Csub_65_132 sn_65 sn_132 6.8202121747977e-18
Rsub_65_174 sn_65 sn_174 27004509.92846653
Csub_65_174 sn_65 sn_174 3.901749570771908e-19
Rsub_65_128 sn_65 sn_128 998884.6381072662
Csub_65_128 sn_65 sn_128 1.054824861677223e-17
Rsub_65_207 sn_65 sn_207 11207794.99089189
Csub_65_207 sn_65 sn_207 9.401031613080507e-19
Rsub_65_215 sn_65 sn_215 1483989.146524693
Csub_65_215 sn_65 sn_215 7.100108196144869e-18
Rsub_65_136 sn_65 sn_136 2961040.829086306
Csub_65_136 sn_65 sn_136 3.55837156945967e-18
Rsub_65_85 sn_65 sn_85 106452.6236246983
Csub_65_85 sn_65 sn_85 9.897814768170173e-17
Rsub_65_216 sn_65 sn_216 1505369.636837479
Csub_65_216 sn_65 sn_216 6.999266654776785e-18
Rsub_65_176 sn_65 sn_176 883664.1705365812
Csub_65_176 sn_65 sn_176 1.192362874216344e-17
Rsub_65_206 sn_65 sn_206 16332889.17463937
Csub_65_206 sn_65 sn_206 6.451083693502528e-19
Rsub_65_221 sn_65 sn_221 6687230.395739549
Csub_65_221 sn_65 sn_221 1.575612455186653e-18
Rsub_65_107 sn_65 sn_107 10102149.4499965
Csub_65_107 sn_65 sn_107 1.042994221614257e-18
Rsub_223_228 sn_223 sn_228 16162791.76678728
Csub_223_228 sn_223 sn_228 6.5189749730497e-19
Rsub_223_226 sn_223 sn_226 260384350.2434435
Csub_223_226 sn_223 sn_226 4.046511817003991e-20
Rsub_223_225 sn_223 sn_225 122556.9401643247
Csub_223_225 sn_223 sn_225 8.597214884854872e-17
Rsub_223_230 sn_223 0 14029.61998052191
Csub_223_230 sn_223 0 7.510170280348559e-16
Rsub_56_78 sn_56 sn_78 24903427.6045544
Csub_56_78 sn_56 sn_78 4.2309370700052e-19
Rsub_56_110 sn_56 sn_110 15448809.83928796
Csub_56_110 sn_56 sn_110 6.820255807301481e-19
Rsub_56_157 sn_56 sn_157 17024032.98170097
Csub_56_157 sn_56 sn_157 6.189181795850373e-19
Rsub_56_128 sn_56 sn_128 10295271.50866353
Csub_56_128 sn_56 sn_128 1.023429396044921e-18
Rsub_56_75 sn_56 sn_75 23013912.93547928
Csub_56_75 sn_56 sn_75 4.578310316793842e-19
Rsub_56_185 sn_56 sn_185 43851797.52796841
Csub_56_185 sn_56 sn_185 2.40274836978117e-19
Rsub_56_203 sn_56 sn_203 21025019.9276221
Csub_56_203 sn_56 sn_203 5.011402385587019e-19
Rsub_56_133 sn_56 sn_133 65682891.57452922
Csub_56_133 sn_56 sn_133 1.604144283184372e-19
Rsub_56_68 sn_56 sn_68 42446458.02262106
Csub_56_68 sn_56 sn_68 2.482299817952955e-19
Rsub_56_178 sn_56 sn_178 10274934.45000042
Csub_56_178 sn_56 sn_178 1.025455057986241e-18
Rsub_56_183 sn_56 sn_183 39713853.42889009
Csub_56_183 sn_56 sn_183 2.653100264142379e-19
Rsub_56_174 sn_56 sn_174 57780645.23719624
Csub_56_174 sn_56 sn_174 1.823531644372699e-19
Rsub_56_215 sn_56 sn_215 7043676.92500955
Csub_56_215 sn_56 sn_215 1.495878305380356e-18
Rsub_56_151 sn_56 sn_151 8036533.282048263
Csub_56_151 sn_56 sn_151 1.311073211849448e-18
Rsub_56_230 sn_56 0 221968.2244248494
Csub_56_230 sn_56 0 4.746843170697743e-17
Rsub_56_72 sn_56 sn_72 66254761.68713849
Csub_56_72 sn_56 sn_72 1.590298302178538e-19
Rsub_56_74 sn_56 sn_74 14194436.31341155
Csub_56_74 sn_56 sn_74 7.422967189105392e-19
Rsub_56_153 sn_56 sn_153 13128384.41555261
Csub_56_153 sn_56 sn_153 8.025727438136181e-19
Rsub_56_57 sn_56 sn_57 2133529.9197195
Csub_56_57 sn_56 sn_57 4.938521557558121e-18
Rsub_56_224 sn_56 sn_224 380818.1824735201
Csub_56_224 sn_56 sn_224 2.766801583315326e-17
Rsub_56_155 sn_56 sn_155 2753942.968641986
Csub_56_155 sn_56 sn_155 3.825962854788424e-18
Rsub_56_76 sn_56 sn_76 5786081.574181666
Csub_56_76 sn_56 sn_76 1.821005004361728e-18
Rsub_56_212 sn_56 sn_212 6395804.906607474
Csub_56_212 sn_56 sn_212 1.647405394017696e-18
Rsub_56_64 sn_56 sn_64 289201.0973702363
Csub_56_64 sn_56 sn_64 3.64330688854239e-17
Rsub_56_222 sn_56 sn_222 426629.9753991775
Csub_56_222 sn_56 sn_222 2.469700703137774e-17
Rsub_56_191 sn_56 sn_191 33592007.69282761
Csub_56_191 sn_56 sn_191 3.13660427759419e-19
Rsub_56_169 sn_56 sn_169 9124604.094699625
Csub_56_169 sn_56 sn_169 1.154733223806447e-18
Rsub_56_144 sn_56 sn_144 26674266.00722333
Csub_56_144 sn_56 sn_144 3.9500556451588e-19
Rsub_56_218 sn_56 sn_218 965273.5178883566
Csub_56_218 sn_56 sn_218 1.091554187177924e-17
Rsub_56_146 sn_56 sn_146 5753209.675509646
Csub_56_146 sn_56 sn_146 1.831409612460653e-18
Rsub_56_225 sn_56 sn_225 53324826.78623577
Csub_56_225 sn_56 sn_225 1.975905809214871e-19
Rsub_56_208 sn_56 sn_208 167111.7607092045
Csub_56_208 sn_56 sn_208 6.305052054693389e-17
Rsub_56_130 sn_56 sn_130 6859952.799307941
Csub_56_130 sn_56 sn_130 1.53594110782992e-18
Rsub_56_209 sn_56 sn_209 40676771.23810957
Csub_56_209 sn_56 sn_209 2.590294947588785e-19
Rsub_56_214 sn_56 sn_214 6592197.676633528
Csub_56_214 sn_56 sn_214 1.598326388114429e-18
Rsub_56_135 sn_56 sn_135 14187777.93945458
Csub_56_135 sn_56 sn_135 7.426450813646619e-19
Rsub_56_93 sn_56 sn_93 56032.7374822522
Csub_56_93 sn_56 sn_93 1.880415624092492e-16
Rsub_56_221 sn_56 sn_221 4255675.349243328
Csub_56_221 sn_56 sn_221 2.475866375498643e-18
Rsub_56_142 sn_56 sn_142 38568108.13966562
Csub_56_142 sn_56 sn_142 2.731916085713752e-19
Rsub_56_184 sn_56 sn_184 2417678.493090688
Csub_56_184 sn_56 sn_184 4.358099529090187e-18
Rsub_56_166 sn_56 sn_166 664792.0734683094
Csub_56_166 sn_56 sn_166 1.584929171501663e-17
Rsub_56_87 sn_56 sn_87 40000126.29109047
Csub_56_87 sn_56 sn_87 2.634112558933813e-19
Rsub_56_120 sn_56 sn_120 45492.29395574577
Csub_56_120 sn_56 sn_120 2.316102923382966e-16
Rsub_56_186 sn_56 sn_186 55842.76768683677
Csub_56_186 sn_56 sn_186 1.886812552221271e-16
Rsub_56_107 sn_56 sn_107 97854261.79983859
Csub_56_107 sn_56 sn_107 1.076752643005211e-19
Rsub_56_84 sn_56 sn_84 41192.61233294055
Csub_56_84 sn_56 sn_84 2.557857563649654e-16
Rsub_56_162 sn_56 sn_162 4340954.90906845
Csub_56_162 sn_56 sn_162 2.427227124663012e-18
Rsub_56_190 sn_56 sn_190 758995.1299923584
Csub_56_190 sn_56 sn_190 1.38821490229273e-17
Rsub_56_138 sn_56 sn_138 7944429.072072861
Csub_56_138 sn_56 sn_138 1.326273216947586e-18
Rsub_56_217 sn_56 sn_217 28190657.9325744
Csub_56_217 sn_56 sn_217 3.737579849122662e-19
Rsub_56_207 sn_56 sn_207 331069.5965316388
Csub_56_207 sn_56 sn_207 3.182558474898518e-17
Rsub_56_160 sn_56 sn_160 536244.3333182845
Csub_56_160 sn_56 sn_160 1.96486617155097e-17
Rsub_56_123 sn_56 sn_123 76279902.47809081
Csub_56_123 sn_56 sn_123 1.381292209341288e-19
Rsub_56_202 sn_56 sn_202 101008305.6810129
Csub_56_202 sn_56 sn_202 1.043130407068159e-19
Rsub_56_197 sn_56 sn_197 227544.8098318056
Csub_56_197 sn_56 sn_197 4.630509265413814e-17
Rsub_56_216 sn_56 sn_216 1363916.621795824
Csub_56_216 sn_56 sn_216 7.725166871532778e-18
Rsub_56_137 sn_56 sn_137 243236.8185255801
Csub_56_137 sn_56 sn_137 4.331779853929444e-17
Rsub_56_59 sn_56 sn_59 28380.16543915742
Csub_56_59 sn_56 sn_59 3.712622297716535e-16
Rsub_56_226 sn_56 sn_226 636086.8986914947
Csub_56_226 sn_56 sn_226 1.656453469471668e-17
Rsub_56_122 sn_56 sn_122 40000126.29109047
Csub_56_122 sn_56 sn_122 2.634112558933813e-19
Rsub_56_131 sn_56 sn_131 16082830.72306356
Csub_56_131 sn_56 sn_131 6.551386185468068e-19
Rsub_56_210 sn_56 sn_210 27632295.10222613
Csub_56_210 sn_56 sn_210 3.813104725195684e-19
Rsub_56_227 sn_56 sn_227 4046744.292227287
Csub_56_227 sn_56 sn_227 2.603693918211676e-18
Rsub_56_164 sn_56 sn_164 4252154.518591418
Csub_56_164 sn_56 sn_164 2.477916420055297e-18
Rsub_56_85 sn_56 sn_85 50504152.84050645
Csub_56_85 sn_56 sn_85 2.086260814136318e-19
Rsub_56_132 sn_56 sn_132 10669015.51630116
Csub_56_132 sn_56 sn_132 9.875778590940595e-19
Rsub_56_211 sn_56 sn_211 20816570.87697065
Csub_56_211 sn_56 sn_211 5.061584621454874e-19
Rsub_56_181 sn_56 sn_181 105022938.1979168
Csub_56_181 sn_56 sn_181 1.003255449049987e-19
Rsub_56_192 sn_56 sn_192 13035555.03410321
Csub_56_192 sn_56 sn_192 8.082880609736051e-19
Rsub_56_219 sn_56 sn_219 11788035.93251626
Csub_56_219 sn_56 sn_219 8.938285870987242e-19
Rsub_56_61 sn_56 sn_61 53324826.78623577
Csub_56_61 sn_56 sn_61 1.975905809214871e-19
Rsub_56_229 sn_56 sn_229 34658072.23598419
Csub_56_229 sn_56 sn_229 3.040123937213785e-19
Rsub_56_141 sn_56 sn_141 70629463.5873879
Csub_56_141 sn_56 sn_141 1.491797185914275e-19
Rsub_56_220 sn_56 sn_220 81353542.47621915
Csub_56_220 sn_56 sn_220 1.295147473794392e-19
Rsub_56_158 sn_56 sn_158 16725744.38369173
Csub_56_158 sn_56 sn_158 6.29956028295129e-19
Rsub_56_196 sn_56 sn_196 53324826.78623577
Csub_56_196 sn_56 sn_196 1.975905809214871e-19
Rsub_56_198 sn_56 sn_198 2624815.619800663
Csub_56_198 sn_56 sn_198 4.014180433378469e-18
Rsub_56_206 sn_56 sn_206 29047185.17268571
Csub_56_206 sn_56 sn_206 3.627368173401497e-19
Rsub_56_177 sn_56 sn_177 23912388.72602954
Csub_56_177 sn_56 sn_177 4.406286474742961e-19
Rsub_56_171 sn_56 sn_171 14287398.40080334
Csub_56_171 sn_56 sn_171 7.374669066159425e-19
Rsub_56_125 sn_56 sn_125 9461714.348159771
Csub_56_125 sn_56 sn_125 1.11359137620544e-18
Rsub_56_213 sn_56 sn_213 11036537.09518239
Csub_56_213 sn_56 sn_213 9.546910784932108e-19
Rsub_83_157 sn_83 sn_157 323641.8132013364
Csub_83_157 sn_83 sn_157 3.255600195168629e-17
Rsub_83_216 sn_83 sn_216 2800697.865362812
Csub_83_216 sn_83 sn_216 3.762092167290979e-18
Rsub_83_219 sn_83 sn_219 4559590.794921478
Csub_83_219 sn_83 sn_219 2.310839717012687e-18
Rsub_83_166 sn_83 sn_166 4351660.823467065
Csub_83_166 sn_83 sn_166 2.421255683671447e-18
Rsub_83_185 sn_83 sn_185 684911.121335343
Csub_83_185 sn_83 sn_185 1.538372377672515e-17
Rsub_83_212 sn_83 sn_212 3130366.990891657
Csub_83_212 sn_83 sn_212 3.365894009516366e-18
Rsub_83_218 sn_83 sn_218 5238438.040458214
Csub_83_218 sn_83 sn_218 2.011378853935697e-18
Rsub_83_211 sn_83 sn_211 32404063.22803655
Csub_83_211 sn_83 sn_211 3.251593304235271e-19
Rsub_83_134 sn_83 sn_134 1772829.468061058
Csub_83_134 sn_83 sn_134 5.943314736162268e-18
Rsub_83_136 sn_83 sn_136 1969119.473839111
Csub_83_136 sn_83 sn_136 5.350860444078314e-18
Rsub_83_152 sn_83 sn_152 298951.857833992
Csub_83_152 sn_83 sn_152 3.524475003624467e-17
Rsub_83_215 sn_83 sn_215 3405589.181650089
Csub_83_215 sn_83 sn_215 3.093879778278138e-18
Rsub_83_123 sn_83 sn_123 73735788.58317719
Csub_83_123 sn_83 sn_123 1.428951083956251e-19
Rsub_83_196 sn_83 sn_196 12839337.8410277
Csub_83_196 sn_83 sn_196 8.206407240536188e-19
Rsub_83_190 sn_83 sn_190 3815025.365120355
Csub_83_190 sn_83 sn_190 2.761838387383199e-18
Rsub_83_229 sn_83 sn_229 99620.24899254669
Csub_83_229 sn_83 sn_229 1.057664843120229e-16
Rsub_83_150 sn_83 sn_150 2822405.079326583
Csub_83_150 sn_83 sn_150 3.73315778780556e-18
Rsub_83_139 sn_83 sn_139 729215.8053509506
Csub_83_139 sn_83 sn_139 1.444906079231113e-17
Rsub_83_129 sn_83 sn_129 28846442.57172228
Csub_83_129 sn_83 sn_129 3.652611054563363e-19
Rsub_83_92 sn_83 sn_92 476995.8449138934
Csub_83_92 sn_83 sn_92 2.208925636266712e-17
Rsub_83_179 sn_83 sn_179 70528.98055792847
Csub_83_179 sn_83 sn_179 1.493922557632311e-16
Rsub_83_100 sn_83 sn_100 153499.6141310046
Csub_83_100 sn_83 sn_100 6.86417588857104e-17
Rsub_83_189 sn_83 sn_189 8597761.268895881
Csub_83_189 sn_83 sn_189 1.225491517233426e-18
Rsub_83_172 sn_83 sn_172 1484283.768275144
Csub_83_172 sn_83 sn_172 7.098698865698866e-18
Rsub_83_209 sn_83 sn_209 138867.6702537635
Csub_83_209 sn_83 sn_209 7.587427284533456e-17
Rsub_83_130 sn_83 sn_130 3253327.826342879
Csub_83_130 sn_83 sn_130 3.238678689836874e-18
Rsub_83_94 sn_83 sn_94 91609.32525974125
Csub_83_94 sn_83 sn_94 1.150154034248779e-16
Rsub_83_167 sn_83 sn_167 17205.76007320411
Csub_83_167 sn_83 sn_167 6.123811710381396e-16
Rsub_83_88 sn_83 sn_88 20550530.47954977
Csub_83_88 sn_83 sn_88 5.12711022847564e-19
Rsub_83_163 sn_83 sn_163 267385.1276887797
Csub_83_163 sn_83 sn_163 3.94056453075948e-17
Rsub_83_200 sn_83 sn_200 8861527.970125988
Csub_83_200 sn_83 sn_200 1.189014302922772e-18
Rsub_83_223 sn_83 sn_223 2842.406838501583
Csub_83_223 sn_83 sn_223 3.706887894973003e-15
Rsub_83_109 sn_83 sn_109 458358.3844647402
Csub_83_109 sn_83 sn_109 2.298743485304463e-17
Rsub_83_188 sn_83 sn_188 44102750.96523761
Csub_83_188 sn_83 sn_188 2.389076252983629e-19
Rsub_83_106 sn_83 sn_106 47693.36544193947
Csub_83_106 sn_83 sn_106 2.209213672508981e-16
Rsub_83_222 sn_83 sn_222 1453421.803932009
Csub_83_222 sn_83 sn_222 7.249432665538086e-18
Rsub_83_111 sn_83 sn_111 46802.4549751726
Csub_83_111 sn_83 sn_111 2.251267269595006e-16
Rsub_83_205 sn_83 sn_205 119246.3641315985
Csub_83_205 sn_83 sn_205 8.835894980078464e-17
Rsub_83_115 sn_83 sn_115 19965.8399089495
Csub_83_115 sn_83 sn_115 5.277255327238762e-16
Rsub_83_162 sn_83 sn_162 28268198.27989036
Csub_83_162 sn_83 sn_162 3.72732757776272e-19
Rsub_83_230 sn_83 0 15185.39912668037
Csub_83_230 sn_83 0 6.938562111098984e-16
Rsub_83_119 sn_83 sn_119 2621.291063997702
Csub_83_119 sn_83 sn_119 4.019577851137571e-15
Rsub_83_198 sn_83 sn_198 1734265.760561686
Csub_83_198 sn_83 sn_198 6.075472249891791e-18
Rsub_83_122 sn_83 sn_122 112808.3383156279
Csub_83_122 sn_83 sn_122 9.340163732178943e-17
Rsub_83_85 sn_83 sn_85 41174.08001718056
Csub_83_85 sn_83 sn_85 2.559008846787465e-16
Rsub_83_225 sn_83 sn_225 30861.12986594759
Csub_83_225 sn_83 sn_225 3.414159996084926e-16
Rsub_83_146 sn_83 sn_146 6903788.007590416
Csub_83_146 sn_83 sn_146 1.52618873734906e-18
Rsub_83_124 sn_83 sn_124 835448.0304172024
Csub_83_124 sn_83 sn_124 1.261177609930846e-17
Rsub_83_175 sn_83 sn_175 73442.57329076159
Csub_83_175 sn_83 sn_175 1.434656089801717e-16
Rsub_83_96 sn_83 sn_96 317481.1307870987
Csub_83_96 sn_83 sn_96 3.318774717762901e-17
Rsub_83_202 sn_83 sn_202 17425.83410117455
Csub_83_202 sn_83 sn_202 6.046472978598947e-16
Rsub_83_91 sn_83 sn_91 299930.9635236533
Csub_83_91 sn_83 sn_91 3.512969577547157e-17
Rsub_83_113 sn_83 sn_113 85427.50476629188
Csub_83_113 sn_83 sn_113 1.233383034077276e-16
Rsub_83_97 sn_83 sn_97 5088958.575378357
Csub_83_97 sn_83 sn_97 2.070459671888099e-18
Rsub_83_193 sn_83 sn_193 3043987.158272908
Csub_83_193 sn_83 sn_193 3.461408657258651e-18
Rsub_83_87 sn_83 sn_87 63433.93905988046
Csub_83_87 sn_83 sn_87 1.661016745670446e-16
Rsub_83_161 sn_83 sn_161 1005082.267897414
Csub_83_161 sn_83 sn_161 1.048320504576391e-17
Rsub_83_195 sn_83 sn_195 439667.21110746
Csub_83_195 sn_83 sn_195 2.396467882080648e-17
Rsub_83_155 sn_83 sn_155 354296.0665445366
Csub_83_155 sn_83 sn_155 2.9739205419334e-17
Rsub_83_177 sn_83 sn_177 241271.0103843769
Csub_83_177 sn_83 sn_177 4.367073974384232e-17
Rsub_83_133 sn_83 sn_133 94604044.93383747
Csub_83_133 sn_83 sn_133 1.11374556020293e-19
Rsub_83_207 sn_83 sn_207 2251610.074555793
Csub_83_207 sn_83 sn_207 4.679532935696553e-18
Rsub_83_117 sn_83 sn_117 528279.1534033035
Csub_83_117 sn_83 sn_117 1.994491630864363e-17
Rsub_83_102 sn_83 sn_102 183230.4981651358
Csub_83_102 sn_83 sn_102 5.750398327648509e-17
Rsub_83_181 sn_83 sn_181 1004113.112308437
Csub_83_181 sn_83 sn_181 1.049332328506977e-17
Rsub_83_217 sn_83 sn_217 124421.7194155881
Csub_83_217 sn_83 sn_217 8.468363523442792e-17
Rsub_83_138 sn_83 sn_138 1490253.19226858
Csub_83_138 sn_83 sn_138 7.070264004058624e-18
Rsub_83_174 sn_83 sn_174 25624048.07291459
Csub_83_174 sn_83 sn_174 4.111951192195659e-19
Rsub_83_95 sn_83 sn_95 26024105.84572721
Csub_83_95 sn_83 sn_95 4.048739873981086e-19
Rsub_83_182 sn_83 sn_182 52079973.05967455
Csub_83_182 sn_83 sn_182 2.023135359566533e-19
Rsub_83_140 sn_83 sn_140 3759218.473738725
Csub_83_140 sn_83 sn_140 2.802838828292669e-18
Rsub_83_131 sn_83 sn_131 561686.1020950155
Csub_83_131 sn_83 sn_131 1.875866869935058e-17
Rsub_83_153 sn_83 sn_153 3961362.612572781
Csub_83_153 sn_83 sn_153 2.659812931234509e-18
Rsub_83_142 sn_83 sn_142 10711619.38789792
Csub_83_142 sn_83 sn_142 9.836499151691492e-19
Rsub_83_221 sn_83 sn_221 4927720.294832658
Csub_83_221 sn_83 sn_221 2.138206487344431e-18
Rsub_83_206 sn_83 sn_206 2419964.438897468
Csub_83_206 sn_83 sn_206 4.353982782916598e-18
Rsub_83_127 sn_83 sn_127 136132.669077421
Csub_83_127 sn_83 sn_127 7.739864041185968e-17
Rsub_83_199 sn_83 sn_199 57980685.17450421
Csub_83_199 sn_83 sn_199 1.817240253459991e-19
Rsub_83_213 sn_83 sn_213 16496491.77888204
Csub_83_213 sn_83 sn_213 6.387105600063563e-19
Rsub_83_108 sn_83 sn_108 88519.15033412384
Csub_83_108 sn_83 sn_108 1.190305539813595e-16
Rsub_83_165 sn_83 sn_165 445192.2288679729
Csub_83_165 sn_83 sn_165 2.366726734880793e-17
Rsub_83_86 sn_83 sn_86 8525302.436415238
Csub_83_86 sn_83 sn_86 1.23590729839966e-18
Rsub_83_104 sn_83 sn_104 473087.4077216526
Csub_83_104 sn_83 sn_104 2.227174794817047e-17
Rsub_83_101 sn_83 sn_101 13483327.86798132
Csub_83_101 sn_83 sn_101 7.814453230979312e-19
Rsub_205_225 sn_205 sn_225 426473.6749594696
Csub_205_225 sn_205 sn_225 2.47060583592442e-17
Rsub_205_207 sn_205 sn_207 10614004.52779828
Csub_205_207 sn_205 sn_207 9.926963451574518e-19
Rsub_205_219 sn_205 sn_219 299920.1365523336
Csub_205_219 sn_205 sn_219 3.513096394043376e-17
Rsub_205_216 sn_205 sn_216 1036322.452332469
Csub_205_216 sn_205 sn_216 1.016718636030259e-17
Rsub_205_228 sn_205 sn_228 19394645.29589588
Csub_205_228 sn_205 sn_228 5.432676566897377e-19
Rsub_205_227 sn_205 sn_227 3210954.675411703
Csub_205_227 sn_205 sn_227 3.281417698890138e-18
Rsub_205_214 sn_205 sn_214 4934498.436190343
Csub_205_214 sn_205 sn_214 2.135269397382695e-18
Rsub_205_223 sn_205 sn_223 89018.19213875108
Csub_205_223 sn_205 sn_223 1.18363260914207e-16
Rsub_205_222 sn_205 sn_222 5779362.479048308
Csub_205_222 sn_205 sn_222 1.82312210739982e-18
Rsub_205_229 sn_205 sn_229 30695.95152013573
Csub_205_229 sn_205 sn_229 3.432531972601777e-16
Rsub_205_230 sn_205 0 14227.71112167681
Csub_205_230 sn_205 0 7.405606855608001e-16
Rsub_205_209 sn_205 sn_209 14841.4183049608
Csub_205_209 sn_205 sn_209 7.099377758733573e-16
Rsub_205_217 sn_205 sn_217 43818.54072325278
Csub_205_217 sn_205 sn_217 2.404571975314254e-16
Rsub_38_84 sn_38 sn_84 257250373.6288055
Csub_38_84 sn_38 sn_84 4.095808823754488e-20
Rsub_38_71 sn_38 sn_71 9808514.785553116
Csub_38_71 sn_38 sn_71 1.074218037347418e-18
Rsub_38_192 sn_38 sn_192 7505609.286512794
Csub_38_192 sn_38 sn_192 1.403814547229835e-18
Rsub_38_83 sn_38 sn_83 22305117.3374873
Csub_38_83 sn_38 sn_83 4.723796491544012e-19
Rsub_38_75 sn_38 sn_75 16584351.97005845
Csub_38_75 sn_38 sn_75 6.353268141711339e-19
Rsub_38_72 sn_38 sn_72 15300090.54584409
Csub_38_72 sn_38 sn_72 6.886549769531911e-19
Rsub_38_146 sn_38 sn_146 3798633.350304677
Csub_38_146 sn_38 sn_146 2.773756383038363e-18
Rsub_38_201 sn_38 sn_201 23126757.62944241
Csub_38_201 sn_38 sn_201 4.555970910862197e-19
Rsub_38_225 sn_38 sn_225 9998240.974251075
Csub_38_225 sn_38 sn_225 1.053833722288259e-18
Rsub_38_79 sn_38 sn_79 16090511.78126739
Csub_38_79 sn_38 sn_79 6.548258778503614e-19
Rsub_38_223 sn_38 sn_223 988543.7284166734
Csub_38_223 sn_38 sn_223 1.065859121791813e-17
Rsub_38_94 sn_38 sn_94 1954904.420386789
Csub_38_94 sn_38 sn_94 5.389769132623525e-18
Rsub_38_175 sn_38 sn_175 14803082.96907031
Csub_38_175 sn_38 sn_175 7.11776291752537e-19
Rsub_38_89 sn_38 sn_89 5697020.005049938
Csub_38_89 sn_38 sn_89 1.849472793300756e-18
Rsub_38_95 sn_38 sn_95 33146410.13806903
Csub_38_95 sn_38 sn_95 3.178770629561699e-19
Rsub_38_98 sn_38 sn_98 142627088.3270315
Csub_38_98 sn_38 sn_98 7.387435041841957e-20
Rsub_38_164 sn_38 sn_164 22015126.64620902
Csub_38_164 sn_38 sn_164 4.786019935999038e-19
Rsub_38_115 sn_38 sn_115 6995186.34186512
Csub_38_115 sn_38 sn_115 1.506247723405273e-18
Rsub_38_76 sn_38 sn_76 7301081.684217948
Csub_38_76 sn_38 sn_76 1.443140065807744e-18
Rsub_38_148 sn_38 sn_148 16101034.5303429
Csub_38_148 sn_38 sn_148 6.543979197345158e-19
Rsub_38_171 sn_38 sn_171 6102745.516342631
Csub_38_171 sn_38 sn_171 1.726515299386841e-18
Rsub_38_99 sn_38 sn_99 7828222.877804848
Csub_38_99 sn_38 sn_99 1.34596110339472e-18
Rsub_38_116 sn_38 sn_116 18500702.92714237
Csub_38_116 sn_38 sn_116 5.695180093277391e-19
Rsub_38_178 sn_38 sn_178 20951827.44485535
Csub_38_178 sn_38 sn_178 5.028909067699105e-19
Rsub_38_144 sn_38 sn_144 54932676.10348231
Csub_38_144 sn_38 sn_144 1.918072129306307e-19
Rsub_38_47 sn_38 sn_47 4619301.020713449
Csub_38_47 sn_38 sn_47 2.280969232137776e-18
Rsub_38_188 sn_38 sn_188 33242073.70657929
Csub_38_188 sn_38 sn_188 3.169622808502651e-19
Rsub_38_166 sn_38 sn_166 1549607.485197742
Csub_38_166 sn_38 sn_166 6.799453153703285e-18
Rsub_38_142 sn_38 sn_142 3671570.241420213
Csub_38_142 sn_38 sn_142 2.869748584233635e-18
Rsub_38_204 sn_38 sn_204 6837476.605947824
Csub_38_204 sn_38 sn_204 1.540990062483645e-18
Rsub_38_160 sn_38 sn_160 2009757.121927116
Csub_38_160 sn_38 sn_160 5.24266508986259e-18
Rsub_38_74 sn_38 sn_74 7392772.988781034
Csub_38_74 sn_38 sn_74 1.425241045304615e-18
Rsub_38_97 sn_38 sn_97 11007563.32310451
Csub_38_97 sn_38 sn_97 9.572039871998075e-19
Rsub_38_138 sn_38 sn_138 2752949.56244013
Csub_38_138 sn_38 sn_138 3.827343459533195e-18
Rsub_38_62 sn_38 sn_62 3726434.760198996
Csub_38_62 sn_38 sn_62 2.827497106555366e-18
Rsub_38_229 sn_38 sn_229 2775580.023253669
Csub_38_229 sn_38 sn_229 3.796137533040256e-18
Rsub_38_40 sn_38 sn_40 147346252.1848595
Csub_38_40 sn_38 sn_40 7.150832373402351e-20
Rsub_38_123 sn_38 sn_123 14148309.81363126
Csub_38_123 sn_38 sn_123 7.447167641239075e-19
Rsub_38_57 sn_38 sn_57 12244813.18604387
Csub_38_57 sn_38 sn_57 8.604854432764273e-19
Rsub_38_224 sn_38 sn_224 10949232.20682813
Csub_38_224 sn_38 sn_224 9.623034111614936e-19
Rsub_38_189 sn_38 sn_189 20618168.95447954
Csub_38_189 sn_38 sn_189 5.110290601213076e-19
Rsub_38_93 sn_38 sn_93 16986555.77793546
Csub_38_93 sn_38 sn_93 6.20283690229674e-19
Rsub_38_122 sn_38 sn_122 21966794.86432931
Csub_38_122 sn_38 sn_122 4.796550232887925e-19
Rsub_38_69 sn_38 sn_69 3179174.293164127
Csub_38_69 sn_38 sn_69 3.314220149831228e-18
Rsub_38_128 sn_38 sn_128 38296012.37854219
Csub_38_128 sn_38 sn_128 2.75132653449155e-19
Rsub_38_152 sn_38 sn_152 102776019.4253598
Csub_38_152 sn_38 sn_152 1.025188907017559e-19
Rsub_38_134 sn_38 sn_134 2947720.993337198
Csub_38_134 sn_38 sn_134 3.574450745523697e-18
Rsub_38_137 sn_38 sn_137 10205214.94914974
Csub_38_137 sn_38 sn_137 1.03246071295224e-18
Rsub_38_41 sn_38 sn_41 7755060.468162149
Csub_38_41 sn_38 sn_41 1.358659103366993e-18
Rsub_38_208 sn_38 sn_208 5804210.701547358
Csub_38_208 sn_38 sn_208 1.815317197120541e-18
Rsub_38_170 sn_38 sn_170 1706360.317216723
Csub_38_170 sn_38 sn_170 6.174829193998288e-18
Rsub_38_111 sn_38 sn_111 36118162.01986363
Csub_38_111 sn_38 sn_111 2.917225825731479e-19
Rsub_38_162 sn_38 sn_162 2279424.411717509
Csub_38_162 sn_38 sn_162 4.622431631453369e-18
Rsub_38_127 sn_38 sn_127 1373750.918242504
Csub_38_127 sn_38 sn_127 7.66986457465649e-18
Rsub_38_101 sn_38 sn_101 11907998.60881096
Csub_38_101 sn_38 sn_101 8.848240454473899e-19
Rsub_38_145 sn_38 sn_145 102608404.347674
Csub_38_145 sn_38 sn_145 1.026863595551942e-19
Rsub_38_161 sn_38 sn_161 4459469.97301523
Csub_38_161 sn_38 sn_161 2.362721033214145e-18
Rsub_38_133 sn_38 sn_133 10416138.23337956
Csub_38_133 sn_38 sn_133 1.01155373192579e-18
Rsub_38_180 sn_38 sn_180 34928.91868519651
Csub_38_180 sn_38 sn_180 3.016550153525235e-16
Rsub_38_184 sn_38 sn_184 4285032.908152847
Csub_38_184 sn_38 sn_184 2.45890375361714e-18
Rsub_38_86 sn_38 sn_86 1108200.73897509
Csub_38_86 sn_38 sn_86 9.507739105078177e-18
Rsub_38_165 sn_38 sn_165 1895898.597623317
Csub_38_165 sn_38 sn_165 5.557514265498403e-18
Rsub_38_114 sn_38 sn_114 16557087.54904858
Csub_38_114 sn_38 sn_114 6.363730016536307e-19
Rsub_38_135 sn_38 sn_135 21580.04012383631
Csub_38_135 sn_38 sn_135 4.882513397457446e-16
Rsub_38_91 sn_38 sn_91 11239342.57184243
Csub_38_91 sn_38 sn_91 9.374643965943989e-19
Rsub_38_176 sn_38 sn_176 37297.49659707028
Csub_38_176 sn_38 sn_176 2.824984104444598e-16
Rsub_38_125 sn_38 sn_125 1267494.934074873
Csub_38_125 sn_38 sn_125 8.312840721466423e-18
Rsub_38_213 sn_38 sn_213 6308210.717072991
Csub_38_213 sn_38 sn_213 1.670280841081182e-18
Rsub_38_46 sn_38 sn_46 16851487.48958907
Csub_38_46 sn_38 sn_46 6.252553971119459e-19
Rsub_38_39 sn_38 sn_39 16303374.5795791
Csub_38_39 sn_38 sn_39 6.462762326167457e-19
Rsub_38_206 sn_38 sn_206 10383815.96469883
Csub_38_206 sn_38 sn_206 1.014702450240854e-18
Rsub_38_132 sn_38 sn_132 806809.4843668304
Csub_38_132 sn_38 sn_132 1.305944427574354e-17
Rsub_38_90 sn_38 sn_90 3337880.334040898
Csub_38_90 sn_38 sn_90 3.156639078631781e-18
Rsub_38_141 sn_38 sn_141 22597.57207941547
Csub_38_141 sn_38 sn_141 4.662661751979927e-16
Rsub_38_53 sn_38 sn_53 32451943.75357583
Csub_38_53 sn_38 sn_53 3.246795810518747e-19
Rsub_38_220 sn_38 sn_220 6243542.717211042
Csub_38_220 sn_38 sn_220 1.687580910303533e-18
Rsub_38_118 sn_38 sn_118 206108.2501659415
Csub_38_118 sn_38 sn_118 5.112111472367984e-17
Rsub_38_43 sn_38 sn_43 11789186.1673636
Csub_38_43 sn_38 sn_43 8.937413789764814e-19
Rsub_38_210 sn_38 sn_210 292080.7342161288
Csub_38_210 sn_38 sn_210 3.607387365177395e-17
Rsub_38_131 sn_38 sn_131 892945.8050465757
Csub_38_131 sn_38 sn_131 1.179968979380604e-17
Rsub_38_126 sn_38 sn_126 220673.8719516845
Csub_38_126 sn_38 sn_126 4.774685561567939e-17
Rsub_38_191 sn_38 sn_191 587085.2613890751
Csub_38_191 sn_38 sn_191 1.794710955151577e-17
Rsub_38_112 sn_38 sn_112 11422.71710892472
Csub_38_112 sn_38 sn_112 9.224148161734397e-16
Rsub_38_117 sn_38 sn_117 3566267.37287286
Csub_38_117 sn_38 sn_117 2.954485012082024e-18
Rsub_38_205 sn_38 sn_205 10799382.04412236
Csub_38_205 sn_38 sn_205 9.756561495076059e-19
Rsub_38_196 sn_38 sn_196 8784557.939568229
Csub_38_196 sn_38 sn_196 1.199432410226425e-18
Rsub_38_80 sn_38 sn_80 439521.9017925434
Csub_38_80 sn_38 sn_80 2.397260172760009e-17
Rsub_38_159 sn_38 sn_159 1730009.874754407
Csub_38_159 sn_38 sn_159 6.090418127657083e-18
Rsub_38_61 sn_38 sn_61 14065798.63625259
Csub_38_61 sn_38 sn_61 7.49085336333034e-19
Rsub_38_70 sn_38 sn_70 438853.5185521999
Csub_38_70 sn_38 sn_70 2.400911250977409e-17
Rsub_38_150 sn_38 sn_150 771665.9399178198
Csub_38_150 sn_38 sn_150 1.365420314307523e-17
Rsub_38_181 sn_38 sn_181 18658.35762885406
Csub_38_181 sn_38 sn_181 5.647058391643186e-16
Rsub_38_151 sn_38 sn_151 2959961.493507376
Csub_38_151 sn_38 sn_151 3.559669112365681e-18
Rsub_38_82 sn_38 sn_82 1757415.445976907
Csub_38_82 sn_38 sn_82 5.995442640697294e-18
Rsub_38_212 sn_38 sn_212 71313544.16351573
Csub_38_212 sn_38 sn_212 1.477487008368391e-19
Rsub_38_45 sn_38 sn_45 752859.2284428393
Csub_38_45 sn_38 sn_45 1.399529035995603e-17
Rsub_38_55 sn_38 sn_55 5424149.490936359
Csub_38_55 sn_38 sn_55 1.942513479732859e-18
Rsub_38_222 sn_38 sn_222 255717.7022924051
Csub_38_222 sn_38 sn_222 4.120357491004618e-17
Rsub_38_190 sn_38 sn_190 866949.5601833666
Csub_38_190 sn_38 sn_190 1.215351386763661e-17
Rsub_38_153 sn_38 sn_153 1028969.177963288
Csub_38_153 sn_38 sn_153 1.023984364923895e-17
Rsub_38_177 sn_38 sn_177 95224.19217168695
Csub_38_177 sn_38 sn_177 1.106492295910788e-16
Rsub_38_140 sn_38 sn_140 56154.09993941241
Csub_38_140 sn_38 sn_140 1.876351595626742e-16
Rsub_38_52 sn_38 sn_52 55380.88514079484
Csub_38_52 sn_38 sn_52 1.902548772097646e-16
Rsub_38_219 sn_38 sn_219 680608.9989898333
Csub_38_219 sn_38 sn_219 1.54809641333987e-17
Rsub_38_168 sn_38 sn_168 856303.9689727701
Csub_38_168 sn_38 sn_168 1.230460663970723e-17
Rsub_38_77 sn_38 sn_77 1428194.66960269
Csub_38_77 sn_38 sn_77 7.377484124878545e-18
Rsub_38_156 sn_38 sn_156 4576863.546816505
Csub_38_156 sn_38 sn_156 2.302118775107198e-18
Rsub_38_195 sn_38 sn_195 156483.9288931757
Csub_38_195 sn_38 sn_195 6.733268762329434e-17
Rsub_38_221 sn_38 sn_221 9072870.524919551
Csub_38_221 sn_38 sn_221 1.161317520545509e-18
Rsub_38_230 sn_38 0 65976.22133715419
Csub_38_230 sn_38 0 1.597012270282359e-16
Rsub_38_63 sn_38 sn_63 2405353.085343563
Csub_38_63 sn_38 sn_63 4.380431116924793e-18
Rsub_38_227 sn_38 sn_227 290627.5664123383
Csub_38_227 sn_38 sn_227 3.62542467402455e-17
Rsub_38_129 sn_38 sn_129 12094918.22254288
Csub_38_129 sn_38 sn_129 8.711496273361965e-19
Rsub_38_154 sn_38 sn_154 2549448.940986652
Csub_38_154 sn_38 sn_154 4.132847429434032e-18
Rsub_38_185 sn_38 sn_185 5257060.562356164
Csub_38_185 sn_38 sn_185 2.004253779703016e-18
Rsub_38_48 sn_38 sn_48 6688555.983063943
Csub_38_48 sn_38 sn_48 1.575300188696839e-18
Rsub_38_136 sn_38 sn_136 15317823.06135273
Csub_38_136 sn_38 sn_136 6.878577628183881e-19
Rsub_38_66 sn_38 sn_66 2964107.594745903
Csub_38_66 sn_38 sn_66 3.554689958254783e-18
Rsub_38_107 sn_38 sn_107 496033.3655532738
Csub_38_107 sn_38 sn_107 2.124148138800632e-17
Rsub_38_130 sn_38 sn_130 4814575.051165759
Csub_38_130 sn_38 sn_130 2.188455552204714e-18
Rsub_38_42 sn_38 sn_42 77693339.37163776
Csub_38_42 sn_38 sn_42 1.356163036297083e-19
Rsub_38_226 sn_38 sn_226 1739672.720678278
Csub_38_226 sn_38 sn_226 6.056589482027371e-18
Rsub_38_50 sn_38 sn_50 13057237.66339079
Csub_38_50 sn_38 sn_50 8.069458314120793e-19
Rsub_38_155 sn_38 sn_155 146134.2914315719
Csub_38_155 sn_38 sn_155 7.210137606315191e-17
Rsub_38_87 sn_38 sn_87 10399235.21152219
Csub_38_87 sn_38 sn_87 1.013197921569823e-18
Rsub_38_183 sn_38 sn_183 8700479.476174612
Csub_38_183 sn_38 sn_183 1.211023315563596e-18
Rsub_38_157 sn_38 sn_157 1484229.126702721
Csub_38_157 sn_38 sn_157 7.098960202753369e-18
Rsub_38_139 sn_38 sn_139 1625820.901105852
Csub_38_139 sn_38 sn_139 6.480715984806992e-18
Rsub_38_49 sn_38 sn_49 11273112.48523781
Csub_38_49 sn_38 sn_49 9.346561134759878e-19
Rsub_38_216 sn_38 sn_216 684356.8145865392
Csub_38_216 sn_38 sn_216 1.539618409235206e-17
Rsub_38_163 sn_38 sn_163 8533350.958591653
Csub_38_163 sn_38 sn_163 1.234741610108222e-18
Rsub_38_158 sn_38 sn_158 1230678.978826712
Csub_38_158 sn_38 sn_158 8.561520659331591e-18
Rsub_38_211 sn_38 sn_211 4083638.79488687
Csub_38_211 sn_38 sn_211 2.580170292098985e-18
Rsub_38_44 sn_38 sn_44 610652.0526649033
Csub_38_44 sn_38 sn_44 1.725447979131239e-17
Rsub_38_100 sn_38 sn_100 10335793.38996573
Csub_38_100 sn_38 sn_100 1.019417001162108e-18
Rsub_45_175 sn_45 sn_175 2844139.563476814
Csub_45_175 sn_45 sn_175 3.704629560917078e-18
Rsub_45_98 sn_45 sn_98 1422069.781738407
Csub_45_98 sn_45 sn_98 7.409259121834157e-18
Rsub_45_79 sn_45 sn_79 521677.4440968721
Csub_45_79 sn_45 sn_79 2.019731468449965e-17
Rsub_45_81 sn_45 sn_81 468401.2070543626
Csub_45_81 sn_45 sn_81 2.249456949201913e-17
Rsub_45_87 sn_45 sn_87 979302.9198294751
Csub_45_87 sn_45 sn_87 1.075916684090425e-17
Rsub_45_53 sn_45 sn_53 1143232.569632837
Csub_45_53 sn_45 sn_53 9.21639549301322e-18
Rsub_45_134 sn_45 sn_134 880667.445467287
Csub_45_134 sn_45 sn_134 1.196420232910879e-17
Rsub_45_115 sn_45 sn_115 877773.8545578719
Csub_45_115 sn_45 sn_115 1.200364245018114e-17
Rsub_45_77 sn_45 sn_77 1087465.127211723
Csub_45_77 sn_45 sn_77 9.68903115932159e-18
Rsub_45_153 sn_45 sn_153 753835.3745701053
Csub_45_153 sn_45 sn_153 1.397716777119767e-17
Rsub_45_130 sn_45 sn_130 736897.4976838045
Csub_45_130 sn_45 sn_130 1.429843843322576e-17
Rsub_45_217 sn_45 sn_217 439297.6631548397
Csub_45_217 sn_45 sn_217 2.398483849552415e-17
Rsub_45_50 sn_45 sn_50 61174931.1931508
Csub_45_50 sn_45 sn_50 1.722353143146596e-19
Rsub_45_170 sn_45 sn_170 1069992.621304784
Csub_45_170 sn_45 sn_170 9.847248749604898e-18
Rsub_45_78 sn_45 sn_78 12189505.52181803
Csub_45_78 sn_45 sn_78 8.643897394665203e-19
Rsub_45_132 sn_45 sn_132 318231.962962404
Csub_45_132 sn_45 sn_132 3.310944445726461e-17
Rsub_45_204 sn_45 sn_204 2348704.688528363
Csub_45_204 sn_45 sn_204 4.486082713460195e-18
Rsub_45_82 sn_45 sn_82 14830205.75070749
Csub_45_82 sn_45 sn_82 7.104745328113434e-19
Rsub_45_58 sn_45 sn_58 12219577.31886294
Csub_45_58 sn_45 sn_58 8.622625175393907e-19
Rsub_45_97 sn_45 sn_97 7118996.125294069
Csub_45_97 sn_45 sn_97 1.480051866413225e-18
Rsub_45_181 sn_45 sn_181 300739.0328473862
Csub_45_181 sn_45 sn_181 3.503530420534694e-17
Rsub_45_118 sn_45 sn_118 379681.5352859912
Csub_45_118 sn_45 sn_118 2.775084517684935e-17
Rsub_45_177 sn_45 sn_177 424922.1417911866
Csub_45_177 sn_45 sn_177 2.47962684594765e-17
Rsub_45_101 sn_45 sn_101 690653.8024787226
Csub_45_101 sn_45 sn_101 1.525581045730159e-17
Rsub_45_180 sn_45 sn_180 6653990.422371513
Csub_45_180 sn_45 sn_180 1.583483418732477e-18
Rsub_45_154 sn_45 sn_154 240419.5644614184
Csub_45_154 sn_45 sn_154 4.382539967507867e-17
Rsub_45_201 sn_45 sn_201 3477802.655984015
Csub_45_201 sn_45 sn_201 3.029638120524349e-18
Rsub_45_203 sn_45 sn_203 451829.5375424721
Csub_45_203 sn_45 sn_203 2.331959871313098e-17
Rsub_45_95 sn_45 sn_95 7818934.762884094
Csub_45_95 sn_45 sn_95 1.347559970988108e-18
Rsub_45_211 sn_45 sn_211 407746.1768753609
Csub_45_211 sn_45 sn_211 2.58407904225446e-17
Rsub_45_210 sn_45 sn_210 2244868.091905131
Csub_45_210 sn_45 sn_210 4.693586915072637e-18
Rsub_45_86 sn_45 sn_86 10297598.53036622
Csub_45_86 sn_45 sn_86 1.023198124413119e-18
Rsub_45_66 sn_45 sn_66 231766.1192768765
Csub_45_66 sn_45 sn_66 4.546170741048965e-17
Rsub_45_60 sn_45 sn_60 12239562.88898566
Csub_45_60 sn_45 sn_60 8.608545581077694e-19
Rsub_45_227 sn_45 sn_227 162377.7241580745
Csub_45_227 sn_45 sn_227 6.488872508135875e-17
Rsub_45_128 sn_45 sn_128 88577.42181982209
Csub_45_128 sn_45 sn_128 1.189522486177411e-16
Rsub_45_64 sn_45 sn_64 523571.4525262112
Csub_45_64 sn_45 sn_64 2.012425133454449e-17
Rsub_45_56 sn_45 sn_56 520347.7004463924
Csub_45_56 sn_45 sn_56 2.024892873205942e-17
Rsub_45_138 sn_45 sn_138 305969.9153921322
Csub_45_138 sn_45 sn_138 3.443633825478038e-17
Rsub_45_107 sn_45 sn_107 9248122.295562169
Csub_45_107 sn_45 sn_107 1.139310571972656e-18
Rsub_45_61 sn_45 sn_61 14065798.63625259
Csub_45_61 sn_45 sn_61 7.49085336333034e-19
Rsub_45_228 sn_45 sn_228 7104848.892366611
Csub_45_228 sn_45 sn_228 1.48299895773298e-18
Rsub_45_200 sn_45 sn_200 242778.8277368235
Csub_45_200 sn_45 sn_200 4.339951551974595e-17
Rsub_45_206 sn_45 sn_206 1289641.319840739
Csub_45_206 sn_45 sn_206 8.170088333964964e-18
Rsub_45_186 sn_45 sn_186 350620.4780421777
Csub_45_186 sn_45 sn_186 3.005096439621682e-17
Rsub_45_155 sn_45 sn_155 58796.24387460287
Csub_45_155 sn_45 sn_155 1.792033437493318e-16
Rsub_45_76 sn_45 sn_76 29171956.11726462
Csub_45_76 sn_45 sn_76 3.611853610322097e-19
Rsub_45_160 sn_45 sn_160 46311.28999775989
Csub_45_160 sn_45 sn_160 2.275143599485063e-16
Rsub_45_123 sn_45 sn_123 589764.3217336221
Csub_45_123 sn_45 sn_123 1.786558310488812e-17
Rsub_45_202 sn_45 sn_202 1477837.224159521
Csub_45_202 sn_45 sn_202 7.12966443799136e-18
Rsub_45_48 sn_45 sn_48 406833.6347824491
Csub_45_48 sn_45 sn_48 2.589875222058348e-17
Rsub_45_215 sn_45 sn_215 253762.0434872317
Csub_45_215 sn_45 sn_215 4.152111701748711e-17
Rsub_45_166 sn_45 sn_166 171070.4776135431
Csub_45_166 sn_45 sn_166 6.159147767174914e-17
Rsub_45_51 sn_45 sn_51 6654595.910809551
Csub_45_51 sn_45 sn_51 1.583339340727634e-18
Rsub_45_218 sn_45 sn_218 85790.11088860747
Csub_45_218 sn_45 sn_218 1.228169936265836e-16
Rsub_45_139 sn_45 sn_139 541967.518565327
Csub_45_139 sn_45 sn_139 1.944117154865983e-17
Rsub_45_88 sn_45 sn_88 1564600.490558
Csub_45_88 sn_45 sn_88 6.734296432741282e-18
Rsub_45_199 sn_45 sn_199 29040849.57356309
Csub_45_199 sn_45 sn_199 3.628159525960196e-19
Rsub_45_120 sn_45 sn_120 148608.313391573
Csub_45_120 sn_45 sn_120 7.090103683814156e-17
Rsub_45_198 sn_45 sn_198 680039.1966870659
Csub_45_198 sn_45 sn_198 1.549393557542034e-17
Rsub_45_116 sn_45 sn_116 203603.2182566752
Csub_45_116 sn_45 sn_116 5.17500832867339e-17
Rsub_45_195 sn_45 sn_195 170983.9644525898
Csub_45_195 sn_45 sn_195 6.162264125740015e-17
Rsub_45_93 sn_45 sn_93 103987.1357708756
Csub_45_93 sn_45 sn_93 1.01324874698405e-16
Rsub_45_55 sn_45 sn_55 48383458.95848569
Csub_45_55 sn_45 sn_55 2.177703646874562e-19
Rsub_45_222 sn_45 sn_222 61794.47077266176
Csub_45_222 sn_45 sn_222 1.705085158993126e-16
Rsub_45_72 sn_45 sn_72 12962837.98044036
Csub_45_72 sn_45 sn_72 8.128222784338207e-19
Rsub_45_146 sn_45 sn_146 113480.8788323864
Csub_45_146 sn_45 sn_146 9.28480957377199e-17
Rsub_45_207 sn_45 sn_207 10260.59754370637
Csub_45_207 sn_45 sn_207 1.026887903686745e-15
Rsub_45_216 sn_45 sn_216 196898.0275103548
Csub_45_216 sn_45 sn_216 5.351238727709392e-17
Rsub_45_49 sn_45 sn_49 3219036.232371918
Csub_45_49 sn_45 sn_49 3.27317953003166e-18
Rsub_45_57 sn_45 sn_57 54091.12085998621
Csub_45_57 sn_45 sn_57 1.947913693543804e-16
Rsub_45_224 sn_45 sn_224 6035.858165942076
Csub_45_224 sn_45 sn_224 1.745647961326054e-15
Rsub_45_219 sn_45 sn_219 1871887.490301167
Csub_45_219 sn_45 sn_219 5.628801707807123e-18
Rsub_45_52 sn_45 sn_52 14472.92798398457
Csub_45_52 sn_45 sn_52 7.280132613034104e-16
Rsub_45_131 sn_45 sn_131 696190.6194259934
Csub_45_131 sn_45 sn_131 1.513448071293648e-17
Rsub_45_135 sn_45 sn_135 488399.5630289505
Csub_45_135 sn_45 sn_135 2.157349084607072e-17
Rsub_45_114 sn_45 sn_114 1270277.561921319
Csub_45_114 sn_45 sn_114 8.29463088861726e-18
Rsub_45_121 sn_45 sn_121 12856253.98000351
Csub_45_121 sn_45 sn_121 8.195609326494591e-19
Rsub_45_84 sn_45 sn_84 105513.3730960198
Csub_45_84 sn_45 sn_84 9.985922346204913e-17
Rsub_45_59 sn_45 sn_59 168405.5535636535
Csub_45_59 sn_45 sn_59 6.256612848724995e-17
Rsub_45_226 sn_45 sn_226 18411.43049168603
Csub_45_226 sn_45 sn_226 5.722794601423238e-16
Rsub_45_171 sn_45 sn_171 279825.9986744226
Csub_45_171 sn_45 sn_171 3.765369748394677e-17
Rsub_45_208 sn_45 sn_208 57056.48418178881
Csub_45_208 sn_45 sn_208 1.846675913058277e-16
Rsub_45_129 sn_45 sn_129 1235670.726179207
Csub_45_129 sn_45 sn_129 8.526934626678139e-18
Rsub_45_230 sn_45 0 12299.98444759937
Csub_45_230 sn_45 0 8.566257581152018e-16
Rsub_45_63 sn_45 sn_63 28710799.96279209
Csub_45_63 sn_45 sn_63 3.66986761632724e-19
Rsub_45_54 sn_45 sn_54 5790519.129020912
Csub_45_54 sn_45 sn_54 1.819609480162715e-18
Rsub_45_221 sn_45 sn_221 141836.3994361614
Csub_45_221 sn_45 sn_221 7.428617438200216e-17
Rsub_45_142 sn_45 sn_142 609051.1301640286
Csub_45_142 sn_45 sn_142 1.729983408682344e-17
Rsub_45_190 sn_45 sn_190 122888.0278117713
Csub_45_190 sn_45 sn_190 8.574052078017584e-17
Rsub_45_212 sn_45 sn_212 231023.8850537911
Csub_45_212 sn_45 sn_212 4.560776691889114e-17
Rsub_45_133 sn_45 sn_133 769461.4005333278
Csub_45_133 sn_45 sn_133 1.369332301129981e-17
Rsub_45_196 sn_45 sn_196 1951553.366715348
Csub_45_196 sn_45 sn_196 5.399024019498845e-18
Rsub_45_173 sn_45 sn_173 25325853.70496933
Csub_45_173 sn_45 sn_173 4.16036656650298e-19
Rsub_45_192 sn_45 sn_192 264880.5703005745
Csub_45_192 sn_45 sn_192 3.977824228584859e-17
Rsub_45_188 sn_45 sn_188 10422102.19620486
Csub_45_188 sn_45 sn_188 1.010974878567856e-18
Rsub_45_80 sn_45 sn_80 1833957.429048392
Csub_45_80 sn_45 sn_80 5.745217056481617e-18
Rsub_45_74 sn_45 sn_74 649569.6764923675
Csub_45_74 sn_45 sn_74 1.622071331766332e-17
Rsub_45_70 sn_45 sn_70 145314054.529717
Csub_45_70 sn_45 sn_70 7.250835809605238e-20
Rsub_45_90 sn_45 sn_90 38424542.30225821
Csub_45_90 sn_45 sn_90 2.742123359426658e-19
Rsub_45_185 sn_45 sn_185 514032.105331736
Csub_45_185 sn_45 sn_185 2.04977148176964e-17
Rsub_45_191 sn_45 sn_191 51640651.68195156
Csub_45_191 sn_45 sn_191 2.040346734414374e-19
Rsub_45_174 sn_45 sn_174 3608063.542328215
Csub_45_174 sn_45 sn_174 2.920259961782992e-18
Rsub_45_164 sn_45 sn_164 1570415.168355305
Csub_45_164 sn_45 sn_164 6.709361775500968e-18
Rsub_45_99 sn_45 sn_99 5905852.136385927
Csub_45_99 sn_45 sn_99 1.784075059603131e-18
Rsub_45_197 sn_45 sn_197 103423.1843267881
Csub_45_197 sn_45 sn_197 1.018773843680706e-16
Rsub_45_213 sn_45 sn_213 580668.3928681327
Csub_45_213 sn_45 sn_213 1.814544003365926e-17
Rsub_45_46 sn_45 sn_46 1851719.074359271
Csub_45_46 sn_45 sn_46 5.690109071148291e-18
Rsub_45_182 sn_45 sn_182 1526198.494771866
Csub_45_182 sn_45 sn_182 6.903743869702203e-18
Rsub_45_103 sn_45 sn_103 23736722.67110327
Csub_45_103 sn_45 sn_103 4.438895650517482e-19
Rsub_45_110 sn_45 sn_110 3586481.866775617
Csub_45_110 sn_45 sn_110 2.93783264313635e-18
Rsub_45_148 sn_45 sn_148 1469272.788537386
Csub_45_148 sn_45 sn_148 7.1712234681204e-18
Rsub_45_214 sn_45 sn_214 411855.3247196868
Csub_45_214 sn_45 sn_214 2.558297263584305e-17
Rsub_45_47 sn_45 sn_47 3435840.739196095
Csub_45_47 sn_45 sn_47 3.066639085458684e-18
Rsub_45_152 sn_45 sn_152 554945.9628225252
Csub_45_152 sn_45 sn_152 1.898650356629341e-17
Rsub_45_140 sn_45 sn_140 2036458.717481937
Csub_45_140 sn_45 sn_140 5.173924426643065e-18
Rsub_45_150 sn_45 sn_150 791926.0201025534
Csub_45_150 sn_45 sn_150 1.330488358100109e-17
Rsub_45_144 sn_45 sn_144 2593713.460722279
Csub_45_144 sn_45 sn_144 4.062315927255848e-18
Rsub_45_158 sn_45 sn_158 114560.818176331
Csub_45_158 sn_45 sn_158 9.197283739727082e-17
Rsub_45_141 sn_45 sn_141 127356.6100854747
Csub_45_141 sn_45 sn_141 8.273212905995607e-17
Rsub_212_223 sn_212 sn_223 208319.8571598971
Csub_212_223 sn_212 sn_223 5.057839250601378e-17
Rsub_212_217 sn_212 sn_217 1267454.391918823
Csub_212_217 sn_212 sn_217 8.313106624908704e-18
Rsub_212_220 sn_212 sn_220 7149476.901537732
Csub_212_220 sn_212 sn_220 1.473741876131355e-18
Rsub_212_215 sn_212 sn_215 50763.66018191031
Csub_212_215 sn_212 sn_215 2.075595704579373e-16
Rsub_212_230 sn_212 0 18137.65585814124
Csub_212_230 sn_212 0 5.809175995309567e-16
Rsub_212_213 sn_212 sn_213 301299.7006616184
Csub_212_213 sn_212 sn_213 3.49701094262395e-17
Rsub_212_221 sn_212 sn_221 25666.5634988847
Csub_212_221 sn_212 sn_221 4.105139943135686e-16
Rsub_212_227 sn_212 sn_227 4982.519201162352
Csub_212_227 sn_212 sn_227 2.114689994525658e-15
Rsub_212_226 sn_212 sn_226 51246.90316199062
Csub_212_226 sn_212 sn_226 2.056023457441779e-16
Rsub_212_229 sn_212 sn_229 3462862.784609707
Csub_212_229 sn_212 sn_229 3.042708925418063e-18
Rsub_212_214 sn_212 sn_214 67566.39286868191
Csub_212_214 sn_212 sn_214 1.559426669810255e-16
Rsub_212_222 sn_212 sn_222 24089.35919063294
Csub_212_222 sn_212 sn_222 4.373916059306e-16
Rsub_212_224 sn_212 sn_224 675550.0232637227
Csub_212_224 sn_212 sn_224 1.559689606896327e-17
Rsub_212_218 sn_212 sn_218 136275.3777989917
Csub_212_218 sn_212 sn_218 7.731758790477525e-17
Rsub_212_225 sn_212 sn_225 2771209.402655722
Csub_212_225 sn_212 sn_225 3.80212462188264e-18
Rsub_212_216 sn_212 sn_216 799380.7633823552
Csub_212_216 sn_212 sn_216 1.318080692566059e-17
Rsub_212_228 sn_212 sn_228 88805492.23619007
Csub_212_228 sn_212 sn_228 1.186467552503039e-19
Rsub_212_219 sn_212 sn_219 548591.5340861881
Csub_212_219 sn_212 sn_219 1.920642745568624e-17
Rsub_187_228 sn_187 sn_228 268460.3571016611
Csub_187_228 sn_187 sn_228 3.92478189926568e-17
Rsub_187_229 sn_187 sn_229 1195338.354998237
Csub_187_229 sn_187 sn_229 8.814645207503232e-18
Rsub_187_198 sn_187 sn_198 2838850.825552201
Csub_187_198 sn_187 sn_198 3.711531232071869e-18
Rsub_187_213 sn_187 sn_213 61634129.63573041
Csub_187_213 sn_187 sn_213 1.709520936614608e-19
Rsub_187_230 sn_187 0 350703.3551922577
Csub_187_230 sn_187 0 3.004386284372396e-17
Rsub_187_218 sn_187 sn_218 5213844.434634468
Csub_187_218 sn_187 sn_218 2.020866490039167e-18
Rsub_187_220 sn_187 sn_220 4207.691908560661
Csub_187_220 sn_187 sn_220 2.504100521426782e-15
Rsub_187_209 sn_187 sn_209 2978.247799859184
Csub_187_209 sn_187 sn_209 3.537812905537337e-15
Rsub_187_202 sn_187 sn_202 977172.5194339675
Csub_187_202 sn_187 sn_202 1.078262363367864e-17
Rsub_187_193 sn_187 sn_193 369403.6790540433
Csub_187_193 sn_187 sn_193 2.852295225973786e-17
Rsub_187_217 sn_187 sn_217 112148.8965189659
Csub_187_217 sn_187 sn_217 9.395084418372443e-17
Rsub_43_89 sn_43 sn_89 6794798.991421814
Csub_43_89 sn_43 sn_89 1.550668903602877e-18
Rsub_43_57 sn_43 sn_57 11986085.95836914
Csub_43_57 sn_43 sn_57 8.79059564467167e-19
Rsub_43_176 sn_43 sn_176 25156692.46839033
Csub_43_176 sn_43 sn_176 4.188342134193202e-19
Rsub_43_63 sn_43 sn_63 14586260.46486708
Csub_43_63 sn_43 sn_63 7.223567361633577e-19
Rsub_43_84 sn_43 sn_84 33690714.80464255
Csub_43_84 sn_43 sn_84 3.127414649207171e-19
Rsub_43_110 sn_43 sn_110 2857121.1397592
Csub_43_110 sn_43 sn_110 3.687797257038259e-18
Rsub_43_212 sn_43 sn_212 165357.7180378171
Csub_43_212 sn_43 sn_212 6.371933301486612e-17
Rsub_43_141 sn_43 sn_141 1241296.223112808
Csub_43_141 sn_43 sn_141 8.4882909542797e-18
Rsub_43_208 sn_43 sn_208 2128936.202609044
Csub_43_208 sn_43 sn_208 4.949177664092223e-18
Rsub_43_51 sn_43 sn_51 1508121.767951335
Csub_43_51 sn_43 sn_51 6.986493880094965e-18
Rsub_43_218 sn_43 sn_218 1357807.915220495
Csub_43_218 sn_43 sn_218 7.759921991999121e-18
Rsub_43_186 sn_43 sn_186 7198944.640398109
Csub_43_186 sn_43 sn_186 1.463615019777027e-18
Rsub_43_126 sn_43 sn_126 1379010.291857186
Csub_43_126 sn_43 sn_126 7.640612665798135e-18
Rsub_43_114 sn_43 sn_114 991087.1815968781
Csub_43_114 sn_43 sn_114 1.063123779408912e-17
Rsub_43_103 sn_43 sn_103 3815453.975923541
Csub_43_103 sn_43 sn_103 2.76152813497891e-18
Rsub_43_182 sn_43 sn_182 218947.223153958
Csub_43_182 sn_43 sn_182 4.812339407849452e-17
Rsub_43_192 sn_43 sn_192 565015.1937590025
Csub_43_192 sn_43 sn_192 1.864814188824125e-17
Rsub_43_188 sn_43 sn_188 5941010.262986894
Csub_43_188 sn_43 sn_188 1.773517135271315e-18
Rsub_43_216 sn_43 sn_216 748994.5068722729
Csub_43_216 sn_43 sn_216 1.40675043749377e-17
Rsub_43_49 sn_43 sn_49 397351.5301648322
Csub_43_49 sn_43 sn_49 2.651678099203287e-17
Rsub_43_137 sn_43 sn_137 3806495.556229337
Csub_43_137 sn_43 sn_137 2.768027269856398e-18
Rsub_43_175 sn_43 sn_175 3819164.880322414
Csub_43_175 sn_43 sn_175 2.75884488688022e-18
Rsub_43_157 sn_43 sn_157 2099739.475824055
Csub_43_157 sn_43 sn_157 5.017995624478554e-18
Rsub_43_174 sn_43 sn_174 9540442.067597495
Csub_43_174 sn_43 sn_174 1.104402021161618e-18
Rsub_43_95 sn_43 sn_95 2555391.459938375
Csub_43_95 sn_43 sn_95 4.123236563717755e-18
Rsub_43_211 sn_43 sn_211 148170.6536987589
Csub_43_211 sn_43 sn_211 7.111046107450802e-17
Rsub_43_44 sn_43 sn_44 376590.2906546482
Csub_43_44 sn_43 sn_44 2.797863822753856e-17
Rsub_43_115 sn_43 sn_115 15117296.95503178
Csub_43_115 sn_43 sn_115 6.969819759162e-19
Rsub_43_118 sn_43 sn_118 18386588.94537738
Csub_43_118 sn_43 sn_118 5.730526490547887e-19
Rsub_43_76 sn_43 sn_76 1583282.173911382
Csub_43_76 sn_43 sn_76 6.654836185138369e-18
Rsub_43_150 sn_43 sn_150 3663522.835388521
Csub_43_150 sn_43 sn_150 2.876052361527753e-18
Rsub_43_71 sn_43 sn_71 3695439.322134281
Csub_43_71 sn_43 sn_71 2.851212693202797e-18
Rsub_43_221 sn_43 sn_221 378502.5746719677
Csub_43_221 sn_43 sn_221 2.783728356765216e-17
Rsub_43_54 sn_43 sn_54 2308512.30748886
Csub_43_54 sn_43 sn_54 4.564187710002428e-18
Rsub_43_101 sn_43 sn_101 971474.0028445482
Csub_43_101 sn_43 sn_101 1.084587284001259e-17
Rsub_43_133 sn_43 sn_133 1074710.640151761
Csub_43_133 sn_43 sn_133 9.804018968996287e-18
Rsub_43_154 sn_43 sn_154 3138412.55136738
Csub_43_154 sn_43 sn_154 3.357265282933993e-18
Rsub_43_200 sn_43 sn_200 223901.4032883575
Csub_43_200 sn_43 sn_200 4.70585862682616e-17
Rsub_43_90 sn_43 sn_90 190538333.5860989
Csub_43_90 sn_43 sn_90 5.529849717862082e-20
Rsub_43_70 sn_43 sn_70 36052401.84416224
Csub_43_70 sn_43 sn_70 2.922546893761564e-19
Rsub_43_172 sn_43 sn_172 2065724.909836399
Csub_43_172 sn_43 sn_172 5.100622765431275e-18
Rsub_43_210 sn_43 sn_210 2493832.510689249
Csub_43_210 sn_43 sn_210 4.22501649852897e-18
Rsub_43_196 sn_43 sn_196 932761.5999826174
Csub_43_196 sn_43 sn_196 1.129600907930425e-17
Rsub_43_117 sn_43 sn_117 1648058.503988299
Csub_43_117 sn_43 sn_117 6.393270309720029e-18
Rsub_43_166 sn_43 sn_166 542061.4277859628
Csub_43_166 sn_43 sn_166 1.943780347047754e-17
Rsub_43_222 sn_43 sn_222 206096.7319969571
Csub_43_222 sn_43 sn_222 5.112397173956922e-17
Rsub_43_55 sn_43 sn_55 40255148.56619357
Csub_43_55 sn_43 sn_55 2.617425069219241e-19
Rsub_43_185 sn_43 sn_185 3236649.005027704
Csub_43_185 sn_43 sn_185 3.255367970349264e-18
Rsub_43_69 sn_43 sn_69 493368.3799237345
Csub_43_69 sn_43 sn_69 2.13562196747565e-17
Rsub_43_148 sn_43 sn_148 659770.1450085648
Csub_43_148 sn_43 sn_148 1.596993071290491e-17
Rsub_43_227 sn_43 sn_227 32931.49900162171
Csub_43_227 sn_43 sn_227 3.199515303482278e-16
Rsub_43_60 sn_43 sn_60 5832487.095931228
Csub_43_60 sn_43 sn_60 1.80651638467924e-18
Rsub_43_153 sn_43 sn_153 3293708.525418953
Csub_43_153 sn_43 sn_153 3.198972653747429e-18
Rsub_43_190 sn_43 sn_190 2260309.445963045
Csub_43_190 sn_43 sn_190 4.661522572074525e-18
Rsub_43_91 sn_43 sn_91 12877210.51520525
Csub_43_91 sn_43 sn_91 8.182271688257837e-19
Rsub_43_170 sn_43 sn_170 39174.38124226986
Csub_43_170 sn_43 sn_170 2.689636228602622e-16
Rsub_43_127 sn_43 sn_127 6793237.277944286
Csub_43_127 sn_43 sn_127 1.551025390565846e-18
Rsub_43_48 sn_43 sn_48 152331.8553420156
Csub_43_48 sn_43 sn_48 6.91679588525557e-17
Rsub_43_215 sn_43 sn_215 5649.036307537878
Csub_43_215 sn_43 sn_215 1.86518247159617e-15
Rsub_43_206 sn_43 sn_206 118670.6318619394
Csub_43_206 sn_43 sn_206 8.87876245109074e-17
Rsub_43_138 sn_43 sn_138 113842.6420619924
Csub_43_138 sn_43 sn_138 9.255304788597945e-17
Rsub_43_199 sn_43 sn_199 1278048.473908705
Csub_43_199 sn_43 sn_199 8.244197084329569e-18
Rsub_43_88 sn_43 sn_88 3082235.472559876
Csub_43_88 sn_43 sn_88 3.418455077826737e-18
Rsub_43_177 sn_43 sn_177 106787.1605294685
Csub_43_177 sn_43 sn_177 9.866807442007415e-17
Rsub_43_66 sn_43 sn_66 1654424.728609335
Csub_43_66 sn_43 sn_66 6.368669012271525e-18
Rsub_43_214 sn_43 sn_214 41962.15148824332
Csub_43_214 sn_43 sn_214 2.510949302773964e-16
Rsub_43_226 sn_43 sn_226 204060.4871311542
Csub_43_226 sn_43 sn_226 5.163411912987334e-17
Rsub_43_59 sn_43 sn_59 4942599.050688599
Csub_43_59 sn_43 sn_59 2.131769822753894e-18
Rsub_43_99 sn_43 sn_99 1037030.933214447
Csub_43_99 sn_43 sn_99 1.016024032144388e-17
Rsub_43_119 sn_43 sn_119 199109.5357053645
Csub_43_119 sn_43 sn_119 5.291802557272562e-17
Rsub_43_198 sn_43 sn_198 76088.64524132878
Csub_43_198 sn_43 sn_198 1.384764240289948e-16
Rsub_43_131 sn_43 sn_131 1580007.48549733
Csub_43_131 sn_43 sn_131 6.668628850776295e-18
Rsub_43_52 sn_43 sn_52 74245.74047447105
Csub_43_52 sn_43 sn_52 1.419136429227601e-16
Rsub_43_219 sn_43 sn_219 20763897.22039938
Csub_43_219 sn_43 sn_219 5.074424801081413e-19
Rsub_43_230 sn_43 0 18652.25105608154
Csub_43_230 sn_43 0 5.648907185813692e-16
Rsub_43_125 sn_43 sn_125 6610078.799844634
Csub_43_125 sn_43 sn_125 1.594002707271456e-18
Rsub_43_46 sn_43 sn_46 384482.3014554029
Csub_43_46 sn_43 sn_46 2.740433945163573e-17
Rsub_43_213 sn_43 sn_213 289352.904070863
Csub_43_213 sn_43 sn_213 3.64139545654935e-17
Rsub_43_204 sn_43 sn_204 703350.2184014786
Csub_43_204 sn_43 sn_204 1.498042259256921e-17
Rsub_43_134 sn_43 sn_134 2023786.895685498
Csub_43_134 sn_43 sn_134 5.206320648034969e-18
Rsub_43_139 sn_43 sn_139 1911447.462670689
Csub_43_139 sn_43 sn_139 5.512306096819603e-18
Rsub_43_171 sn_43 sn_171 8792127.604650101
Csub_43_171 sn_43 sn_171 1.19839974759435e-18
Rsub_43_116 sn_43 sn_116 16409031.4674194
Csub_43_116 sn_43 sn_116 6.421148940539539e-19
Rsub_43_195 sn_43 sn_195 437353.8062945
Csub_43_195 sn_43 sn_195 2.40914411869439e-17
Rsub_43_228 sn_43 sn_228 26485816.47008242
Csub_43_228 sn_43 sn_228 3.978160731473652e-19
Rsub_43_160 sn_43 sn_160 491941.6205780276
Csub_43_160 sn_43 sn_160 2.141815829660787e-17
Rsub_43_165 sn_43 sn_165 27186627.30733826
Csub_43_165 sn_43 sn_165 3.875612588173442e-19
Rsub_43_132 sn_43 sn_132 1237790.713632091
Csub_43_132 sn_43 sn_132 8.512330385249413e-18
Rsub_43_77 sn_43 sn_77 3169417.267736089
Csub_43_77 sn_43 sn_77 3.324422949760792e-18
Rsub_43_87 sn_43 sn_87 549741.9131721624
Csub_43_87 sn_43 sn_87 1.916623646436487e-17
Rsub_43_97 sn_43 sn_97 5913676.794901371
Csub_43_97 sn_43 sn_97 1.781714467607412e-18
Rsub_43_207 sn_43 sn_207 895854.0510511935
Csub_43_207 sn_43 sn_207 1.176138399984519e-17
Rsub_43_181 sn_43 sn_181 1359386.222148631
Csub_43_181 sn_43 sn_181 7.750912382778276e-18
Rsub_43_223 sn_43 sn_223 5606206.616558415
Csub_43_223 sn_43 sn_223 1.87943189091704e-18
Rsub_43_203 sn_43 sn_203 392160.1971054634
Csub_43_203 sn_43 sn_203 2.686780448398345e-17
Rsub_43_80 sn_43 sn_80 2184177.020641788
Csub_43_80 sn_43 sn_80 4.824006205840408e-18
Rsub_43_184 sn_43 sn_184 25519180.83248818
Csub_43_184 sn_43 sn_184 4.128848637968866e-19
Rsub_43_53 sn_43 sn_53 648199.0547125166
Csub_43_53 sn_43 sn_53 1.62550121380585e-17
Rsub_43_220 sn_43 sn_220 9699152.366614973
Csub_43_220 sn_43 sn_220 1.08633034145305e-18
Rsub_43_191 sn_43 sn_191 6549419.96140632
Csub_43_191 sn_43 sn_191 1.608765900540536e-18
Rsub_43_85 sn_43 sn_85 7342216.07673525
Csub_43_85 sn_43 sn_85 1.435054946913943e-18
Rsub_43_169 sn_43 sn_169 5520181.348642892
Csub_43_169 sn_43 sn_169 1.908720535933179e-18
Rsub_43_202 sn_43 sn_202 12841545.49370465
Csub_43_202 sn_43 sn_202 8.204996437068524e-19
Rsub_43_72 sn_43 sn_72 17475972.92793257
Csub_43_72 sn_43 sn_72 6.029125557518519e-19
Rsub_43_193 sn_43 sn_193 9494670.848103631
Csub_43_193 sn_43 sn_193 1.109726042197077e-18
Rsub_43_93 sn_43 sn_93 2505206.826916066
Csub_43_93 sn_43 sn_93 4.205833781476845e-18
Rsub_43_107 sn_43 sn_107 31391348.59377653
Csub_43_107 sn_43 sn_107 3.356492783594172e-19
Rsub_43_205 sn_43 sn_205 3337226.107798235
Csub_43_205 sn_43 sn_205 3.157257902786079e-18
Rsub_43_130 sn_43 sn_130 2422811.48099239
Csub_43_130 sn_43 sn_130 4.348866424355158e-18
Rsub_43_142 sn_43 sn_142 2145650.255470953
Csub_43_142 sn_43 sn_142 4.910624867852626e-18
Rsub_43_144 sn_43 sn_144 1562422.989322349
Csub_43_144 sn_43 sn_144 6.743681816151375e-18
Rsub_43_201 sn_43 sn_201 1733472.139110169
Csub_43_201 sn_43 sn_201 6.078253733941534e-18
Rsub_43_67 sn_43 sn_67 4041436.879456672
Csub_43_67 sn_43 sn_67 2.607113216536618e-18
Rsub_43_209 sn_43 sn_209 10469215.66726435
Csub_43_209 sn_43 sn_209 1.006425298427655e-18
Rsub_43_83 sn_43 sn_83 366767.8379890816
Csub_43_83 sn_43 sn_83 2.87279374331172e-17
Rsub_43_50 sn_43 sn_50 8274363.55047778
Csub_43_50 sn_43 sn_50 1.273388996984741e-18
Rsub_43_217 sn_43 sn_217 4657302.355708971
Csub_43_217 sn_43 sn_217 2.262357626258529e-18
Rsub_43_140 sn_43 sn_140 12565240.50845849
Csub_43_140 sn_43 sn_140 8.385421270000524e-19
Rsub_43_62 sn_43 sn_62 11743951.62035142
Csub_43_62 sn_43 sn_62 8.971838306938384e-19
Rsub_43_229 sn_43 sn_229 3530310.536594437
Csub_43_229 sn_43 sn_229 2.98457696370081e-18
Rsub_43_167 sn_43 sn_167 25615844.3962476
Csub_43_167 sn_43 sn_167 4.113268077070871e-19
Rsub_43_162 sn_43 sn_162 1869692.904499289
Csub_43_162 sn_43 sn_162 5.635408615433407e-18
Rsub_43_128 sn_43 sn_128 957910.3914532013
Csub_43_128 sn_43 sn_128 1.099944587326753e-17
Rsub_43_79 sn_43 sn_79 2125261.773052173
Csub_43_79 sn_43 sn_79 4.957734447506735e-18
Rsub_43_68 sn_43 sn_68 25688342.06906717
Csub_43_68 sn_43 sn_68 4.101659606486475e-19
Rsub_43_78 sn_43 sn_78 4115718.438924459
Csub_43_78 sn_43 sn_78 2.560059357457759e-18
Rsub_43_96 sn_43 sn_96 8759853.315172315
Csub_43_96 sn_43 sn_96 1.202815061295663e-18
Rsub_43_189 sn_43 sn_189 22484506.39314782
Csub_43_189 sn_43 sn_189 4.686108433067939e-19
Rsub_43_58 sn_43 sn_58 3252155.556484702
Csub_43_58 sn_43 sn_58 3.239846101832541e-18
Rsub_43_225 sn_43 sn_225 153787952.7430346
Csub_43_225 sn_43 sn_225 6.85130617470114e-20
Rsub_43_100 sn_43 sn_100 678671.5499816006
Csub_43_100 sn_43 sn_100 1.55251586758214e-17
Rsub_43_159 sn_43 sn_159 18574046.56094564
Csub_43_159 sn_43 sn_159 5.672691444838054e-19
Rsub_43_74 sn_43 sn_74 7590341.908459939
Csub_43_74 sn_43 sn_74 1.388143463008747e-18
Rsub_43_158 sn_43 sn_158 680405.056134515
Csub_43_158 sn_43 sn_158 1.548560435762981e-17
Rsub_43_194 sn_43 sn_194 13994247.48171762
Csub_43_194 sn_43 sn_194 7.529153329605671e-19
Rsub_43_65 sn_43 sn_65 12374416.37628962
Csub_43_65 sn_43 sn_65 8.514731670431544e-19
Rsub_43_122 sn_43 sn_122 86278578.47999331
Csub_43_122 sn_43 sn_122 1.22121663196772e-19
Rsub_43_98 sn_43 sn_98 54034932.14151852
Csub_43_98 sn_43 sn_98 1.949939249416424e-19
Rsub_43_152 sn_43 sn_152 854454.8218774083
Csub_43_152 sn_43 sn_152 1.233123534732853e-17
Rsub_43_161 sn_43 sn_161 48822885.5723654
Csub_43_161 sn_43 sn_161 2.158103393256591e-19
Rsub_43_179 sn_43 sn_179 267230.4714114777
Csub_43_179 sn_43 sn_179 3.942845082964388e-17
Rsub_43_168 sn_43 sn_168 3891965.986290472
Csub_43_168 sn_43 sn_168 2.707239359065566e-18
Rsub_43_120 sn_43 sn_120 28508698.55879738
Csub_43_120 sn_43 sn_120 3.695883724926683e-19
Rsub_43_156 sn_43 sn_156 14212470.58049307
Csub_43_156 sn_43 sn_156 7.413548153050574e-19
Rsub_43_92 sn_43 sn_92 10772867.08636808
Csub_43_92 sn_43 sn_92 9.780575048180816e-19
Rsub_43_94 sn_43 sn_94 52923301.15828514
Csub_43_94 sn_43 sn_94 1.990896877486357e-19
Rsub_43_143 sn_43 sn_143 19932860.0377821
Csub_43_143 sn_43 sn_143 5.285986798812832e-19
Rsub_43_86 sn_43 sn_86 12370651.36579231
Csub_43_86 sn_43 sn_86 8.517323130911113e-19
Rsub_43_64 sn_43 sn_64 18701881.35034603
Csub_43_64 sn_43 sn_64 5.633916345017906e-19
Rsub_43_180 sn_43 sn_180 9640579.389807964
Csub_43_180 sn_43 sn_180 1.092930525873703e-18
Rsub_43_105 sn_43 sn_105 6969583.063305154
Csub_43_105 sn_43 sn_105 1.511781035755865e-18
Rsub_43_135 sn_43 sn_135 4693950.701877962
Csub_43_135 sn_43 sn_135 2.244694111937425e-18
Rsub_43_224 sn_43 sn_224 34242093.65339953
Csub_43_224 sn_43 sn_224 3.077055862553529e-19
Rsub_43_151 sn_43 sn_151 5489118.977035576
Csub_43_151 sn_43 sn_151 1.9195217932624e-18
Rsub_43_197 sn_43 sn_197 11551583.25823539
Csub_43_197 sn_43 sn_197 9.121246210746299e-19
Rsub_43_183 sn_43 sn_183 9928743.833631346
Csub_43_183 sn_43 sn_183 1.061210126757433e-18
Rsub_43_145 sn_43 sn_145 7461668.67220628
Csub_43_145 sn_43 sn_145 1.412081394270024e-18
Rsub_43_123 sn_43 sn_123 15052951.27168792
Csub_43_123 sn_43 sn_123 6.999613107130269e-19
Rsub_43_136 sn_43 sn_136 6103981.120283348
Csub_43_136 sn_43 sn_136 1.726165807954022e-18
Rsub_135_196 sn_135 sn_196 5224633.773109541
Csub_135_196 sn_135 sn_196 2.016693219046243e-18
Rsub_135_182 sn_135 sn_182 23032976.97393556
Csub_135_182 sn_135 sn_182 4.574520920223744e-19
Rsub_135_149 sn_135 sn_149 10927689.36265966
Csub_135_149 sn_135 sn_149 9.642004958736818e-19
Rsub_135_203 sn_135 sn_203 1738812.642446063
Csub_135_203 sn_135 sn_203 6.059585285397898e-18
Rsub_135_167 sn_135 sn_167 4832113.541058715
Csub_135_167 sn_135 sn_167 2.180512401602521e-18
Rsub_135_206 sn_135 sn_206 4376259.756781763
Csub_135_206 sn_135 sn_206 2.407645818076022e-18
Rsub_135_150 sn_135 sn_150 719974.9141787671
Csub_135_150 sn_135 sn_150 1.463451475145956e-17
Rsub_135_229 sn_135 sn_229 4273620.300010885
Csub_135_229 sn_135 sn_229 2.465470201506476e-18
Rsub_135_176 sn_135 sn_176 32854.89805804699
Csub_135_176 sn_135 sn_176 3.206974948945049e-16
Rsub_135_219 sn_135 sn_219 332938.4186151469
Csub_135_219 sn_135 sn_219 3.164694403864945e-17
Rsub_135_140 sn_135 sn_140 4932.872308251279
Csub_135_140 sn_135 sn_140 2.135973291788943e-15
Rsub_135_186 sn_135 sn_186 1042481.644819854
Csub_135_186 sn_135 sn_186 1.010711656611543e-17
Rsub_135_165 sn_135 sn_165 1302900.895758788
Csub_135_165 sn_135 sn_165 8.086941636565326e-18
Rsub_135_180 sn_135 sn_180 125696.1134012614
Csub_135_180 sn_135 sn_180 8.382505406984419e-17
Rsub_135_220 sn_135 sn_220 24148315.80395966
Csub_135_220 sn_135 sn_220 4.363237414885186e-19
Rsub_135_141 sn_135 sn_141 29332.96241251998
Csub_135_141 sn_135 sn_141 3.592028433423004e-16
Rsub_135_146 sn_135 sn_146 2685511.688910395
Csub_135_146 sn_135 sn_146 3.923454716559069e-18
Rsub_135_188 sn_135 sn_188 20910359.98703392
Csub_135_188 sn_135 sn_188 5.038881926836007e-19
Rsub_135_160 sn_135 sn_160 686738.3875135272
Csub_135_160 sn_135 sn_160 1.534279092855059e-17
Rsub_135_197 sn_135 sn_197 2399311.737171207
Csub_135_197 sn_135 sn_197 4.391460825616823e-18
Rsub_135_228 sn_135 sn_228 298082.0051289668
Csub_135_228 sn_135 sn_228 3.534760005949147e-17
Rsub_135_189 sn_135 sn_189 1403045.681872705
Csub_135_189 sn_135 sn_189 7.509722340734131e-18
Rsub_135_226 sn_135 sn_226 1345239.789130122
Csub_135_226 sn_135 sn_226 7.832420351648424e-18
Rsub_135_147 sn_135 sn_147 2981575.8834252
Csub_135_147 sn_135 sn_147 3.533863941147058e-18
Rsub_135_158 sn_135 sn_158 53263.37518690759
Csub_135_158 sn_135 sn_158 1.978185472711072e-16
Rsub_135_210 sn_135 sn_210 40347.59903947084
Csub_135_210 sn_135 sn_210 2.611427632142987e-16
Rsub_135_214 sn_135 sn_214 6287423.230031658
Csub_135_214 sn_135 sn_214 1.675803125818357e-18
Rsub_135_218 sn_135 sn_218 4119953.808848286
Csub_135_218 sn_135 sn_218 2.55742758076587e-18
Rsub_135_139 sn_135 sn_139 97484582.08635072
Csub_135_139 sn_135 sn_139 1.080835889812494e-19
Rsub_135_181 sn_135 sn_181 7065.762778497543
Csub_135_181 sn_135 sn_181 1.491202554138177e-15
Rsub_135_179 sn_135 sn_179 11358414.44891115
Csub_135_179 sn_135 sn_179 9.276368237505241e-19
Rsub_135_216 sn_135 sn_216 92158.63932940978
Csub_135_216 sn_135 sn_216 1.143298509927933e-16
Rsub_135_137 sn_135 sn_137 463546.3326380045
Csub_135_137 sn_135 sn_137 2.273016257569708e-17
Rsub_135_177 sn_135 sn_177 407928.936408777
Csub_135_177 sn_135 sn_177 2.582921328157906e-17
Rsub_135_222 sn_135 sn_222 104253.9360169869
Csub_135_222 sn_135 sn_222 1.010655703254524e-16
Rsub_135_171 sn_135 sn_171 2071820.148869454
Csub_135_171 sn_135 sn_171 5.085616870740215e-18
Rsub_135_138 sn_135 sn_138 1096060.598623647
Csub_135_138 sn_135 sn_138 9.613048325485793e-18
Rsub_135_217 sn_135 sn_217 1694996.352094114
Csub_135_217 sn_135 sn_217 6.216227833890327e-18
Rsub_135_155 sn_135 sn_155 18518.58024450395
Csub_135_155 sn_135 sn_155 5.689682126337454e-16
Rsub_135_156 sn_135 sn_156 1155691.354513865
Csub_135_156 sn_135 sn_156 9.117039303856447e-18
Rsub_135_230 sn_135 0 30385.72299537026
Csub_135_230 sn_135 0 3.467577027486033e-16
Rsub_135_151 sn_135 sn_151 182269.4353673369
Csub_135_151 sn_135 sn_151 5.780718791933102e-17
Rsub_135_153 sn_135 sn_153 441445.9131438443
Csub_135_153 sn_135 sn_153 2.386811880801512e-17
Rsub_135_190 sn_135 sn_190 97135.61232126885
Csub_135_190 sn_135 sn_190 1.084718904883346e-16
Rsub_135_168 sn_135 sn_168 137971.8087811508
Csub_135_168 sn_135 sn_168 7.636693028314824e-17
Rsub_135_207 sn_135 sn_207 2540615.360136526
Csub_135_207 sn_135 sn_207 4.147217114228498e-18
Rsub_135_159 sn_135 sn_159 567456.4118446781
Csub_135_159 sn_135 sn_159 1.856791690480362e-17
Rsub_135_157 sn_135 sn_157 211745.3052370367
Csub_135_157 sn_135 sn_157 4.976017527488987e-17
Rsub_135_195 sn_135 sn_195 466908.2820938809
Csub_135_195 sn_135 sn_195 2.256649519040109e-17
Rsub_135_172 sn_135 sn_172 3066599.816707572
Csub_135_172 sn_135 sn_172 3.435884736190457e-18
Rsub_135_185 sn_135 sn_185 808221.8171063235
Csub_135_185 sn_135 sn_185 1.303662346056652e-17
Rsub_135_191 sn_135 sn_191 386043.1070429792
Csub_135_191 sn_135 sn_191 2.729354134292817e-17
Rsub_135_170 sn_135 sn_170 2361789.113236523
Csub_135_170 sn_135 sn_170 4.461229600551054e-18
Rsub_135_169 sn_135 sn_169 1309121.589162633
Csub_135_169 sn_135 sn_169 8.048514049004082e-18
Rsub_135_136 sn_135 sn_136 2792302.390276949
Csub_135_136 sn_135 sn_136 3.77340346049876e-18
Rsub_135_215 sn_135 sn_215 2870221.458391588
Csub_135_215 sn_135 sn_215 3.670965343606073e-18
Rsub_135_209 sn_135 sn_209 318479.7383560298
Csub_135_209 sn_135 sn_209 3.30836855010576e-17
Rsub_135_178 sn_135 sn_178 11256907.42081992
Csub_135_178 sn_135 sn_178 9.36001612906803e-19
Rsub_135_183 sn_135 sn_183 3877420.605191066
Csub_135_183 sn_135 sn_183 2.717395035277788e-18
Rsub_135_224 sn_135 sn_224 5098095.254583147
Csub_135_224 sn_135 sn_224 2.066749045686776e-18
Rsub_135_152 sn_135 sn_152 11628030.49078352
Csub_135_152 sn_135 sn_152 9.061279561127146e-19
Rsub_135_154 sn_135 sn_154 2228477.931981394
Csub_135_154 sn_135 sn_154 4.728107624948192e-18
Rsub_135_198 sn_135 sn_198 3291991.273327904
Csub_135_198 sn_135 sn_198 3.200641383103842e-18
Rsub_135_192 sn_135 sn_192 3456483.585133569
Csub_135_192 sn_135 sn_192 3.048324472752513e-18
Rsub_135_227 sn_135 sn_227 2884124.596809842
Csub_135_227 sn_135 sn_227 3.653269180493972e-18
Rsub_135_148 sn_135 sn_148 3678360.553284878
Csub_135_148 sn_135 sn_148 2.864450982876224e-18
Rsub_135_201 sn_135 sn_201 12290955.93420612
Csub_135_201 sn_135 sn_201 8.572550059272964e-19
Rsub_135_166 sn_135 sn_166 13335909.38893444
Csub_135_166 sn_135 sn_166 7.900836152180756e-19
Rsub_135_175 sn_135 sn_175 2732870.759940791
Csub_135_175 sn_135 sn_175 3.855463513561204e-18
Rsub_135_221 sn_135 sn_221 2714229.700061917
Csub_135_221 sn_135 sn_221 3.881942453871772e-18
Rsub_135_213 sn_135 sn_213 7366061.682562869
Csub_135_213 sn_135 sn_213 1.430409349839174e-18
Rsub_135_204 sn_135 sn_204 86534040.99823005
Csub_135_204 sn_135 sn_204 1.217611402482118e-19
Rsub_135_208 sn_135 sn_208 12100520.69215882
Csub_135_208 sn_135 sn_208 8.707462902036667e-19
Rsub_135_202 sn_135 sn_202 6949181.08240688
Csub_135_202 sn_135 sn_202 1.516219447627438e-18
Rsub_135_223 sn_135 sn_223 22112459.12369648
Csub_135_223 sn_135 sn_223 4.764953297726502e-19
Rsub_194_227 sn_194 sn_227 983126.6455465734
Csub_194_227 sn_194 sn_227 1.071732065238879e-17
Rsub_194_220 sn_194 sn_220 1396655.086257008
Csub_194_220 sn_194 sn_220 7.544084152134833e-18
Rsub_194_229 sn_194 sn_229 361938.2951669233
Csub_194_229 sn_194 sn_229 2.911127018866752e-17
Rsub_194_211 sn_194 sn_211 1213750.286176306
Csub_194_211 sn_194 sn_211 8.680931837654373e-18
Rsub_194_230 sn_194 0 101743.9703202154
Csub_194_230 sn_194 0 1.035588002814209e-16
Rsub_194_213 sn_194 sn_213 15931904.81803607
Csub_194_213 sn_194 sn_213 6.61344868838404e-19
Rsub_194_196 sn_194 sn_196 3566215.607220139
Csub_194_196 sn_194 sn_196 2.954527898116395e-18
Rsub_194_202 sn_194 sn_202 6018.534868031471
Csub_194_202 sn_194 sn_202 1.750672503069879e-15
Rsub_194_225 sn_194 sn_225 10400.78223100833
Csub_194_225 sn_194 sn_225 1.013047217815704e-15
Rsub_194_209 sn_194 sn_209 1405346.970046025
Csub_194_209 sn_194 sn_209 7.497424996678885e-18
Rsub_194_223 sn_194 sn_223 6488490.815899926
Csub_194_223 sn_194 sn_223 1.623872761969632e-18
Rsub_194_217 sn_194 sn_217 1632873.046520176
Csub_194_217 sn_194 sn_217 6.452726698309068e-18
Rsub_194_204 sn_194 sn_204 6210633.97154305
Csub_194_204 sn_194 sn_204 1.696523020114834e-18
Rsub_194_222 sn_194 sn_222 2362322.388972069
Csub_194_222 sn_194 sn_222 4.460222512988501e-18
Rsub_115_128 sn_115 sn_128 289673.4146237948
Csub_115_128 sn_115 sn_128 3.637366416905728e-17
Rsub_115_165 sn_115 sn_165 248459.1963905984
Csub_115_165 sn_115 sn_165 4.240729928815264e-17
Rsub_115_139 sn_115 sn_139 103576.251976086
Csub_115_139 sn_115 sn_139 1.017268273490211e-16
Rsub_115_218 sn_115 sn_218 3088763.723927403
Csub_115_218 sn_115 sn_218 3.411230007853345e-18
Rsub_115_192 sn_115 sn_192 10787481.10876015
Csub_115_192 sn_115 sn_192 9.76732510212572e-19
Rsub_115_177 sn_115 sn_177 215414.0554828797
Csub_115_177 sn_115 sn_177 4.891270199899933e-17
Rsub_115_135 sn_115 sn_135 8159870.031570885
Csub_115_135 sn_115 sn_135 1.291256289801663e-18
Rsub_115_219 sn_115 sn_219 3383224.729943452
Csub_115_219 sn_115 sn_219 3.114331545574305e-18
Rsub_115_140 sn_115 sn_140 10329468.43155547
Csub_115_140 sn_115 sn_140 1.020041212386315e-18
Rsub_115_186 sn_115 sn_186 7951889.244538954
Csub_115_186 sn_115 sn_186 1.325028955787588e-18
Rsub_115_160 sn_115 sn_160 7639939.608604999
Csub_115_160 sn_115 sn_160 1.379131778785604e-18
Rsub_115_226 sn_115 sn_226 828876.7759925124
Csub_115_226 sn_115 sn_226 1.271176103301172e-17
Rsub_115_204 sn_115 sn_204 162504.730496872
Csub_115_204 sn_115 sn_204 6.483801099213425e-17
Rsub_115_164 sn_115 sn_164 31672420.81304907
Csub_115_164 sn_115 sn_164 3.326706084269049e-19
Rsub_115_217 sn_115 sn_217 3620384.064996434
Csub_115_217 sn_115 sn_217 2.910322030223713e-18
Rsub_115_197 sn_115 sn_197 39861001.16079443
Csub_115_197 sn_115 sn_197 2.643306288200617e-19
Rsub_115_166 sn_115 sn_166 4936801.528321348
Csub_115_166 sn_115 sn_166 2.134273262107967e-18
Rsub_115_205 sn_115 sn_205 76689.18355367967
Csub_115_205 sn_115 sn_205 1.373920416671908e-16
Rsub_115_132 sn_115 sn_132 462302.0908794729
Csub_115_132 sn_115 sn_132 2.279133862921891e-17
Rsub_115_174 sn_115 sn_174 12395449.20938814
Csub_115_174 sn_115 sn_174 8.500283712388426e-19
Rsub_115_188 sn_115 sn_188 25409300.07760186
Csub_115_188 sn_115 sn_188 4.146703557378915e-19
Rsub_115_225 sn_115 sn_225 77521.33195367309
Csub_115_225 sn_115 sn_225 1.359172144839646e-16
Rsub_115_206 sn_115 sn_206 1672762.296125643
Csub_115_206 sn_115 sn_206 6.298852817662141e-18
Rsub_115_172 sn_115 sn_172 1872440.533721318
Csub_115_172 sn_115 sn_172 5.627139186786148e-18
Rsub_115_130 sn_115 sn_130 48951.24502005444
Csub_115_130 sn_115 sn_130 2.152444436890909e-16
Rsub_115_209 sn_115 sn_209 83803.28584285814
Csub_115_209 sn_115 sn_209 1.257287634519159e-16
Rsub_115_230 sn_115 0 6715.467364122144
Csub_115_230 sn_115 0 1.568987373614814e-15
Rsub_115_193 sn_115 sn_193 9436085.217196256
Csub_115_193 sn_115 sn_193 1.116615975768043e-18
Rsub_115_179 sn_115 sn_179 101391.9476759235
Csub_115_179 sn_115 sn_179 1.039183460200163e-16
Rsub_115_137 sn_115 sn_137 205643.5052043849
Csub_115_137 sn_115 sn_137 5.123664611609302e-17
Rsub_115_180 sn_115 sn_180 5523771.311695335
Csub_115_180 sn_115 sn_180 1.907480036315294e-18
Rsub_115_163 sn_115 sn_163 158348.5558335107
Csub_115_163 sn_115 sn_163 6.653981431512497e-17
Rsub_115_173 sn_115 sn_173 14108.77241479344
Csub_115_173 sn_115 sn_173 7.468037042813309e-16
Rsub_115_122 sn_115 sn_122 2090.214484432734
Csub_115_122 sn_115 sn_122 5.040862352022936e-15
Rsub_115_117 sn_115 sn_117 99346.48188859147
Csub_115_117 sn_115 sn_117 1.060579428876582e-16
Rsub_115_202 sn_115 sn_202 897.5569341084175
Csub_115_202 sn_115 sn_202 1.173906980362906e-14
Rsub_115_167 sn_115 sn_167 901.6666574233321
Csub_115_167 sn_115 sn_167 1.168556407790415e-14
Rsub_115_175 sn_115 sn_175 16049.42847646885
Csub_115_175 sn_115 sn_175 6.565021002260764e-16
Rsub_115_143 sn_115 sn_143 265089.6244665672
Csub_115_143 sn_115 sn_143 3.974687249051066e-17
Rsub_115_222 sn_115 sn_222 5632912.563689341
Csub_115_222 sn_115 sn_222 1.870521401335051e-18
Rsub_115_150 sn_115 sn_150 3680067.865161972
Csub_115_150 sn_115 sn_150 2.863122064127004e-18
Rsub_115_155 sn_115 sn_155 3048178.98939678
Csub_115_155 sn_115 sn_155 3.45664855603349e-18
Rsub_115_178 sn_115 sn_178 6038396.393495961
Csub_115_178 sn_115 sn_178 1.744914181781605e-18
Rsub_115_144 sn_115 sn_144 31137193.02729731
Csub_115_144 sn_115 sn_144 3.383889964966622e-19
Rsub_115_195 sn_115 sn_195 3022616.716568633
Csub_115_195 sn_115 sn_195 3.485881436595553e-18
Rsub_115_158 sn_115 sn_158 2234920.053156717
Csub_115_158 sn_115 sn_158 4.714478930621131e-18
Rsub_115_200 sn_115 sn_200 13557956.84706662
Csub_115_200 sn_115 sn_200 7.771439031028971e-19
Rsub_115_121 sn_115 sn_121 12677234.74397393
Csub_115_121 sn_115 sn_121 8.311342114445323e-19
Rsub_115_221 sn_115 sn_221 8349670.700469441
Csub_115_221 sn_115 sn_221 1.261904077443151e-18
Rsub_115_194 sn_115 sn_194 723836.8323425064
Csub_115_194 sn_115 sn_194 1.45564345877944e-17
Rsub_115_187 sn_115 sn_187 667578.7552845535
Csub_115_187 sn_115 sn_187 1.578313183099851e-17
Rsub_115_220 sn_115 sn_220 381379.8587008616
Csub_115_220 sn_115 sn_220 2.762726783244832e-17
Rsub_115_119 sn_115 sn_119 52008.70982189628
Csub_115_119 sn_115 sn_119 2.025907494785424e-16
Rsub_115_198 sn_115 sn_198 1572094.0208411
Csub_115_198 sn_115 sn_198 6.702196791380697e-18
Rsub_115_210 sn_115 sn_210 7608496.507464066
Csub_115_210 sn_115 sn_210 1.384831220188316e-18
Rsub_115_131 sn_115 sn_131 2457665.852850889
Csub_115_131 sn_115 sn_131 4.287191234726923e-18
Rsub_161_186 sn_161 sn_186 26739701.81824657
Csub_161_186 sn_161 sn_186 3.940389303458928e-19
Rsub_161_215 sn_161 sn_215 972983.9615662639
Csub_161_215 sn_161 sn_215 1.08290412981411e-17
Rsub_161_229 sn_161 sn_229 11545802.39071144
Csub_161_229 sn_161 sn_229 9.125813127294266e-19
Rsub_161_170 sn_161 sn_170 4426649.181506374
Csub_161_170 sn_161 sn_170 2.380239108680501e-18
Rsub_161_211 sn_161 sn_211 33663086.07921972
Csub_161_211 sn_161 sn_211 3.129981451324568e-19
Rsub_161_222 sn_161 sn_222 1812515.790832876
Csub_161_222 sn_161 sn_222 5.813181631586415e-18
Rsub_161_185 sn_161 sn_185 1917105.175081916
Csub_161_185 sn_161 sn_185 5.496038318179277e-18
Rsub_161_181 sn_161 sn_181 414217.7589498353
Csub_161_181 sn_161 sn_181 2.543706365691106e-17
Rsub_161_165 sn_161 sn_165 43310.03004700399
Csub_161_165 sn_161 sn_165 2.432804477575945e-16
Rsub_161_169 sn_161 sn_169 527807.7902556737
Csub_161_169 sn_161 sn_169 1.996272828244172e-17
Rsub_161_220 sn_161 sn_220 1480456.568117303
Csub_161_220 sn_161 sn_220 7.117050056814063e-18
Rsub_161_183 sn_161 sn_183 107914.6333762314
Csub_161_183 sn_161 sn_183 9.763720797248891e-17
Rsub_161_163 sn_161 sn_163 3524008.410410202
Csub_161_163 sn_161 sn_163 2.989914402901079e-18
Rsub_161_200 sn_161 sn_200 11432534.50106381
Csub_161_200 sn_161 sn_200 9.216227164019987e-19
Rsub_161_177 sn_161 sn_177 6071.406241992407
Csub_161_177 sn_161 sn_177 1.73542719466789e-15
Rsub_161_195 sn_161 sn_195 1364428.508320758
Csub_161_195 sn_161 sn_195 7.722268655319697e-18
Rsub_161_189 sn_161 sn_189 5114.676638352936
Csub_161_189 sn_161 sn_189 2.060048806061576e-15
Rsub_161_216 sn_161 sn_216 22145211.10566336
Csub_161_216 sn_161 sn_216 4.757906100762086e-19
Rsub_161_179 sn_161 sn_179 835967.4719423414
Csub_161_179 sn_161 sn_179 1.260393957404688e-17
Rsub_161_230 sn_161 0 137709.6484400023
Csub_161_230 sn_161 0 7.651231138550587e-17
Rsub_161_196 sn_161 sn_196 23496495.73278983
Csub_161_196 sn_161 sn_196 4.484278686513294e-19
Rsub_161_209 sn_161 sn_209 1966499.375230801
Csub_161_209 sn_161 sn_209 5.357989753235175e-18
Rsub_161_228 sn_161 sn_228 36233714.42052847
Csub_161_228 sn_161 sn_228 2.907922544165244e-19
Rsub_161_191 sn_161 sn_191 2250689.277142994
Csub_161_191 sn_161 sn_191 4.681447416679804e-18
Rsub_161_205 sn_161 sn_205 1204695.412686592
Csub_161_205 sn_161 sn_205 8.74618047953929e-18
Rsub_152_211 sn_152 sn_211 7899189.034668444
Csub_152_211 sn_152 sn_211 1.333869015665638e-18
Rsub_152_225 sn_152 sn_225 1534682.25077493
Csub_152_225 sn_152 sn_225 6.865579827296274e-18
Rsub_152_160 sn_152 sn_160 3585672.271091936
Csub_152_160 sn_152 sn_160 2.938495965505891e-18
Rsub_152_176 sn_152 sn_176 3257889.834600818
Csub_152_176 sn_152 sn_176 3.234143582857219e-18
Rsub_152_155 sn_152 sn_155 874293.4086950328
Csub_152_155 sn_152 sn_155 1.205142735544206e-17
Rsub_152_153 sn_152 sn_153 3225818.519121469
Csub_152_153 sn_152 sn_153 3.266297666708028e-18
Rsub_152_230 sn_152 0 42223.34227433242
Csub_152_230 sn_152 0 2.495416737446465e-16
Rsub_152_181 sn_152 sn_181 397210.2370165435
Csub_152_181 sn_152 sn_181 2.652621337599405e-17
Rsub_152_190 sn_152 sn_190 7105338.232418117
Csub_152_190 sn_152 sn_190 1.482896824553302e-18
Rsub_152_158 sn_152 sn_158 7145744.792794948
Csub_152_158 sn_152 sn_158 1.474511588050826e-18
Rsub_152_195 sn_152 sn_195 424570.8513914894
Csub_152_195 sn_152 sn_195 2.481678491987311e-17
Rsub_152_202 sn_152 sn_202 925110.1441724477
Csub_152_202 sn_152 sn_202 1.138943678069313e-17
Rsub_152_189 sn_152 sn_189 5255731.377163629
Csub_152_189 sn_152 sn_189 2.0047606595747e-18
Rsub_152_157 sn_152 sn_157 1063.518673587676
Csub_152_157 sn_152 sn_157 9.907191818913913e-15
Rsub_152_177 sn_152 sn_177 2870.037322777033
Csub_152_177 sn_152 sn_177 3.671200865093613e-15
Rsub_152_220 sn_152 sn_220 74293.99957948236
Csub_152_220 sn_152 sn_220 1.418214601699791e-16
Rsub_152_183 sn_152 sn_183 368806.268090172
Csub_152_183 sn_152 sn_183 2.85691551740489e-17
Rsub_152_154 sn_152 sn_154 331647.442448194
Csub_152_154 sn_152 sn_154 3.177013344185786e-17
Rsub_152_191 sn_152 sn_191 1163047.827657763
Csub_152_191 sn_152 sn_191 9.059372496700498e-18
Rsub_152_228 sn_152 sn_228 1019356.892723081
Csub_152_228 sn_152 sn_228 1.033640286090884e-17
Rsub_152_222 sn_152 sn_222 402073.6802635391
Csub_152_222 sn_152 sn_222 2.6205354937244e-17
Rsub_152_229 sn_152 sn_229 221251.0753742459
Csub_152_229 sn_152 sn_229 4.762229283815933e-17
Rsub_152_161 sn_152 sn_161 2484.275509827332
Csub_152_161 sn_152 sn_161 4.241270125052407e-15
Rsub_152_217 sn_152 sn_217 116365.5886929497
Csub_152_217 sn_152 sn_217 9.054638592541561e-17
Rsub_152_206 sn_152 sn_206 2727146.473871049
Csub_152_206 sn_152 sn_206 3.863556139422898e-18
Rsub_152_169 sn_152 sn_169 36369484.75129065
Csub_152_169 sn_152 sn_169 2.897067025909982e-19
Rsub_152_209 sn_152 sn_209 290593.1593930789
Csub_152_209 sn_152 sn_209 3.625853934151813e-17
Rsub_152_172 sn_152 sn_172 17179488.59477767
Csub_152_172 sn_152 sn_172 6.133176458717723e-19
Rsub_152_163 sn_152 sn_163 9881287.907469479
Csub_152_163 sn_152 sn_163 1.066306700188873e-18
Rsub_152_215 sn_152 sn_215 5528311.490482422
Csub_152_215 sn_152 sn_215 1.905913500056877e-18
Rsub_152_207 sn_152 sn_207 3046786.86925624
Csub_152_207 sn_152 sn_207 3.458227947792781e-18
Rsub_152_205 sn_152 sn_205 325581.3082785237
Csub_152_205 sn_152 sn_205 3.236206512573013e-17
Rsub_152_210 sn_152 sn_210 9600323.193823695
Csub_152_210 sn_152 sn_210 1.097513415903391e-18
Rsub_152_162 sn_152 sn_162 73471381.40085265
Csub_152_162 sn_152 sn_162 1.434093561511248e-19
Rsub_152_174 sn_152 sn_174 55896702.00526683
Csub_152_174 sn_152 sn_174 1.884991980606872e-19
Rsub_152_179 sn_152 sn_179 569170.2809219228
Csub_152_179 sn_152 sn_179 1.851200573080408e-17
Rsub_152_219 sn_152 sn_219 703519.660115385
Csub_152_219 sn_152 sn_219 1.497681457900111e-17
Rsub_68_128 sn_68 sn_128 611880.35184223
Csub_68_128 sn_68 sn_128 1.721984285082384e-17
Rsub_68_126 sn_68 sn_126 8111968.469061292
Csub_68_126 sn_68 sn_126 1.298881220065846e-18
Rsub_68_102 sn_68 sn_102 9027254.481325867
Csub_68_102 sn_68 sn_102 1.167185828651024e-18
Rsub_68_113 sn_68 sn_113 453244.7321393581
Csub_68_113 sn_68 sn_113 2.32467864601466e-17
Rsub_68_192 sn_68 sn_192 10712394.23329314
Csub_68_192 sn_68 sn_192 9.835787661252774e-19
Rsub_68_153 sn_68 sn_153 4226257.779448954
Csub_68_153 sn_68 sn_153 2.493100054962528e-18
Rsub_68_163 sn_68 sn_163 1694015.890707281
Csub_68_163 sn_68 sn_163 6.219825658088035e-18
Rsub_68_119 sn_68 sn_119 647358.0780653508
Csub_68_119 sn_68 sn_119 1.627612886784174e-17
Rsub_68_198 sn_68 sn_198 4324272.955237802
Csub_68_198 sn_68 sn_198 2.436590754398984e-18
Rsub_68_230 sn_68 0 25673.05911416093
Csub_68_230 sn_68 0 4.104101289751721e-16
Rsub_68_72 sn_68 sn_72 94271140.55637914
Csub_68_72 sn_68 sn_72 1.117678585412746e-19
Rsub_68_173 sn_68 sn_173 619305.002149539
Csub_68_173 sn_68 sn_173 1.701339964259781e-17
Rsub_68_94 sn_68 sn_94 34365.22809351594
Csub_68_94 sn_68 sn_94 3.066030428652395e-16
Rsub_68_202 sn_68 sn_202 63152.1698436011
Csub_68_202 sn_68 sn_202 1.668427787726697e-16
Rsub_68_106 sn_68 sn_106 175611.4730520204
Csub_68_106 sn_68 sn_106 5.999883332855385e-17
Rsub_68_69 sn_68 sn_69 6952729.129879628
Csub_68_69 sn_68 sn_69 1.515445705622134e-18
Rsub_68_222 sn_68 sn_222 1237069.059313932
Csub_68_222 sn_68 sn_222 8.517296122557172e-18
Rsub_68_175 sn_68 sn_175 242441.9901659329
Csub_68_175 sn_68 sn_175 4.345981277838294e-17
Rsub_68_167 sn_68 sn_167 56797.2311468749
Csub_68_167 sn_68 sn_167 1.855105132675071e-16
Rsub_68_100 sn_68 sn_100 4114.458728675273
Csub_68_100 sn_68 sn_100 2.560843162381755e-15
Rsub_68_179 sn_68 sn_179 627900.771128206
Csub_68_179 sn_68 sn_179 1.678049141952502e-17
Rsub_68_117 sn_68 sn_117 75766.90085763733
Csub_68_117 sn_68 sn_117 1.390644646008102e-16
Rsub_68_223 sn_68 sn_223 1535.497262755624
Csub_68_223 sn_68 sn_223 6.861935711510869e-15
Rsub_68_121 sn_68 sn_121 14313.72599425803
Csub_68_121 sn_68 sn_121 7.361104653293434e-16
Rsub_68_200 sn_68 sn_200 13715414.99736524
Csub_68_200 sn_68 sn_200 7.682219972384415e-19
Rsub_68_98 sn_68 sn_98 317894.6522456686
Csub_68_98 sn_68 sn_98 3.314457612859564e-17
Rsub_68_172 sn_68 sn_172 42641.02052739202
Csub_68_172 sn_68 sn_172 2.470973577065658e-16
Rsub_68_216 sn_68 sn_216 3951018.093261819
Csub_68_216 sn_68 sn_216 2.6667768290404e-18
Rsub_68_205 sn_68 sn_205 274821.9169875379
Csub_68_205 sn_68 sn_205 3.833931302759886e-17
Rsub_68_131 sn_68 sn_131 2939037.008354339
Csub_68_131 sn_68 sn_131 3.585012190142416e-18
Rsub_68_210 sn_68 sn_210 7752490.646885272
Csub_68_210 sn_68 sn_210 1.359109476186632e-18
Rsub_68_71 sn_68 sn_71 31075.15666004357
Csub_68_71 sn_68 sn_71 3.39064533688347e-16
Rsub_68_229 sn_68 sn_229 13965.46063294532
Csub_68_229 sn_68 sn_229 7.544673089675134e-16
Rsub_68_150 sn_68 sn_150 8094766.275755855
Csub_68_150 sn_68 sn_150 1.301641473427983e-18
Rsub_68_124 sn_68 sn_124 720067.5427946751
Csub_68_124 sn_68 sn_124 1.46326321852205e-17
Rsub_68_203 sn_68 sn_203 5782982.685047805
Csub_68_203 sn_68 sn_203 1.821980814411327e-18
Rsub_68_83 sn_68 sn_83 15261.79430194237
Csub_68_83 sn_68 sn_83 6.903830109208734e-16
Rsub_68_194 sn_68 sn_194 381434.6918939704
Csub_68_194 sn_68 sn_194 2.762329627101378e-17
Rsub_68_115 sn_68 sn_115 190624.4599866322
Csub_68_115 sn_68 sn_115 5.527351265923003e-17
Rsub_68_188 sn_68 sn_188 19515814.51691885
Csub_68_188 sn_68 sn_188 5.398946322786378e-19
Rsub_68_109 sn_68 sn_109 171475.894971533
Csub_68_109 sn_68 sn_109 6.144585805473813e-17
Rsub_68_225 sn_68 sn_225 18512.38747778605
Csub_68_225 sn_68 sn_225 5.691585439681003e-16
Rsub_68_146 sn_68 sn_146 19924428.68477992
Csub_68_146 sn_68 sn_146 5.288223651942763e-19
Rsub_68_114 sn_68 sn_114 16225054.67681215
Csub_68_114 sn_68 sn_114 6.493958702825265e-19
Rsub_68_193 sn_68 sn_193 2936243.802489999
Csub_68_193 sn_68 sn_193 3.588422559902837e-18
Rsub_68_107 sn_68 sn_107 13928268.18330874
Csub_68_107 sn_68 sn_107 7.564819519239757e-19
Rsub_68_85 sn_68 sn_85 176614.5583512968
Csub_68_85 sn_68 sn_85 5.965806896435067e-17
Rsub_68_86 sn_68 sn_86 23247587.08414169
Csub_68_86 sn_68 sn_86 4.532291228373309e-19
Rsub_68_130 sn_68 sn_130 93248.18928973658
Csub_68_130 sn_68 sn_130 1.129939742796669e-16
Rsub_68_209 sn_68 sn_209 9646946.113463692
Csub_68_209 sn_68 sn_209 1.092209221271054e-18
Rsub_68_212 sn_68 sn_212 402602.0414184527
Csub_68_212 sn_68 sn_212 2.61709639253386e-17
Rsub_68_133 sn_68 sn_133 68026982.99569528
Csub_68_133 sn_68 sn_133 1.548868263479617e-19
Rsub_68_166 sn_68 sn_166 2597926.636599648
Csub_68_166 sn_68 sn_166 4.055727884610669e-18
Rsub_68_157 sn_68 sn_157 492903.6167617964
Csub_68_157 sn_68 sn_157 2.137635664240201e-17
Rsub_68_78 sn_68 sn_78 20243566.24745742
Csub_68_78 sn_68 sn_78 5.204855396243919e-19
Rsub_68_122 sn_68 sn_122 112058.6884608569
Csub_68_122 sn_68 sn_122 9.402647529567058e-17
Rsub_68_92 sn_68 sn_92 23500876.13548273
Csub_68_92 sn_68 sn_92 4.483442847614317e-19
Rsub_68_178 sn_68 sn_178 7318971.064773
Csub_68_178 sn_68 sn_178 1.439612673555063e-18
Rsub_68_101 sn_68 sn_101 1412406.793708394
Csub_68_101 sn_68 sn_101 7.459949604579264e-18
Rsub_68_97 sn_68 sn_97 8817586.294768665
Csub_68_97 sn_68 sn_97 1.194939652417253e-18
Rsub_68_140 sn_68 sn_140 9399564.9474495
Csub_68_140 sn_68 sn_140 1.120954380456618e-18
Rsub_68_219 sn_68 sn_219 7038066.338727342
Csub_68_219 sn_68 sn_219 1.497070785515679e-18
Rsub_68_199 sn_68 sn_199 26980708.58281166
Csub_68_199 sn_68 sn_199 3.905191544503162e-19
Rsub_68_221 sn_68 sn_221 6643250.419945066
Csub_68_221 sn_68 sn_221 1.586043402879449e-18
Rsub_68_75 sn_68 sn_75 8702298.337311715
Csub_68_75 sn_68 sn_75 1.210770200448551e-18
Rsub_68_158 sn_68 sn_158 297042.8701073864
Csub_68_158 sn_68 sn_158 3.547125537273751e-17
Rsub_147_215 sn_147 sn_215 1710201.78390202
Csub_147_215 sn_147 sn_215 6.160959251363786e-18
Rsub_147_181 sn_147 sn_181 1367325.989441225
Csub_147_181 sn_147 sn_181 7.705904505286168e-18
Rsub_147_210 sn_147 sn_210 11312233.36995756
Csub_147_210 sn_147 sn_210 9.314238097502693e-19
Rsub_147_195 sn_147 sn_195 20334711.80953709
Csub_147_195 sn_147 sn_195 5.181525856338093e-19
Rsub_147_172 sn_147 sn_172 1939121.964573937
Csub_147_172 sn_147 sn_172 5.43363630278154e-18
Rsub_147_150 sn_147 sn_150 1773969.582796866
Csub_147_150 sn_147 sn_150 5.939495019761292e-18
Rsub_147_177 sn_147 sn_177 592981.0501417336
Csub_147_177 sn_147 sn_177 1.776866815509802e-17
Rsub_147_169 sn_147 sn_169 72164.58071694247
Csub_147_169 sn_147 sn_169 1.460063011182478e-16
Rsub_147_152 sn_147 sn_152 243642.679618187
Csub_147_152 sn_147 sn_152 4.324563955191164e-17
Rsub_147_189 sn_147 sn_189 2385.61638270808
Csub_147_189 sn_147 sn_189 4.41667133852816e-15
Rsub_147_192 sn_147 sn_192 1964305.366711261
Csub_147_192 sn_147 sn_192 5.363974298899724e-18
Rsub_147_155 sn_147 sn_155 1423692.090704434
Csub_147_155 sn_147 sn_155 7.400816209505396e-18
Rsub_147_159 sn_147 sn_159 2420.054638633787
Csub_147_159 sn_147 sn_159 4.35382050224215e-15
Rsub_147_151 sn_147 sn_151 116347.8457494606
Csub_147_151 sn_147 sn_151 9.05601941691202e-17
Rsub_147_185 sn_147 sn_185 43758.85729183818
Csub_147_185 sn_147 sn_185 2.40785161092295e-16
Rsub_147_165 sn_147 sn_165 10069.18269581828
Csub_147_165 sn_147 sn_165 1.046409010594851e-15
Rsub_147_161 sn_147 sn_161 5029.746278717686
Csub_147_161 sn_147 sn_161 2.094833997256067e-15
Rsub_147_221 sn_147 sn_221 2937268.100332656
Csub_147_221 sn_147 sn_221 3.587171188437551e-18
Rsub_147_156 sn_147 sn_156 60562.51781834417
Csub_147_156 sn_147 sn_156 1.739769725861453e-16
Rsub_147_230 sn_147 0 177367.8720015634
Csub_147_230 sn_147 0 5.940469028199833e-17
Rsub_147_183 sn_147 sn_183 343978.1788553263
Csub_147_183 sn_147 sn_183 3.063125555607275e-17
Rsub_147_157 sn_147 sn_157 143335.3316173236
Csub_147_157 sn_147 sn_157 7.350932518410942e-17
Rsub_147_154 sn_147 sn_154 145821.7485747496
Csub_147_154 sn_147 sn_154 7.225591247679288e-17
Rsub_147_191 sn_147 sn_191 14102705.19690136
Csub_147_191 sn_147 sn_191 7.471249916324616e-19
Rsub_149_159 sn_149 sn_159 1228510.257938634
Csub_149_159 sn_149 sn_159 8.576634532876903e-18
Rsub_149_165 sn_149 sn_165 162066.0684208748
Csub_149_165 sn_149 sn_165 6.501350717577386e-17
Rsub_149_219 sn_149 sn_219 10166518.39104088
Csub_149_219 sn_149 sn_219 1.036390541674045e-18
Rsub_149_225 sn_149 sn_225 1409173.531164904
Csub_149_225 sn_149 sn_225 7.47706600302089e-18
Rsub_149_151 sn_149 sn_151 60298.30116818516
Csub_149_151 sn_149 sn_151 1.747393093686245e-16
Rsub_149_222 sn_149 sn_222 5131451.887226749
Csub_149_222 sn_149 sn_222 2.053314292677575e-18
Rsub_149_157 sn_149 sn_157 49102.25570530783
Csub_149_157 sn_149 sn_157 2.145824738778963e-16
Rsub_149_174 sn_149 sn_174 82798807.1197135
Csub_149_174 sn_149 sn_174 1.272540495299162e-19
Rsub_149_152 sn_149 sn_152 7226.531218516345
Csub_149_152 sn_149 sn_152 1.458027812186386e-15
Rsub_149_177 sn_149 sn_177 89052.12857528255
Csub_149_177 sn_149 sn_177 1.183181544427959e-16
Rsub_149_200 sn_149 sn_200 9205550.041607916
Csub_149_200 sn_149 sn_200 1.144579460717332e-18
Rsub_149_163 sn_149 sn_163 5599906.399659099
Csub_149_163 sn_149 sn_163 1.881546359930484e-18
Rsub_149_206 sn_149 sn_206 6879917.612457327
Csub_149_206 sn_149 sn_206 1.531483964742805e-18
Rsub_149_161 sn_149 sn_161 117404.1410348996
Csub_149_161 sn_149 sn_161 8.974541621234571e-17
Rsub_149_175 sn_149 sn_175 337698.207605547
Csub_149_175 sn_149 sn_175 3.120088666427654e-17
Rsub_149_195 sn_149 sn_195 5143956.742423589
Csub_149_195 sn_149 sn_195 2.04832272700367e-18
Rsub_149_158 sn_149 sn_158 3243972.917320042
Csub_149_158 sn_149 sn_158 3.24801833146454e-18
Rsub_149_215 sn_149 sn_215 5038723.004373645
Csub_149_215 sn_149 sn_215 2.091101950451387e-18
Rsub_217_228 sn_217 sn_228 105121718.5473826
Csub_217_228 sn_217 sn_228 1.002312714044984e-19
Rsub_217_218 sn_217 sn_218 385101.8396520984
Csub_217_218 sn_217 sn_218 2.736025232117477e-17
Rsub_217_227 sn_217 sn_227 166297.6696711245
Csub_217_227 sn_217 sn_227 6.335917708929586e-17
Rsub_217_225 sn_217 sn_225 154577.8175365657
Csub_217_225 sn_217 sn_225 6.816297234716472e-17
Rsub_217_221 sn_217 sn_221 988598.4353335683
Csub_217_221 sn_217 sn_221 1.065800139434252e-17
Rsub_217_219 sn_217 sn_219 1890879.783526395
Csub_217_219 sn_217 sn_219 5.57226514029358e-18
Rsub_217_220 sn_217 sn_220 1106.595101531988
Csub_217_220 sn_217 sn_220 9.521534559156392e-15
Rsub_217_229 sn_217 sn_229 52371.19174646118
Csub_217_229 sn_217 sn_229 2.011885380275306e-16
Rsub_217_222 sn_217 sn_222 517161.2482759449
Csub_217_222 sn_217 sn_222 2.037369106319425e-17
Rsub_217_230 sn_217 0 7379.706401023336
Csub_217_230 sn_217 0 1.427764592473343e-15
Rsub_217_223 sn_217 sn_223 491282.978452778
Csub_217_223 sn_217 sn_223 2.144687270748332e-17
Rsub_50_119 sn_50 sn_119 72327167.51028185
Csub_50_119 sn_50 sn_119 1.456780883992472e-19
Rsub_50_81 sn_50 sn_81 43150853.82905531
Csub_50_81 sn_50 sn_81 2.441778682751195e-19
Rsub_50_196 sn_50 sn_196 33106980.88238791
Csub_50_196 sn_50 sn_196 3.182556434143213e-19
Rsub_50_205 sn_50 sn_205 42803251.43354284
Csub_50_205 sn_50 sn_205 2.461608207168362e-19
Rsub_50_64 sn_50 sn_64 181026689.030463
Csub_50_64 sn_50 sn_64 5.820403366299723e-20
Rsub_50_134 sn_50 sn_134 67085224.85508936
Csub_50_134 sn_50 sn_134 1.570611639893856e-19
Rsub_50_193 sn_50 sn_193 71587508.3238679
Csub_50_193 sn_50 sn_193 1.471832691055828e-19
Rsub_50_203 sn_50 sn_203 28507596.0488168
Csub_50_203 sn_50 sn_203 3.696026660468734e-19
Rsub_50_208 sn_50 sn_208 30921791.15923227
Csub_50_208 sn_50 sn_208 3.407462215876244e-19
Rsub_50_184 sn_50 sn_184 25743033.29593106
Csub_50_184 sn_50 sn_184 4.092945606334355e-19
Rsub_50_166 sn_50 sn_166 29827220.52021964
Csub_50_166 sn_50 sn_166 3.532505985627257e-19
Rsub_50_103 sn_50 sn_103 31057333.4341798
Csub_50_103 sn_50 sn_103 3.392591165162362e-19
Rsub_50_197 sn_50 sn_197 179770062.7015904
Csub_50_197 sn_50 sn_197 5.861089073390407e-20
Rsub_50_83 sn_50 sn_83 79235925.51989758
Csub_50_83 sn_50 sn_83 1.329760892309398e-19
Rsub_50_192 sn_50 sn_192 76935092.49586445
Csub_50_192 sn_50 sn_192 1.369528931520603e-19
Rsub_50_88 sn_50 sn_88 74977772.49480414
Csub_50_88 sn_50 sn_88 1.405280945490901e-19
Rsub_50_160 sn_50 sn_160 58466170.74745667
Csub_50_160 sn_50 sn_160 1.802150434606383e-19
Rsub_50_151 sn_50 sn_151 88639726.09406142
Csub_50_151 sn_50 sn_151 1.188686378729222e-19
Rsub_50_116 sn_50 sn_116 132443604.6356177
Csub_50_116 sn_50 sn_116 7.955449061672893e-20
Rsub_50_137 sn_50 sn_137 99733765.69224726
Csub_50_137 sn_50 sn_137 1.056461011884669e-19
Rsub_50_84 sn_50 sn_84 182496721.7069907
Csub_50_84 sn_50 sn_84 5.773519328827697e-20
Rsub_50_168 sn_50 sn_168 815787413.8634136
Csub_50_168 sn_50 sn_168 1.291572206579067e-20
Rsub_50_211 sn_50 sn_211 38088404.21742525
Csub_50_211 sn_50 sn_211 2.766323168091566e-19
Rsub_50_179 sn_50 sn_179 40150029.39019174
Csub_50_179 sn_50 sn_179 2.624277905212184e-19
Rsub_50_69 sn_50 sn_69 180582453.8493738
Csub_50_69 sn_50 sn_69 5.834721634150912e-20
Rsub_50_210 sn_50 sn_210 15019793.59059854
Csub_50_210 sn_50 sn_210 7.015065445922765e-19
Rsub_50_214 sn_50 sn_214 20121320.56536105
Csub_50_214 sn_50 sn_214 5.236477132802413e-19
Rsub_50_91 sn_50 sn_91 31343338.14737882
Csub_50_91 sn_50 sn_91 3.361634122277158e-19
Rsub_50_122 sn_50 sn_122 19960171.46798404
Csub_50_122 sn_50 sn_122 5.278754002254158e-19
Rsub_50_202 sn_50 sn_202 28326791.05080615
Csub_50_202 sn_50 sn_202 3.719617758090585e-19
Rsub_50_71 sn_50 sn_71 25508478.87572845
Csub_50_71 sn_50 sn_71 4.130580876092756e-19
Rsub_50_68 sn_50 sn_68 47811235.98046381
Csub_50_68 sn_50 sn_68 2.203767228802728e-19
Rsub_50_146 sn_50 sn_146 88838084.44518645
Csub_50_146 sn_50 sn_146 1.186032270735313e-19
Rsub_50_190 sn_50 sn_190 61483058.07998416
Csub_50_190 sn_50 sn_190 1.71372144315316e-19
Rsub_50_82 sn_50 sn_82 29403967.40455303
Csub_50_82 sn_50 sn_82 3.583354367546499e-19
Rsub_50_194 sn_50 sn_194 181799997.5405384
Csub_50_194 sn_50 sn_194 5.795645569181342e-20
Rsub_50_161 sn_50 sn_161 129220555.0841093
Csub_50_161 sn_50 sn_161 8.153875747842e-20
Rsub_50_80 sn_50 sn_80 2393389.106062802
Csub_50_80 sn_50 sn_80 4.402327843617052e-18
Rsub_50_124 sn_50 sn_124 118933795.5148379
Csub_50_124 sn_50 sn_124 8.859116499746698e-20
Rsub_50_183 sn_50 sn_183 133812936.7884384
Csub_50_183 sn_50 sn_183 7.874039502539612e-20
Rsub_50_112 sn_50 sn_112 17104248.40754362
Csub_50_112 sn_50 sn_112 6.160155799411224e-19
Rsub_50_107 sn_50 sn_107 22041014.21204634
Csub_50_107 sn_50 sn_107 4.780398669890322e-19
Rsub_50_158 sn_50 sn_158 26001546.05513979
Csub_50_158 sn_50 sn_158 4.05225269293063e-19
Rsub_50_150 sn_50 sn_150 14502286.7885315
Csub_50_150 sn_50 sn_150 7.265394524236219e-19
Rsub_50_156 sn_50 sn_156 51891676.06310226
Csub_50_156 sn_50 sn_156 2.030476620068551e-19
Rsub_50_100 sn_50 sn_100 31412114.5207806
Csub_50_100 sn_50 sn_100 3.3542738726677e-19
Rsub_50_75 sn_50 sn_75 39660130.6739268
Csub_50_75 sn_50 sn_75 2.656694096360316e-19
Rsub_50_212 sn_50 sn_212 12135019.56750382
Csub_50_212 sn_50 sn_212 8.682708291996075e-19
Rsub_50_132 sn_50 sn_132 12152487.35022996
Csub_50_132 sn_50 sn_132 8.670227911844418e-19
Rsub_50_54 sn_50 sn_54 41035959.54979463
Csub_50_54 sn_50 sn_54 2.567622060706201e-19
Rsub_50_189 sn_50 sn_189 13561601.28088585
Csub_50_189 sn_50 sn_189 7.769350598059871e-19
Rsub_50_85 sn_50 sn_85 29011508.43598738
Csub_50_85 sn_50 sn_85 3.631828908682321e-19
Rsub_50_128 sn_50 sn_128 22512119.13343138
Csub_50_128 sn_50 sn_128 4.680360582573016e-19
Rsub_50_217 sn_50 sn_217 14403939.02842118
Csub_50_217 sn_50 sn_217 7.31500145997557e-19
Rsub_50_188 sn_50 sn_188 14885139.3515281
Csub_50_188 sn_50 sn_188 7.078525268322956e-19
Rsub_50_174 sn_50 sn_174 10881510.88992961
Csub_50_174 sn_50 sn_174 9.682923271235326e-19
Rsub_50_114 sn_50 sn_114 13993136.96834297
Csub_50_114 sn_50 sn_114 7.529750852912362e-19
Rsub_50_153 sn_50 sn_153 689123.520167299
Csub_50_153 sn_50 sn_153 1.528968783371674e-17
Rsub_50_186 sn_50 sn_186 34024697.78132467
Csub_50_186 sn_50 sn_186 3.096716264740262e-19
Rsub_50_130 sn_50 sn_130 4983627.463101413
Csub_50_130 sn_50 sn_130 2.11421972854948e-18
Rsub_50_199 sn_50 sn_199 10866741.30537967
Csub_50_199 sn_50 sn_199 9.69608386371895e-19
Rsub_50_138 sn_50 sn_138 1104159.98628316
Csub_50_138 sn_50 sn_138 9.542533358501854e-18
Rsub_50_204 sn_50 sn_204 3556013.396665901
Csub_50_204 sn_50 sn_204 2.963004445401964e-18
Rsub_50_125 sn_50 sn_125 51657794.29993734
Csub_50_125 sn_50 sn_125 2.039669646182083e-19
Rsub_50_105 sn_50 sn_105 2378467.523567485
Csub_50_105 sn_50 sn_105 4.429946340585821e-18
Rsub_50_195 sn_50 sn_195 920480.6086770335
Csub_50_195 sn_50 sn_195 1.144671968415894e-17
Rsub_50_110 sn_50 sn_110 359245.6430715701
Csub_50_110 sn_50 sn_110 2.932946774842552e-17
Rsub_50_76 sn_50 sn_76 347768.7784560496
Csub_50_76 sn_50 sn_76 3.02973819242994e-17
Rsub_50_155 sn_50 sn_155 1271529.76164425
Csub_50_155 sn_50 sn_155 8.286462354294398e-18
Rsub_50_99 sn_50 sn_99 1147973.670660042
Csub_50_99 sn_50 sn_99 9.178332022346748e-18
Rsub_50_170 sn_50 sn_170 1162160.592960058
Csub_50_170 sn_50 sn_170 9.066288743617833e-18
Rsub_50_133 sn_50 sn_133 6611411.723636069
Csub_50_133 sn_50 sn_133 1.593681341091138e-18
Rsub_50_72 sn_50 sn_72 3354148.998213807
Csub_50_72 sn_50 sn_72 3.141328398899697e-18
Rsub_50_230 sn_50 0 191250.2538880311
Csub_50_230 sn_50 0 5.509265105811921e-17
Rsub_50_131 sn_50 sn_131 86594.88862676969
Csub_50_131 sn_50 sn_131 1.216755823503974e-16
Rsub_50_52 sn_50 sn_52 20915.09069255898
Csub_50_52 sn_50 sn_52 5.03774220112686e-16
Rsub_50_227 sn_50 sn_227 44877205.1315809
Csub_50_227 sn_50 sn_227 2.347847525561543e-19
Rsub_50_60 sn_50 sn_60 22923082.33178943
Csub_50_60 sn_50 sn_60 4.596451449994639e-19
Rsub_50_139 sn_50 sn_139 17027318.39333478
Csub_50_139 sn_50 sn_139 6.187987596657871e-19
Rsub_50_51 sn_50 sn_51 1375751.245863275
Csub_50_51 sn_50 sn_51 7.658712673466217e-18
Rsub_50_218 sn_50 sn_218 34401706.85213001
Csub_50_218 sn_50 sn_218 3.062779282295299e-19
Rsub_50_97 sn_50 sn_97 388186.7979057984
Csub_50_97 sn_50 sn_97 2.714281773381406e-17
Rsub_50_200 sn_50 sn_200 2549916.914818506
Csub_50_200 sn_50 sn_200 4.13208894807459e-18
Rsub_50_86 sn_50 sn_86 17911700.96762132
Csub_50_86 sn_50 sn_86 5.882458355728821e-19
Rsub_50_165 sn_50 sn_165 24175781.67983208
Csub_50_165 sn_50 sn_165 4.358280382313241e-19
Rsub_50_129 sn_50 sn_129 160859.5587996598
Csub_50_129 sn_50 sn_129 6.550113391366758e-17
Rsub_50_78 sn_50 sn_78 1210338.372499072
Csub_50_78 sn_50 sn_78 8.70540316793772e-18
Rsub_50_157 sn_50 sn_157 13610925.94228062
Csub_50_157 sn_50 sn_157 7.741195233088257e-19
Rsub_50_67 sn_50 sn_67 107023.750652398
Csub_50_67 sn_50 sn_67 9.844995562201335e-17
Rsub_50_201 sn_50 sn_201 8736552.739211641
Csub_50_201 sn_50 sn_201 1.20602299519579e-18
Rsub_50_90 sn_50 sn_90 56011774.4772475
Csub_50_90 sn_50 sn_90 1.88111938972939e-19
Rsub_50_169 sn_50 sn_169 11819742.28022014
Csub_50_169 sn_50 sn_169 8.914309003050241e-19
Rsub_50_225 sn_50 sn_225 12300494.34079521
Csub_50_225 sn_50 sn_225 8.565902483516636e-19
Rsub_50_58 sn_50 sn_58 41858896.44631168
Csub_50_58 sn_50 sn_58 2.517143163519401e-19
Rsub_50_206 sn_50 sn_206 3593738.381609823
Csub_50_206 sn_50 sn_206 2.931900540158452e-18
Rsub_50_127 sn_50 sn_127 9493494.586422207
Csub_50_127 sn_50 sn_127 1.10986353932297e-18
Rsub_50_171 sn_50 sn_171 10838669.11641718
Csub_50_171 sn_50 sn_171 9.721196753087085e-19
Rsub_50_141 sn_50 sn_141 3448523.57180192
Csub_50_141 sn_50 sn_141 3.05536073129536e-18
Rsub_50_191 sn_50 sn_191 130597140.4856351
Csub_50_191 sn_50 sn_191 8.067928182079113e-20
Rsub_50_181 sn_50 sn_181 3558719.924768248
Csub_50_181 sn_50 sn_181 2.960750979276955e-18
Rsub_50_185 sn_50 sn_185 164320497.4929656
Csub_50_185 sn_50 sn_185 6.412154090928953e-20
Rsub_50_77 sn_50 sn_77 5532429.612331539
Csub_50_77 sn_50 sn_77 1.904494813407955e-18
Rsub_50_144 sn_50 sn_144 181799997.5405384
Csub_50_144 sn_50 sn_144 5.795645569181342e-20
Rsub_50_55 sn_50 sn_55 227014379.4890094
Csub_50_55 sn_50 sn_55 4.641328679683972e-20
Rsub_50_222 sn_50 sn_222 840912.3690706068
Csub_50_222 sn_50 sn_222 1.252982342723194e-17
Rsub_50_177 sn_50 sn_177 1967551.943079897
Csub_50_177 sn_50 sn_177 5.355123425985274e-18
Rsub_50_220 sn_50 sn_220 56303337.36294825
Csub_50_220 sn_50 sn_220 1.87137814483512e-19
Rsub_50_53 sn_50 sn_53 15826773.09138663
Csub_50_53 sn_50 sn_53 6.657379518484563e-19
Rsub_50_126 sn_50 sn_126 10198812.68783797
Csub_50_126 sn_50 sn_126 1.033108835776021e-18
Rsub_50_62 sn_50 sn_62 18291539.48874577
Csub_50_62 sn_50 sn_62 5.760304379362262e-19
Rsub_50_229 sn_50 sn_229 15683558.10363204
Csub_50_229 sn_50 sn_229 6.718171624454233e-19
Rsub_50_79 sn_50 sn_79 51099769.13209837
Csub_50_79 sn_50 sn_79 2.061943464948357e-19
Rsub_50_154 sn_50 sn_154 45212287.70660309
Csub_50_154 sn_50 sn_154 2.330446884396692e-19
Rsub_50_59 sn_50 sn_59 35976374.27697855
Csub_50_59 sn_50 sn_59 2.928723006134708e-19
Rsub_50_226 sn_50 sn_226 5209849.047733221
Csub_50_226 sn_50 sn_226 2.022416274577931e-18
Rsub_50_215 sn_50 sn_215 5850838.350712898
Csub_50_215 sn_50 sn_215 1.800850215071517e-18
Rsub_50_93 sn_50 sn_93 32099362.6072094
Csub_50_93 sn_50 sn_93 3.282458792457001e-19
Rsub_50_172 sn_50 sn_172 60500473.15752902
Csub_50_172 sn_50 sn_172 1.741553900710078e-19
Rsub_50_117 sn_50 sn_117 18489862.02175094
Csub_50_117 sn_50 sn_117 5.698519269551708e-19
Rsub_50_57 sn_50 sn_57 49462403.57831945
Csub_50_57 sn_50 sn_57 2.13020046337748e-19
Rsub_50_224 sn_50 sn_224 60513831.66301592
Csub_50_224 sn_50 sn_224 1.74116945046624e-19
Rsub_50_66 sn_50 sn_66 12761421.13762114
Csub_50_66 sn_50 sn_66 8.256512647457468e-19
Rsub_50_162 sn_50 sn_162 45225731.47336057
Csub_50_162 sn_50 sn_162 2.32975413751712e-19
Rsub_50_148 sn_50 sn_148 36621902.60757694
Csub_50_148 sn_50 sn_148 2.87709888127168e-19
Rsub_50_159 sn_50 sn_159 10354331.1883462
Csub_50_159 sn_50 sn_159 1.017591895658969e-18
Rsub_50_89 sn_50 sn_89 82011722.79121548
Csub_50_89 sn_50 sn_89 1.284753343013372e-19
Rsub_50_109 sn_50 sn_109 85977377.46953148
Csub_50_109 sn_50 sn_109 1.22549486996901e-19
Rsub_50_175 sn_50 sn_175 14012456.78187692
Csub_50_175 sn_50 sn_175 7.519369134367226e-19
Rsub_50_61 sn_50 sn_61 765261.4531736583
Csub_50_61 sn_50 sn_61 1.376847541259731e-17
Rsub_50_228 sn_50 sn_228 65608933.79596993
Csub_50_228 sn_50 sn_228 1.60595255746668e-19
Rsub_50_198 sn_50 sn_198 5739901.751592016
Csub_50_198 sn_50 sn_198 1.835655723428996e-18
Rsub_189_207 sn_189 sn_207 9583362.84806728
Csub_189_207 sn_189 sn_207 1.099455761956769e-18
Rsub_189_220 sn_189 sn_220 175580.5034261159
Csub_189_220 sn_189 sn_220 6.000941617452271e-17
Rsub_189_214 sn_189 sn_214 4759046.730023987
Csub_189_214 sn_189 sn_214 2.213990343014954e-18
Rsub_189_224 sn_189 sn_224 7093953.740729555
Csub_189_224 sn_189 sn_224 1.485276601359175e-18
Rsub_189_199 sn_189 sn_199 62342628.4938356
Csub_189_199 sn_189 sn_199 1.690092919850475e-19
Rsub_189_198 sn_189 sn_198 4631321.922473622
Csub_189_198 sn_189 sn_198 2.275048825930543e-18
Rsub_189_227 sn_189 sn_227 824281.121671887
Csub_189_227 sn_189 sn_227 1.278263352781741e-17
Rsub_189_210 sn_189 sn_210 3682293.377016385
Csub_189_210 sn_189 sn_210 2.861391644673161e-18
Rsub_189_228 sn_189 sn_228 25936120.72821254
Csub_189_228 sn_189 sn_228 4.062474728832029e-19
Rsub_189_191 sn_189 sn_191 12554617.51339715
Csub_189_191 sn_189 sn_191 8.392516531058329e-19
Rsub_189_206 sn_189 sn_206 4185893.911480851
Csub_189_206 sn_189 sn_206 2.517140597694339e-18
Rsub_189_193 sn_189 sn_193 8940282.520115357
Csub_189_193 sn_189 sn_193 1.178540328957529e-18
Rsub_189_230 sn_189 0 31075.29973902077
Csub_189_230 sn_189 0 3.390629725447025e-16
Rsub_189_215 sn_189 sn_215 748396.1315780481
Csub_189_215 sn_189 sn_215 1.407875195721957e-17
Rsub_189_195 sn_189 sn_195 2078064.666014224
Csub_189_195 sn_189 sn_195 5.070334756443948e-18
Rsub_189_192 sn_189 sn_192 10662336.31631513
Csub_189_192 sn_189 sn_192 9.881965068113115e-19
Rsub_189_229 sn_189 sn_229 529320.4534423584
Csub_189_229 sn_189 sn_229 1.990567988391062e-17
Rsub_189_222 sn_189 sn_222 608468.4537367682
Csub_189_222 sn_189 sn_222 1.731640060798982e-17
Rsub_189_205 sn_189 sn_205 1657027.573233082
Csub_189_205 sn_189 sn_205 6.358665161903077e-18
Rsub_189_216 sn_189 sn_216 117824.3518873038
Csub_189_216 sn_189 sn_216 8.942534657273482e-17
Rsub_189_218 sn_189 sn_218 1212349.87077973
Csub_189_218 sn_189 sn_218 8.690959397268216e-18
Rsub_22_105 sn_22 sn_105 41140081.71608978
Csub_22_105 sn_22 sn_105 2.561123620255039e-19
Rsub_22_38 sn_22 sn_38 28688465.48481721
Csub_22_38 sn_22 sn_38 3.672724673198789e-19
Rsub_22_78 sn_22 sn_78 44924391.25719272
Csub_22_78 sn_22 sn_78 2.345381474822551e-19
Rsub_22_72 sn_22 sn_72 44924391.25719272
Csub_22_72 sn_22 sn_72 2.345381474822551e-19
Rsub_22_140 sn_22 sn_140 12282200.0841749
Csub_22_140 sn_22 sn_140 8.578661339189401e-19
Rsub_22_152 sn_22 sn_152 103917879.3579374
Csub_22_152 sn_22 sn_152 1.013924029948482e-19
Rsub_22_69 sn_22 sn_69 38968182.77228519
Csub_22_69 sn_22 sn_69 2.703868323498965e-19
Rsub_22_71 sn_22 sn_71 28875817.79205953
Csub_22_71 sn_22 sn_71 3.648895272198107e-19
Rsub_22_76 sn_22 sn_76 9353381424.656857
Rsub_22_185 sn_22 sn_185 91153740.62513769
Csub_22_185 sn_22 sn_185 1.155902481891602e-19
Rsub_22_154 sn_22 sn_154 30238187.6913153
Csub_22_154 sn_22 sn_154 3.48449570119448e-19
Rsub_22_187 sn_22 sn_187 45576870.31256884
Csub_22_187 sn_22 sn_187 2.311804963783204e-19
Rsub_22_101 sn_22 sn_101 45576870.31256884
Csub_22_101 sn_22 sn_101 2.311804963783204e-19
Rsub_22_79 sn_22 sn_79 45173694.37645846
Csub_22_79 sn_22 sn_79 2.33243785961436e-19
Rsub_22_161 sn_22 sn_161 15060827.04029155
Csub_22_161 sn_22 sn_161 6.995952794652129e-19
Rsub_22_61 sn_22 sn_61 41086375.62817303
Csub_22_61 sn_22 sn_61 2.564471394990876e-19
Rsub_22_42 sn_22 sn_42 78949965.70051029
Csub_22_42 sn_22 sn_42 1.33457733752529e-19
Rsub_22_180 sn_22 sn_180 44634400.56591445
Csub_22_180 sn_22 sn_180 2.360619470327625e-19
Rsub_22_82 sn_22 sn_82 18890543.38063328
Csub_22_82 sn_22 sn_82 5.577649774242111e-19
Rsub_22_169 sn_22 sn_169 35303419.86437873
Csub_22_169 sn_22 sn_169 2.9845503757729e-19
Rsub_22_165 sn_22 sn_165 12958998.97922724
Csub_22_165 sn_22 sn_165 8.130630706213933e-19
Rsub_22_159 sn_22 sn_159 43474437.80080135
Csub_22_159 sn_22 sn_159 2.423604314449763e-19
Rsub_22_112 sn_22 sn_112 751191906.4521743
Csub_22_112 sn_22 sn_112 1.402635386740661e-20
Rsub_22_66 sn_22 sn_66 39736108.63422685
Csub_22_66 sn_22 sn_66 2.651614328725274e-19
Rsub_22_184 sn_22 sn_184 5029730.995896709
Csub_22_184 sn_22 sn_184 2.094840362402232e-18
Rsub_22_177 sn_22 sn_177 6445786.338948661
Csub_22_177 sn_22 sn_177 1.634631206834037e-18
Rsub_22_139 sn_22 sn_139 8069317.906625678
Csub_22_139 sn_22 sn_139 1.305746486153253e-18
Rsub_22_41 sn_22 sn_41 709241.0176117443
Csub_22_41 sn_22 sn_41 1.485599851191619e-17
Rsub_22_208 sn_22 sn_208 7666951.210191782
Csub_22_208 sn_22 sn_208 1.374272929795577e-18
Rsub_22_128 sn_22 sn_128 7087065.048148329
Csub_22_128 sn_22 sn_128 1.486720303912396e-18
Rsub_22_162 sn_22 sn_162 11692913.79835051
Csub_22_162 sn_22 sn_162 9.010999040903181e-19
Rsub_22_110 sn_22 sn_110 45407709.07598985
Csub_22_110 sn_22 sn_110 2.320417329268293e-19
Rsub_22_53 sn_22 sn_53 12055946.45158118
Csub_22_53 sn_22 sn_53 8.73965685277916e-19
Rsub_22_220 sn_22 sn_220 15091479.69703004
Csub_22_220 sn_22 sn_220 6.98174315160332e-19
Rsub_22_135 sn_22 sn_135 20340029.80508431
Csub_22_135 sn_22 sn_135 5.18017112226465e-19
Rsub_22_131 sn_22 sn_131 11549783.39942727
Csub_22_131 sn_22 sn_131 9.122667618816546e-19
Rsub_22_181 sn_22 sn_181 15612866.49092018
Csub_22_181 sn_22 sn_181 6.748590022439249e-19
Rsub_22_87 sn_22 sn_87 5331003.630535225
Csub_22_87 sn_22 sn_87 1.976454009875089e-18
Rsub_22_57 sn_22 sn_57 43703614.71542346
Csub_22_57 sn_22 sn_57 2.410895201881681e-19
Rsub_22_224 sn_22 sn_224 4096054.738975285
Csub_22_224 sn_22 sn_224 2.572349290641054e-18
Rsub_22_97 sn_22 sn_97 1951245.48189505
Csub_22_97 sn_22 sn_97 5.399875925399692e-18
Rsub_22_114 sn_22 sn_114 9604885.325239889
Csub_22_114 sn_22 sn_114 1.096992118640088e-18
Rsub_22_24 sn_22 sn_24 83270276.28049764
Csub_22_24 sn_22 sn_24 1.265335480182345e-19
Rsub_22_50 sn_22 sn_50 38439671.81678582
Csub_22_50 sn_22 sn_50 2.741044083947911e-19
Rsub_22_217 sn_22 sn_217 8284991.683878866
Csub_22_217 sn_22 sn_217 1.271755471128854e-18
Rsub_22_138 sn_22 sn_138 186728.3744519729
Csub_22_138 sn_22 sn_138 5.642679390935318e-17
Rsub_22_63 sn_22 sn_63 11186170.70799396
Csub_22_63 sn_22 sn_63 9.419204996308816e-19
Rsub_22_230 sn_22 0 140523.9492343813
Csub_22_230 sn_22 0 7.497998426343748e-17
Rsub_22_132 sn_22 sn_132 5057094.706730946
Csub_22_132 sn_22 sn_132 2.083505275905955e-18
Rsub_22_133 sn_22 sn_133 3526818.355238025
Csub_22_133 sn_22 sn_133 2.987532229036188e-18
Rsub_22_150 sn_22 sn_150 9057475.629141863
Csub_22_150 sn_22 sn_150 1.163291399684204e-18
Rsub_22_28 sn_22 sn_28 76195054.13336669
Csub_22_28 sn_22 sn_28 1.382830371612789e-19
Rsub_22_195 sn_22 sn_195 17462220.60880223
Csub_22_195 sn_22 sn_195 6.033873777152284e-19
Rsub_22_134 sn_22 sn_134 24340580.05108786
Csub_22_134 sn_22 sn_134 4.32877256010959e-19
Rsub_22_47 sn_22 sn_47 44924391.25719272
Csub_22_47 sn_22 sn_47 2.345381474822551e-19
Rsub_22_214 sn_22 sn_214 2397562.951956304
Csub_22_214 sn_22 sn_214 4.394663962267477e-18
Rsub_22_144 sn_22 sn_144 588173.534756306
Csub_22_144 sn_22 sn_144 1.791390275081913e-17
Rsub_22_51 sn_22 sn_51 3982133.013117024
Csub_22_51 sn_22 sn_51 2.645939617668006e-18
Rsub_22_218 sn_22 sn_218 611979.9359438814
Csub_22_218 sn_22 sn_218 1.721704076127783e-17
Rsub_22_190 sn_22 sn_190 10055037.96469702
Csub_22_190 sn_22 sn_190 1.04788102632962e-18
Rsub_22_23 sn_22 sn_23 1373602.981994356
Csub_22_23 sn_22 sn_23 7.670690614643184e-18
Rsub_22_178 sn_22 sn_178 1764379.531988943
Csub_22_178 sn_22 sn_178 5.971778356753253e-18
Rsub_22_99 sn_22 sn_99 7514826.381708645
Csub_22_99 sn_22 sn_99 1.402092738679389e-18
Rsub_22_36 sn_22 sn_36 4244152.367790071
Csub_22_36 sn_22 sn_36 2.482588415579515e-18
Rsub_22_203 sn_22 sn_203 502517.5388139679
Csub_22_203 sn_22 sn_203 2.096739454526901e-17
Rsub_22_212 sn_22 sn_212 305570.4151975407
Csub_22_212 sn_22 sn_212 3.448136003421184e-17
Rsub_22_45 sn_22 sn_45 1993658.576486155
Csub_22_45 sn_22 sn_45 5.284998959451056e-18
Rsub_22_166 sn_22 sn_166 469347.7392898515
Csub_22_166 sn_22 sn_166 2.244920475844257e-17
Rsub_22_202 sn_22 sn_202 4101736.513719078
Csub_22_202 sn_22 sn_202 2.568786041470149e-18
Rsub_22_35 sn_22 sn_35 1448641.518480628
Csub_22_35 sn_22 sn_35 7.273354634541289e-18
Rsub_22_213 sn_22 sn_213 302975.6280823722
Csub_22_213 sn_22 sn_213 3.477667021904933e-17
Rsub_22_46 sn_22 sn_46 1373985.722201046
Csub_22_46 sn_22 sn_46 7.668553851746847e-18
Rsub_22_125 sn_22 sn_125 7017259.615148376
Csub_22_125 sn_22 sn_125 1.501509717480677e-18
Rsub_22_222 sn_22 sn_222 16661.13757095546
Csub_22_222 sn_22 sn_222 6.323988057452772e-16
Rsub_22_148 sn_22 sn_148 104367.446776996
Csub_22_148 sn_22 sn_148 1.009556507092055e-16
Rsub_22_60 sn_22 sn_60 44296078.09275647
Csub_22_60 sn_22 sn_60 2.37864929716046e-19
Rsub_22_227 sn_22 sn_227 982782.9008074121
Csub_22_227 sn_22 sn_227 1.072106921434396e-17
Rsub_22_199 sn_22 sn_199 1109504469.152542
Rsub_22_88 sn_22 sn_88 4300254.747396719
Csub_22_88 sn_22 sn_88 2.450199841906706e-18
Rsub_22_142 sn_22 sn_142 513813.4320107534
Csub_22_142 sn_22 sn_142 2.050643841870114e-17
Rsub_22_54 sn_22 sn_54 2112257.638229327
Csub_22_54 sn_22 sn_54 4.988256788155147e-18
Rsub_22_221 sn_22 sn_221 1307782.470245565
Csub_22_221 sn_22 sn_221 8.05675541762809e-18
Rsub_22_211 sn_22 sn_211 1633232.730667415
Csub_22_211 sn_22 sn_211 6.451305624963995e-18
Rsub_22_25 sn_22 sn_25 724175.7763748064
Csub_22_25 sn_22 sn_25 1.454962157803068e-17
Rsub_22_192 sn_22 sn_192 25836.350494301
Csub_22_192 sn_22 sn_192 4.078162472890335e-16
Rsub_22_201 sn_22 sn_201 21970663.82739184
Csub_22_201 sn_22 sn_201 4.795705575856876e-19
Rsub_22_34 sn_22 sn_34 14708192.8891588
Csub_22_34 sn_22 sn_34 7.163683248943718e-19
Rsub_22_40 sn_22 sn_40 23369005.63493427
Csub_22_40 sn_22 sn_40 4.508742762455858e-19
Rsub_22_207 sn_22 sn_207 7587754.423448806
Csub_22_207 sn_22 sn_207 1.388616831044056e-18
Rsub_22_160 sn_22 sn_160 204826.1020214795
Csub_22_160 sn_22 sn_160 5.144111711467844e-17
Rsub_22_27 sn_22 sn_27 78831345.77367158
Csub_22_27 sn_22 sn_27 1.33658551669037e-19
Rsub_22_189 sn_22 sn_189 21940706.08173703
Csub_22_189 sn_22 sn_189 4.802253611610224e-19
Rsub_22_170 sn_22 sn_170 1150282.722909543
Csub_22_170 sn_22 sn_170 9.159907640426745e-18
Rsub_22_31 sn_22 sn_31 28698993.00153357
Csub_22_31 sn_22 sn_31 3.671377424868868e-19
Rsub_22_198 sn_22 sn_198 527883.9589070921
Csub_22_198 sn_22 sn_198 1.995984784997876e-17
Rsub_22_182 sn_22 sn_182 2037694.125570487
Csub_22_182 sn_22 sn_182 5.17078759270611e-18
Rsub_22_103 sn_22 sn_103 1181961.821353794
Csub_22_103 sn_22 sn_103 8.91440257364805e-18
Rsub_22_77 sn_22 sn_77 5723574.816011213
Csub_22_77 sn_22 sn_77 1.840892071988836e-18
Rsub_22_156 sn_22 sn_156 7568642.076586248
Csub_22_156 sn_22 sn_156 1.392123368447404e-18
Rsub_22_196 sn_22 sn_196 1630190.185840704
Csub_22_196 sn_22 sn_196 6.463346175033092e-18
Rsub_22_117 sn_22 sn_117 4639428.606158247
Csub_22_117 sn_22 sn_117 2.27107353009898e-18
Rsub_22_153 sn_22 sn_153 8018662.234702628
Csub_22_153 sn_22 sn_153 1.313995176979885e-18
Rsub_22_58 sn_22 sn_58 3426449.911366257
Csub_22_58 sn_22 sn_58 3.075043784319819e-18
Rsub_22_49 sn_22 sn_49 382441.2685300624
Csub_22_49 sn_22 sn_49 2.755059238959135e-17
Rsub_22_216 sn_22 sn_216 18831657.52120051
Csub_22_216 sn_22 sn_216 5.595090867794362e-19
Rsub_22_137 sn_22 sn_137 11960913.33144443
Csub_22_137 sn_22 sn_137 8.809096103497635e-19
Rsub_22_200 sn_22 sn_200 4033028.272850465
Csub_22_200 sn_22 sn_200 2.612548881236338e-18
Rsub_22_33 sn_22 sn_33 7446352.285856676
Csub_22_33 sn_22 sn_33 1.414985901518869e-18
Rsub_22_52 sn_22 sn_52 53493.89359004648
Csub_22_52 sn_22 sn_52 1.969660982798699e-16
Rsub_22_219 sn_22 sn_219 1682245.381309222
Csub_22_219 sn_22 sn_219 6.263345180968718e-18
Rsub_22_215 sn_22 sn_215 393599.0462987997
Csub_22_215 sn_22 sn_215 2.676958595634212e-17
Rsub_22_48 sn_22 sn_48 1834325.986622173
Csub_22_48 sn_22 sn_48 5.744062712447557e-18
Rsub_22_59 sn_22 sn_59 24473034.59028743
Csub_22_59 sn_22 sn_59 4.305344097544649e-19
Rsub_22_226 sn_22 sn_226 761110.0786889056
Csub_22_226 sn_22 sn_226 1.384357374478634e-17
Rsub_22_206 sn_22 sn_206 3137555.716496007
Csub_22_206 sn_22 sn_206 3.358182118275512e-18
Rsub_22_39 sn_22 sn_39 18794221.27067744
Csub_22_39 sn_22 sn_39 5.606235741551537e-19
Rsub_22_197 sn_22 sn_197 7160533.589872864
Csub_22_197 sn_22 sn_197 1.471466248986212e-18
Rsub_22_158 sn_22 sn_158 3299516.864775789
Csub_22_158 sn_22 sn_158 3.193341308454256e-18
Rsub_22_210 sn_22 sn_210 19997954.91222183
Csub_22_210 sn_22 sn_210 5.268780507046042e-19
Rsub_22_43 sn_22 sn_43 1549638.278462488
Csub_22_43 sn_22 sn_43 6.799318040003523e-18
Rsub_22_186 sn_22 sn_186 2492429.109291919
Csub_22_186 sn_22 sn_186 4.227395460496503e-18
Rsub_22_95 sn_22 sn_95 1905622.667929781
Csub_22_95 sn_22 sn_95 5.529155209764883e-18
Rsub_22_174 sn_22 sn_174 5363997.710985178
Csub_22_174 sn_22 sn_174 1.964296793164519e-18
Rsub_22_93 sn_22 sn_93 1400891.257386762
Csub_22_93 sn_22 sn_93 7.521271509599449e-18
Rsub_22_168 sn_22 sn_168 7711801.112022163
Csub_22_168 sn_22 sn_168 1.366280502981898e-18
Rsub_22_130 sn_22 sn_130 7849483.498073639
Csub_22_130 sn_22 sn_130 1.342315517296875e-18
Rsub_22_80 sn_22 sn_80 45552704.42162898
Csub_22_80 sn_22 sn_80 2.313031385514654e-19
Rsub_22_179 sn_22 sn_179 6053818.771158866
Csub_22_179 sn_22 sn_179 1.740468933828528e-18
Rsub_22_146 sn_22 sn_146 11091049.25133743
Csub_22_146 sn_22 sn_146 9.499988020483677e-19
Rsub_137_183 sn_137 sn_183 329029.5411247934
Csub_137_183 sn_137 sn_183 3.202291036303563e-17
Rsub_137_189 sn_137 sn_189 493544.31168719
Csub_137_189 sn_137 sn_189 2.134860690869042e-17
Rsub_137_230 sn_137 0 19514.91885059761
Csub_137_230 sn_137 0 5.399194115484287e-16
Rsub_137_170 sn_137 sn_170 3996631.832445756
Csub_137_170 sn_137 sn_170 2.636340784930935e-18
Rsub_137_168 sn_137 sn_168 3448860.593583583
Csub_137_168 sn_137 sn_168 3.055062162220344e-18
Rsub_137_175 sn_137 sn_175 766276.2844304392
Csub_137_175 sn_137 sn_175 1.375024089393762e-17
Rsub_137_211 sn_137 sn_211 9148024.120866196
Csub_137_211 sn_137 sn_211 1.151776969870116e-18
Rsub_137_174 sn_137 sn_174 24131487.41871632
Csub_137_174 sn_137 sn_174 4.366280171382196e-19
Rsub_137_215 sn_137 sn_215 105498803.944053
Csub_137_215 sn_137 sn_215 9.987301380039902e-20
Rsub_137_165 sn_137 sn_165 134615.9629770651
Csub_137_165 sn_137 sn_165 7.827068402003063e-17
Rsub_137_160 sn_137 sn_160 2659532.925563994
Csub_137_160 sn_137 sn_160 3.961779679789292e-18
Rsub_137_177 sn_137 sn_177 83437.65210755677
Csub_137_177 sn_137 sn_177 1.262797218772139e-16
Rsub_137_221 sn_137 sn_221 8152434.384710321
Csub_137_221 sn_137 sn_221 1.292434014800647e-18
Rsub_137_176 sn_137 sn_176 4909285.20723452
Csub_137_176 sn_137 sn_176 2.146235767012072e-18
Rsub_137_190 sn_137 sn_190 5985941.827894741
Csub_137_190 sn_137 sn_190 1.76020479402749e-18
Rsub_137_184 sn_137 sn_184 7455786.847216722
Csub_137_184 sn_137 sn_184 1.413195376711087e-18
Rsub_137_214 sn_137 sn_214 8007229.306170065
Csub_137_214 sn_137 sn_214 1.315871333185249e-18
Rsub_137_180 sn_137 sn_180 1122839.257007297
Csub_137_180 sn_137 sn_180 9.383786179967456e-18
Rsub_137_201 sn_137 sn_201 10216396.50173935
Csub_137_201 sn_137 sn_201 1.031330714350814e-18
Rsub_137_210 sn_137 sn_210 1358405.349500918
Csub_137_210 sn_137 sn_210 7.756509134847808e-18
Rsub_137_140 sn_137 sn_140 3914368.026679429
Csub_137_140 sn_137 sn_140 2.691745750633503e-18
Rsub_137_219 sn_137 sn_219 1786674.395166786
Csub_137_219 sn_137 sn_219 5.897260032792052e-18
Rsub_137_150 sn_137 sn_150 10708250.84812465
Csub_137_150 sn_137 sn_150 9.839593460845442e-19
Rsub_137_191 sn_137 sn_191 4030.981367946084
Csub_137_191 sn_137 sn_191 2.613875515777609e-15
Rsub_137_154 sn_137 sn_154 10986.67753468211
Csub_137_154 sn_137 sn_154 9.590236419489914e-16
Rsub_137_228 sn_137 sn_228 14869175.66986874
Csub_137_228 sn_137 sn_228 7.086124837156501e-19
Rsub_137_139 sn_137 sn_139 67196.97212658056
Csub_137_139 sn_137 sn_139 1.567999742961956e-16
Rsub_137_218 sn_137 sn_218 1704680.547168307
Csub_137_218 sn_137 sn_218 6.180913790406334e-18
Rsub_137_185 sn_137 sn_185 17116.18851629092
Csub_137_185 sn_137 sn_185 6.155858526681651e-16
Rsub_137_143 sn_137 sn_143 18296253.06164251
Csub_137_143 sn_137 sn_143 5.7588203807256e-19
Rsub_137_222 sn_137 sn_222 1578239.528621263
Csub_137_222 sn_137 sn_222 6.676099103559132e-18
Rsub_137_199 sn_137 sn_199 21137923.06934312
Csub_137_199 sn_137 sn_199 4.984635182777884e-19
Rsub_137_162 sn_137 sn_162 2451569.072936001
Csub_137_162 sn_137 sn_162 4.29785300302043e-18
Rsub_137_193 sn_137 sn_193 23996729.70327723
Csub_137_193 sn_137 sn_193 4.39079976001523e-19
Rsub_137_156 sn_137 sn_156 1240.295101558869
Csub_137_156 sn_137 sn_156 8.495142397149827e-15
Rsub_137_159 sn_137 sn_159 89486.91505292468
Csub_137_159 sn_137 sn_159 1.177432867810727e-16
Rsub_137_212 sn_137 sn_212 1049495.581694745
Csub_137_212 sn_137 sn_212 1.003956918543238e-17
Rsub_137_138 sn_137 sn_138 11857564.66260495
Csub_137_138 sn_137 sn_138 8.885874799788171e-19
Rsub_137_195 sn_137 sn_195 381640.0526636026
Csub_137_195 sn_137 sn_195 2.760843215666728e-17
Rsub_137_158 sn_137 sn_158 155651.1046502346
Csub_137_158 sn_137 sn_158 6.769295679530613e-17
Rsub_137_155 sn_137 sn_155 385264.8720910304
Csub_137_155 sn_137 sn_155 2.734867429008799e-17
Rsub_137_192 sn_137 sn_192 2509254.222424624
Csub_137_192 sn_137 sn_192 4.1990498244729e-18
Rsub_137_220 sn_137 sn_220 215660.7818254782
Csub_137_220 sn_137 sn_220 4.885674350729457e-17
Rsub_137_141 sn_137 sn_141 463.6509651885482
Csub_137_141 sn_137 sn_141 2.272503303847375e-14
Rsub_137_163 sn_137 sn_163 3606459.062759792
Csub_137_163 sn_137 sn_163 2.921559157853606e-18
Rsub_137_216 sn_137 sn_216 812789.7765477443
Csub_137_216 sn_137 sn_216 1.29633563391789e-17
Rsub_137_188 sn_137 sn_188 14437495.64387838
Csub_137_188 sn_137 sn_188 7.297999432953984e-19
Rsub_137_226 sn_137 sn_226 971530.1285891469
Csub_137_226 sn_137 sn_226 1.084524626892534e-17
Rsub_137_203 sn_137 sn_203 8015135.570723457
Csub_137_203 sn_137 sn_203 1.314573335567294e-18
Rsub_137_186 sn_137 sn_186 4054330.46877506
Csub_137_186 sn_137 sn_186 2.598822070222954e-18
Rsub_137_146 sn_137 sn_146 4222415.637353426
Csub_137_146 sn_137 sn_146 2.495368624779482e-18
Rsub_137_153 sn_137 sn_153 1889755.676316861
Csub_137_153 sn_137 sn_153 5.575579761065005e-18
Rsub_137_224 sn_137 sn_224 2908765.619204526
Csub_137_224 sn_137 sn_224 3.622321246051946e-18
Rsub_137_197 sn_137 sn_197 40285721.30660153
Csub_137_197 sn_137 sn_197 2.615438711408504e-19
Rsub_137_169 sn_137 sn_169 273416.8999966133
Csub_137_169 sn_137 sn_169 3.8536328596954e-17
Rsub_137_213 sn_137 sn_213 7423781.14244157
Csub_137_213 sn_137 sn_213 1.419288001634799e-18
Rsub_137_171 sn_137 sn_171 4740073.719137005
Csub_137_171 sn_137 sn_171 2.222852243772342e-18
Rsub_137_204 sn_137 sn_204 2175191.719259329
Csub_137_204 sn_137 sn_204 4.843933253762921e-18
Rsub_98_225 sn_98 sn_225 345166.7145625732
Csub_98_225 sn_98 sn_225 3.052578089860952e-17
Rsub_98_104 sn_98 sn_104 53910468.36720145
Csub_98_104 sn_98 sn_104 1.954441098612358e-19
Rsub_98_205 sn_98 sn_205 358095.789749541
Csub_98_205 sn_98 sn_205 2.942364530339611e-17
Rsub_98_214 sn_98 sn_214 7901389.294734715
Csub_98_214 sn_98 sn_214 1.333497579881458e-18
Rsub_98_121 sn_98 sn_121 13581230.7081992
Csub_98_121 sn_98 sn_121 7.758121284155023e-19
Rsub_98_154 sn_98 sn_154 139990.1038721941
Csub_98_154 sn_98 sn_154 7.526591673829623e-17
Rsub_98_216 sn_98 sn_216 4854430.457060669
Csub_98_216 sn_98 sn_216 2.170488092357962e-18
Rsub_98_213 sn_98 sn_213 17616934.48909559
Csub_98_213 sn_98 sn_213 5.980883625781659e-19
Rsub_98_226 sn_98 sn_226 435239.9932552233
Csub_98_226 sn_98 sn_226 2.420844514638029e-17
Rsub_98_160 sn_98 sn_160 6834800.138187794
Csub_98_160 sn_98 sn_160 1.541593505179463e-18
Rsub_98_128 sn_98 sn_128 383303.9221489617
Csub_98_128 sn_98 sn_128 2.748858775865919e-17
Rsub_98_180 sn_98 sn_180 8680484.049589498
Csub_98_180 sn_98 sn_180 1.213812898225217e-18
Rsub_98_101 sn_98 sn_101 25082955.51911231
Csub_98_101 sn_98 sn_101 4.20065470123789e-19
Rsub_98_218 sn_98 sn_218 2689419.002340982
Csub_98_218 sn_98 sn_218 3.917754538455559e-18
Rsub_98_139 sn_98 sn_139 73135892.74815197
Csub_98_139 sn_98 sn_139 1.440672029329435e-19
Rsub_98_223 sn_98 sn_223 26955234.18360073
Csub_98_223 sn_98 sn_223 3.908882197224717e-19
Rsub_98_117 sn_98 sn_117 1270571.650311293
Csub_98_117 sn_98 sn_117 8.292711001106105e-18
Rsub_98_228 sn_98 sn_228 26280275.27580513
Csub_98_228 sn_98 sn_228 4.009274405101224e-19
Rsub_98_198 sn_98 sn_198 3088436.650808892
Csub_98_198 sn_98 sn_198 3.411591265590762e-18
Rsub_98_119 sn_98 sn_119 169507.2931715398
Csub_98_119 sn_98 sn_119 6.21594699855609e-17
Rsub_98_230 sn_98 0 13948.28643100967
Csub_98_230 sn_98 0 7.553962670859275e-16
Rsub_98_193 sn_98 sn_193 3874248.258257729
Csub_98_193 sn_98 sn_193 2.719620117211673e-18
Rsub_98_187 sn_98 sn_187 1315664.823208
Csub_98_187 sn_98 sn_187 8.008486140519265e-18
Rsub_98_108 sn_98 sn_108 11283.66201511438
Csub_98_108 sn_98 sn_108 9.33782267504686e-16
Rsub_98_163 sn_98 sn_163 72788.86319272827
Csub_98_163 sn_98 sn_163 1.44754060443722e-16
Rsub_98_190 sn_98 sn_190 3884750.238969068
Csub_98_190 sn_98 sn_190 2.712267933350115e-18
Rsub_98_111 sn_98 sn_111 459076.6779691067
Csub_98_111 sn_98 sn_111 2.295146760415272e-17
Rsub_98_179 sn_98 sn_179 6583.333586588021
Csub_98_179 sn_98 sn_179 1.600478445098937e-15
Rsub_98_106 sn_98 sn_106 815080.463472067
Csub_98_106 sn_98 sn_106 1.29269243644325e-17
Rsub_98_222 sn_98 sn_222 4572824.606338461
Csub_98_222 sn_98 sn_222 2.304152118064013e-18
Rsub_98_173 sn_98 sn_173 3678099.189127057
Csub_98_173 sn_98 sn_173 2.864654529539939e-18
Rsub_98_122 sn_98 sn_122 16742.25077897865
Csub_98_122 sn_98 sn_122 6.293349467360427e-16
Rsub_98_113 sn_98 sn_113 100863.1933777127
Csub_98_113 sn_98 sn_113 1.044631163200728e-16
Rsub_98_194 sn_98 sn_194 5315262.467666454
Csub_98_194 sn_98 sn_194 1.982307283285637e-18
Rsub_98_115 sn_98 sn_115 19058.11634124794
Csub_98_115 sn_98 sn_115 5.528606979602509e-16
Rsub_98_152 sn_98 sn_152 537571.559820612
Csub_98_152 sn_98 sn_152 1.960015054692631e-17
Rsub_98_172 sn_98 sn_172 1372380.517633334
Csub_98_172 sn_98 sn_172 7.677523374056737e-18
Rsub_98_209 sn_98 sn_209 382568.1041774835
Csub_98_209 sn_98 sn_209 2.754145833689744e-17
Rsub_98_175 sn_98 sn_175 837.8581653073455
Csub_98_175 sn_98 sn_175 1.257549778531427e-14
Rsub_98_167 sn_98 sn_167 14427.12833949781
Csub_98_167 sn_98 sn_167 7.303243760148575e-16
Rsub_98_212 sn_98 sn_212 26523655.27074486
Csub_98_212 sn_98 sn_212 3.972485464268404e-19
Rsub_98_202 sn_98 sn_202 214003.610540675
Csub_98_202 sn_98 sn_202 4.923507353735681e-17
Rsub_98_206 sn_98 sn_206 2601251.238478517
Csub_98_206 sn_98 sn_206 4.05054434818562e-18
Rsub_98_132 sn_98 sn_132 1188804.526738671
Csub_98_132 sn_98 sn_132 8.863091673393486e-18
Rsub_98_150 sn_98 sn_150 51374478.90779581
Csub_98_150 sn_98 sn_150 2.050917834347347e-19
Rsub_98_229 sn_98 sn_229 105865.195252037
Csub_98_229 sn_98 sn_229 9.952736097208743e-17
Rsub_98_102 sn_98 sn_102 29095.04951849337
Csub_98_102 sn_98 sn_102 3.621400780064942e-16
Rsub_98_178 sn_98 sn_178 8457863.644826427
Csub_98_178 sn_98 sn_178 1.245761807554682e-18
Rsub_98_157 sn_98 sn_157 30164314.33658935
Csub_98_157 sn_98 sn_157 3.493029340782739e-19
Rsub_98_118 sn_98 sn_118 9497195.139363497
Csub_98_118 sn_98 sn_118 1.109431084400795e-18
Rsub_98_197 sn_98 sn_197 14890825.65893933
Csub_98_197 sn_98 sn_197 7.075822216684601e-19
Rsub_98_186 sn_98 sn_186 45366484.83904355
Csub_98_186 sn_98 sn_186 2.322525877773549e-19
Rsub_177_185 sn_177 sn_185 224364.9655578855
Csub_177_185 sn_177 sn_185 4.696135814266253e-17
Rsub_177_193 sn_177 sn_193 1759313.20899269
Csub_177_193 sn_177 sn_193 5.98897538446992e-18
Rsub_177_205 sn_177 sn_205 217229.6582622125
Csub_177_205 sn_177 sn_205 4.850389024463536e-17
Rsub_177_218 sn_177 sn_218 1355502.251956252
Csub_177_218 sn_177 sn_218 7.77312135558891e-18
Rsub_177_196 sn_177 sn_196 1350768.446842192
Csub_177_196 sn_177 sn_196 7.800362472829484e-18
Rsub_177_194 sn_177 sn_194 1774517.701252508
Csub_177_194 sn_177 sn_194 5.937660410371244e-18
Rsub_177_208 sn_177 sn_208 739330.8882030906
Csub_177_208 sn_177 sn_208 1.425137738778699e-17
Rsub_177_224 sn_177 sn_224 1504836.545480619
Csub_177_224 sn_177 sn_224 7.001746158992189e-18
Rsub_177_182 sn_177 sn_182 5054017.802605151
Csub_177_182 sn_177 sn_182 2.084773721374478e-18
Rsub_177_223 sn_177 sn_223 872699.2221529345
Csub_177_223 sn_177 sn_223 1.207344206889136e-17
Rsub_177_197 sn_177 sn_197 24040665.26205545
Csub_177_197 sn_177 sn_197 4.382775346429469e-19
Rsub_177_204 sn_177 sn_204 2266854.027091831
Csub_177_204 sn_177 sn_204 4.648064399518198e-18
Rsub_177_180 sn_177 sn_180 59023.2372743211
Csub_177_180 sn_177 sn_180 1.785141579622243e-16
Rsub_177_217 sn_177 sn_217 86670.43825654224
Csub_177_217 sn_177 sn_217 1.215695191368744e-16
Rsub_177_199 sn_177 sn_199 2492830.432417616
Csub_177_199 sn_177 sn_199 4.226714888108705e-18
Rsub_177_202 sn_177 sn_202 732256.8820175664
Csub_177_202 sn_177 sn_202 1.438905356983349e-17
Rsub_177_219 sn_177 sn_219 128960.9527975675
Csub_177_219 sn_177 sn_219 8.170289745586269e-17
Rsub_177_206 sn_177 sn_206 188085.0439254884
Csub_177_206 sn_177 sn_206 5.601978382929865e-17
Rsub_177_190 sn_177 sn_190 769711.4936370776
Csub_177_190 sn_177 sn_190 1.368887380444653e-17
Rsub_177_195 sn_177 sn_195 20510.97388141181
Csub_177_195 sn_177 sn_195 5.136998156766585e-16
Rsub_177_222 sn_177 sn_222 70532.81688785757
Csub_177_222 sn_177 sn_222 1.493841302124981e-16
Rsub_177_213 sn_177 sn_213 92757.66243765873
Csub_177_213 sn_177 sn_213 1.135915160573547e-16
Rsub_177_230 sn_177 0 3778.382298508558
Csub_177_230 sn_177 0 2.788622926374886e-15
Rsub_177_181 sn_177 sn_181 805.1969812142247
Csub_177_181 sn_177 sn_181 1.308559737313116e-14
Rsub_177_214 sn_177 sn_214 424858.7369438473
Csub_177_214 sn_177 sn_214 2.479996899209957e-17
Rsub_177_191 sn_177 sn_191 14420.6795050676
Csub_177_191 sn_177 sn_191 7.306509723433875e-16
Rsub_177_228 sn_177 sn_228 599944.8170083652
Csub_177_228 sn_177 sn_228 1.756242108194275e-17
Rsub_177_220 sn_177 sn_220 1004511.493154461
Csub_177_220 sn_177 sn_220 1.048916172092999e-17
Rsub_177_183 sn_177 sn_183 28298.74474263541
Csub_177_183 sn_177 sn_183 3.72330419531137e-16
Rsub_177_186 sn_177 sn_186 21678732.33719957
Csub_177_186 sn_177 sn_186 4.860285803773657e-19
Rsub_177_189 sn_177 sn_189 676140.5787274778
Csub_177_189 sn_177 sn_189 1.558327341047932e-17
Rsub_177_226 sn_177 sn_226 39392.43811482519
Csub_177_226 sn_177 sn_226 2.674747745117263e-16
Rsub_177_198 sn_177 sn_198 491086.9236286394
Csub_177_198 sn_177 sn_198 2.145543486349823e-17
Rsub_177_188 sn_177 sn_188 9446767.334332617
Csub_177_188 sn_177 sn_188 1.115353340389469e-18
Rsub_177_178 sn_177 sn_178 1198857.379134884
Csub_177_178 sn_177 sn_178 8.788771446552976e-18
Rsub_177_215 sn_177 sn_215 42198.32301399335
Csub_177_215 sn_177 sn_215 2.496896262615935e-16
Rsub_177_229 sn_177 sn_229 147660.3730040662
Csub_177_229 sn_177 sn_229 7.135620266880844e-17
Rsub_177_192 sn_177 sn_192 2645688.114582666
Csub_177_192 sn_177 sn_192 3.982511560661428e-18
Rsub_177_216 sn_177 sn_216 340872.9420107159
Csub_177_216 sn_177 sn_216 3.09102959011008e-17
Rsub_177_179 sn_177 sn_179 38370.1830465316
Csub_177_179 sn_177 sn_179 2.746008141126766e-16
Rsub_177_210 sn_177 sn_210 82811.43091096649
Csub_177_210 sn_177 sn_210 1.272346508969051e-16
Rsub_177_201 sn_177 sn_201 4468185.248782128
Csub_177_201 sn_177 sn_201 2.358112503303635e-18
Rsub_177_187 sn_177 sn_187 193346.9069975229
Csub_177_187 sn_177 sn_187 5.44952265637484e-17
Rsub_177_207 sn_177 sn_207 8806908.304348327
Csub_177_207 sn_177 sn_207 1.196388464386272e-18
Rsub_177_221 sn_177 sn_221 1949265.997631472
Csub_177_221 sn_177 sn_221 5.405359512263972e-18
Rsub_177_211 sn_177 sn_211 2432118.227221807
Csub_177_211 sn_177 sn_211 4.332225047408883e-18
Rsub_10_98 sn_10 sn_98 50718243.35988538
Csub_10_98 sn_10 sn_98 2.077454344675437e-19
Rsub_10_56 sn_10 sn_56 27637399.43680281
Csub_10_56 sn_10 sn_56 3.812400485191562e-19
Rsub_10_213 sn_10 sn_213 12067739.73168575
Csub_10_213 sn_10 sn_213 8.731115964131051e-19
Rsub_10_21 sn_10 sn_21 71233694.06293936
Csub_10_21 sn_10 sn_21 1.479143211767225e-19
Rsub_10_42 sn_10 sn_42 17490318.30223125
Csub_10_42 sn_10 sn_42 6.024180532429679e-19
Rsub_10_72 sn_10 sn_72 89099639.89524992
Csub_10_72 sn_10 sn_72 1.182550626985387e-19
Rsub_10_104 sn_10 sn_104 191780510.498699
Csub_10_104 sn_10 sn_104 5.494032461813412e-20
Rsub_10_80 sn_10 sn_80 11545893.34344802
Csub_10_80 sn_10 sn_80 9.12574123873158e-19
Rsub_10_112 sn_10 sn_112 1407724.101317297
Csub_10_112 sn_10 sn_112 7.484764587301124e-18
Rsub_10_88 sn_10 sn_88 40500000.25188223
Csub_10_88 sn_10 sn_88 2.601600848567975e-19
Rsub_10_214 sn_10 sn_214 46632697.45821173
Csub_10_214 sn_10 sn_214 2.259462582380508e-19
Rsub_10_34 sn_10 sn_34 28975001.59794338
Csub_10_34 sn_10 sn_34 3.636404804539466e-19
Rsub_10_35 sn_10 sn_35 5873259.483775756
Csub_10_35 sn_10 sn_35 1.793975480112176e-18
Rsub_10_144 sn_10 sn_144 16857658.95869893
Csub_10_144 sn_10 sn_144 6.250264955557746e-19
Rsub_10_60 sn_10 sn_60 27910093.63332882
Csub_10_60 sn_10 sn_60 3.775151613840473e-19
Rsub_10_227 sn_10 sn_227 18507695.77994664
Csub_10_227 sn_10 sn_227 5.693028255654836e-19
Rsub_10_68 sn_10 sn_68 93521997.9372436
Csub_10_68 sn_10 sn_68 1.126631566329489e-19
Rsub_10_66 sn_10 sn_66 29768455.71926707
Csub_10_66 sn_10 sn_66 3.539479374272835e-19
Rsub_10_228 sn_10 sn_228 93521997.9372436
Csub_10_228 sn_10 sn_228 1.126631566329489e-19
Rsub_10_53 sn_10 sn_53 18878859.29795701
Csub_10_53 sn_10 sn_53 5.58110176888188e-19
Rsub_10_71 sn_10 sn_71 93521997.9372436
Csub_10_71 sn_10 sn_71 1.126631566329489e-19
Rsub_10_206 sn_10 sn_206 186958049.6005015
Csub_10_206 sn_10 sn_206 5.635747444276793e-20
Rsub_10_87 sn_10 sn_87 93521997.9372436
Csub_10_87 sn_10 sn_87 1.126631566329489e-19
Rsub_10_183 sn_10 sn_183 19860530.5185223
Csub_10_183 sn_10 sn_183 5.305237688592197e-19
Rsub_10_140 sn_10 sn_140 93521997.9372436
Csub_10_140 sn_10 sn_140 1.126631566329489e-19
Rsub_10_22 sn_10 sn_22 93521997.9372436
Csub_10_22 sn_10 sn_22 1.126631566329489e-19
Rsub_10_175 sn_10 sn_175 57246597.58319877
Csub_10_175 sn_10 sn_175 1.840543184582614e-19
Rsub_10_170 sn_10 sn_170 93521997.9372436
Csub_10_170 sn_10 sn_170 1.126631566329489e-19
Rsub_10_122 sn_10 sn_122 74657200.05665611
Csub_10_122 sn_10 sn_122 1.41131511685866e-19
Rsub_10_139 sn_10 sn_139 51406539.38989729
Csub_10_139 sn_10 sn_139 2.049638747770034e-19
Rsub_10_152 sn_10 sn_152 24933898.7252523
Csub_10_152 sn_10 sn_152 4.225766543103413e-19
Rsub_10_100 sn_10 sn_100 93521997.9372436
Csub_10_100 sn_10 sn_100 1.126631566329489e-19
Rsub_10_128 sn_10 sn_128 27785201.13332288
Csub_10_128 sn_10 sn_128 3.792120651447638e-19
Rsub_10_195 sn_10 sn_195 35432104.12340689
Csub_10_195 sn_10 sn_195 2.973710922030585e-19
Rsub_10_137 sn_10 sn_137 28257770.85803368
Csub_10_137 sn_10 sn_137 3.728703001791977e-19
Rsub_10_26 sn_10 sn_26 5076747.07743949
Csub_10_26 sn_10 sn_26 2.075439910932925e-18
Rsub_10_184 sn_10 sn_184 59344.27741736475
Csub_10_184 sn_10 sn_184 1.775484336615567e-16
Rsub_10_166 sn_10 sn_166 1187110.347929284
Csub_10_166 sn_10 sn_166 8.875740591941716e-18
Rsub_10_64 sn_10 sn_64 7461181.369116432
Csub_10_64 sn_10 sn_64 1.412173619829557e-18
Rsub_10_222 sn_10 sn_222 2050042.82549949
Csub_10_222 sn_10 sn_222 5.139640680268618e-18
Rsub_10_164 sn_10 sn_164 809742.9804978298
Csub_10_164 sn_10 sn_164 1.301213317805135e-17
Rsub_10_29 sn_10 sn_29 6990082.581520411
Csub_10_29 sn_10 sn_29 1.507347499739869e-18
Rsub_10_96 sn_10 sn_96 62406959.07744884
Csub_10_96 sn_10 sn_96 1.688350731711494e-19
Rsub_10_207 sn_10 sn_207 3433267.34721835
Csub_10_207 sn_10 sn_207 3.068937672671111e-18
Rsub_10_158 sn_10 sn_158 429364.9856478408
Csub_10_158 sn_10 sn_158 2.453968966829512e-17
Rsub_10_79 sn_10 sn_79 574996515.3624471
Csub_10_79 sn_10 sn_79 1.832443018474358e-20
Rsub_10_177 sn_10 sn_177 23507034.73227779
Csub_10_177 sn_10 sn_177 4.48226823256539e-19
Rsub_10_84 sn_10 sn_84 35906.88939776069
Csub_10_84 sn_10 sn_84 2.934390496907567e-16
Rsub_10_57 sn_10 sn_57 17495390.8928568
Csub_10_57 sn_10 sn_57 6.022433889449107e-19
Rsub_10_224 sn_10 sn_224 93285.38909040717
Csub_10_224 sn_10 sn_224 1.129489152049161e-16
Rsub_10_145 sn_10 sn_145 25596736.0603524
Csub_10_145 sn_10 sn_145 4.116338691537432e-19
Rsub_10_162 sn_10 sn_162 113039.598721711
Csub_10_162 sn_10 sn_162 9.32105529511784e-17
Rsub_10_200 sn_10 sn_200 93521997.9372436
Csub_10_200 sn_10 sn_200 1.126631566329489e-19
Rsub_10_33 sn_10 sn_33 6047668.52791479
Csub_10_33 sn_10 sn_33 1.742238922916454e-18
Rsub_10_191 sn_10 sn_191 14828090.5315895
Csub_10_191 sn_10 sn_191 7.105758816203115e-19
Rsub_10_123 sn_10 sn_123 1561675.556463485
Csub_10_123 sn_10 sn_123 6.746909406772395e-18
Rsub_10_44 sn_10 sn_44 490873.3007371458
Csub_10_44 sn_10 sn_44 2.14647720428211e-17
Rsub_10_230 sn_10 0 239793.6235821973
Csub_10_230 sn_10 0 4.39397985018491e-17
Rsub_10_212 sn_10 sn_212 31006148.14034395
Csub_10_212 sn_10 sn_212 3.398191692350316e-19
Rsub_10_45 sn_10 sn_45 284563.0530734876
Csub_10_45 sn_10 sn_45 3.70268852137631e-17
Rsub_10_216 sn_10 sn_216 711678.0210915516
Csub_10_216 sn_10 sn_216 1.480512702369176e-17
Rsub_10_198 sn_10 sn_198 28530054.47920462
Csub_10_198 sn_10 sn_198 3.693117203792926e-19
Rsub_10_31 sn_10 sn_31 1522759.981267295
Csub_10_31 sn_10 sn_31 6.91933307405489e-18
Rsub_10_32 sn_10 sn_32 2992698.463873127
Csub_10_32 sn_10 sn_32 3.520730080034112e-18
Rsub_10_116 sn_10 sn_116 1779386.990549521
Csub_10_116 sn_10 sn_116 5.921412013345146e-18
Rsub_10_93 sn_10 sn_93 751684.7634166019
Csub_10_93 sn_10 sn_93 1.401715721140728e-17
Rsub_10_208 sn_10 sn_208 51635.37498842289
Csub_10_208 sn_10 sn_208 2.040555240393311e-16
Rsub_10_190 sn_10 sn_190 385694.4687526468
Csub_10_190 sn_10 sn_190 2.731821261607785e-17
Rsub_10_23 sn_10 sn_23 8932808.456945045
Csub_10_23 sn_10 sn_23 1.179526411320075e-18
Rsub_10_181 sn_10 sn_181 7541645.278974978
Csub_10_181 sn_10 sn_181 1.397106746932821e-18
Rsub_10_171 sn_10 sn_171 691165.9685180506
Csub_10_171 sn_10 sn_171 1.524450563563132e-17
Rsub_10_219 sn_10 sn_219 15579202.62398549
Csub_10_219 sn_10 sn_219 6.763172516934981e-19
Rsub_10_131 sn_10 sn_131 3628393.267660207
Csub_10_131 sn_10 sn_131 2.90389787571856e-18
Rsub_10_155 sn_10 sn_155 363936.7074109996
Csub_10_155 sn_10 sn_155 2.895141734172745e-17
Rsub_10_146 sn_10 sn_146 140696.2822214442
Csub_10_146 sn_10 sn_146 7.488814441910025e-17
Rsub_10_226 sn_10 sn_226 1915411.196187549
Csub_10_226 sn_10 sn_226 5.500898983571732e-18
Rsub_10_59 sn_10 sn_59 11152498.10233473
Csub_10_59 sn_10 sn_59 9.447644290586545e-19
Rsub_10_138 sn_10 sn_138 41989585.01751743
Csub_10_138 sn_10 sn_138 2.509308795939359e-19
Rsub_10_25 sn_10 sn_25 9943902.109150331
Csub_10_25 sn_10 sn_25 1.059592440329273e-18
Rsub_10_192 sn_10 sn_192 43634343.54331747
Csub_10_192 sn_10 sn_192 2.414722589276502e-19
Rsub_10_159 sn_10 sn_159 28871720.81443763
Csub_10_159 sn_10 sn_159 3.649413060603272e-19
Rsub_10_160 sn_10 sn_160 26301174.11992082
Csub_10_160 sn_10 sn_160 4.0060886461527e-19
Rsub_10_107 sn_10 sn_107 4991655.87988275
Csub_10_107 sn_10 sn_107 2.110819286380273e-18
Rsub_10_218 sn_10 sn_218 4398237738.467881
Rsub_10_186 sn_10 sn_186 19461475.92777036
Csub_10_186 sn_10 sn_186 5.414020776910898e-19
Rsub_10_19 sn_10 sn_19 4683462.862369818
Csub_10_19 sn_10 sn_19 2.249720732684229e-18
Rsub_10_157 sn_10 sn_157 21808937.05659273
Csub_10_157 sn_10 sn_157 4.831268701857653e-19
Rsub_10_130 sn_10 sn_130 19627944.22480141
Csub_10_130 sn_10 sn_130 5.368103445554093e-19
Rsub_10_134 sn_10 sn_134 44867050.49141571
Csub_10_134 sn_10 sn_134 2.348378907645359e-19
Rsub_10_154 sn_10 sn_154 69219325.0529307
Csub_10_154 sn_10 sn_154 1.522188130868504e-19
Rsub_10_132 sn_10 sn_132 3904941.54311174
Csub_10_132 sn_10 sn_132 2.698243593637453e-18
Rsub_10_221 sn_10 sn_221 71202247.44731243
Csub_10_221 sn_10 sn_221 1.479796478338228e-19
Rsub_10_15 sn_10 sn_15 21149065.48858554
Csub_10_15 sn_10 sn_15 4.982009019697205e-19
Rsub_10_215 sn_10 sn_215 34236167.29488432
Csub_10_215 sn_10 sn_215 3.077588507929858e-19
Rsub_10_48 sn_10 sn_48 23336809.74739869
Csub_10_48 sn_10 sn_48 4.514963106045154e-19
Rsub_10_86 sn_10 sn_86 13281885.68829917
Csub_10_86 sn_10 sn_86 7.932972583488076e-19
Rsub_10_36 sn_10 sn_36 2019498.318045981
Csub_10_36 sn_10 sn_36 5.217376715829531e-18
Rsub_10_179 sn_10 sn_179 14731389.217512
Csub_10_179 sn_10 sn_179 7.152403175733566e-19
Rsub_10_141 sn_10 sn_141 1554597.047178541
Csub_10_141 sn_10 sn_141 6.777629946842373e-18
Rsub_10_77 sn_10 sn_77 16870175.588484
Csub_10_77 sn_10 sn_77 6.245627644458228e-19
Rsub_10_156 sn_10 sn_156 358372.1532859656
Csub_10_156 sn_10 sn_156 2.940095486108358e-17
Rsub_10_95 sn_10 sn_95 22874101.70875954
Csub_10_95 sn_10 sn_95 4.606293893584944e-19
Rsub_10_180 sn_10 sn_180 48696865.56260526
Csub_10_180 sn_10 sn_180 2.163688233421138e-19
Rsub_10_169 sn_10 sn_169 15915996.95286409
Csub_10_169 sn_10 sn_169 6.620058758137646e-19
Rsub_10_135 sn_10 sn_135 53003283.78361838
Csub_10_135 sn_10 sn_135 1.987892588927951e-19
Rsub_10_18 sn_10 sn_18 295258855.5031633
Csub_10_18 sn_10 sn_18 3.568557997786154e-20
Rsub_10_185 sn_10 sn_185 13013095.51109076
Csub_10_185 sn_10 sn_185 8.096830990942931e-19
Rsub_10_30 sn_10 sn_30 6685124.544858883
Csub_10_30 sn_10 sn_30 1.576108781747823e-18
Rsub_10_197 sn_10 sn_197 53813998.95718432
Csub_10_197 sn_10 sn_197 1.957944718178828e-19
Rsub_10_150 sn_10 sn_150 34459479.52958035
Csub_10_150 sn_10 sn_150 3.057644411949224e-19
Rsub_75_101 sn_75 sn_101 12660194.23380938
Csub_75_101 sn_75 sn_101 8.322529107880545e-19
Rsub_75_172 sn_75 sn_172 3323436.259221919
Csub_75_172 sn_75 sn_172 3.170358231782907e-18
Rsub_75_219 sn_75 sn_219 205823089.934378
Csub_75_219 sn_75 sn_219 5.119194112569837e-20
Rsub_75_81 sn_75 sn_81 802519.5607026991
Csub_75_81 sn_75 sn_81 1.312925443587205e-17
Rsub_75_105 sn_75 sn_105 26050830.52921763
Csub_75_105 sn_75 sn_105 4.044586405954574e-19
Rsub_75_129 sn_75 sn_129 21053244.82519076
Csub_75_129 sn_75 sn_129 5.00468388113875e-19
Rsub_75_87 sn_75 sn_87 351577.5533489364
Csub_75_87 sn_75 sn_87 2.996915873003039e-17
Rsub_75_110 sn_75 sn_110 34871380.62621254
Csub_75_110 sn_75 sn_110 3.021527485582206e-19
Rsub_75_82 sn_75 sn_82 27597534.99616764
Csub_75_82 sn_75 sn_82 3.817907470248035e-19
Rsub_75_139 sn_75 sn_139 248119.0774770484
Csub_75_139 sn_75 sn_139 4.246543074949427e-17
Rsub_75_106 sn_75 sn_106 837411.7155158599
Csub_75_106 sn_75 sn_106 1.258220216771072e-17
Rsub_75_178 sn_75 sn_178 2519924.00041116
Csub_75_178 sn_75 sn_178 4.181270348038605e-18
Rsub_75_152 sn_75 sn_152 1069469.266811736
Csub_75_152 sn_75 sn_152 9.852067590161794e-18
Rsub_75_156 sn_75 sn_156 974390.9279905012
Csub_75_156 sn_75 sn_156 1.081340476348597e-17
Rsub_75_77 sn_75 sn_77 404871.817144817
Csub_75_77 sn_75 sn_77 2.602424534395598e-17
Rsub_75_130 sn_75 sn_130 278516.9547366606
Csub_75_130 sn_75 sn_130 3.783067178869706e-17
Rsub_75_209 sn_75 sn_209 3506661.558722663
Csub_75_209 sn_75 sn_209 3.004704995274201e-18
Rsub_75_228 sn_75 sn_228 52222490.32102931
Csub_75_228 sn_75 sn_228 2.017614142385527e-19
Rsub_75_181 sn_75 sn_181 1023072.018345479
Csub_75_181 sn_75 sn_181 1.029886783461216e-17
Rsub_75_102 sn_75 sn_102 6669246.29042636
Csub_75_102 sn_75 sn_102 1.579861208208043e-18
Rsub_75_128 sn_75 sn_128 439641.1506458265
Csub_75_128 sn_75 sn_128 2.396609936706803e-17
Rsub_75_229 sn_75 sn_229 672248.2650310261
Csub_75_229 sn_75 sn_229 1.567350047641062e-17
Rsub_75_124 sn_75 sn_124 8796384.302107666
Csub_75_124 sn_75 sn_124 1.197819824641518e-18
Rsub_75_204 sn_75 sn_204 13478397.12973173
Csub_75_204 sn_75 sn_204 7.817311955431098e-19
Rsub_75_205 sn_75 sn_205 703155.1066978727
Csub_75_205 sn_75 sn_205 1.498457936501519e-17
Rsub_75_126 sn_75 sn_126 10211815.06842812
Csub_75_126 sn_75 sn_126 1.031793411026964e-18
Rsub_75_170 sn_75 sn_170 3800535.831373385
Csub_75_170 sn_75 sn_170 2.772367889614785e-18
Rsub_75_91 sn_75 sn_91 484766.1741777913
Csub_75_91 sn_75 sn_91 2.173518711387167e-17
Rsub_75_216 sn_75 sn_216 5204750.180766077
Csub_75_216 sn_75 sn_216 2.024397547680023e-18
Rsub_75_100 sn_75 sn_100 6225015.482821698
Csub_75_100 sn_75 sn_100 1.692603581678801e-18
Rsub_75_179 sn_75 sn_179 169737.2339087869
Csub_75_179 sn_75 sn_179 6.207526339148473e-17
Rsub_75_201 sn_75 sn_201 4854905.966236354
Csub_75_201 sn_75 sn_201 2.170275505953445e-18
Rsub_75_122 sn_75 sn_122 24893.66587788022
Csub_75_122 sn_75 sn_122 4.232596176842083e-16
Rsub_75_85 sn_75 sn_85 252667.3279573716
Csub_75_85 sn_75 sn_85 4.170101289869836e-17
Rsub_75_113 sn_75 sn_113 5465.570337666683
Csub_75_113 sn_75 sn_113 1.92779213353389e-15
Rsub_75_194 sn_75 sn_194 2333471.222306148
Csub_75_194 sn_75 sn_194 4.515368949704419e-18
Rsub_75_115 sn_75 sn_115 45039.01286419993
Csub_75_115 sn_75 sn_115 2.339412618566762e-16
Rsub_75_119 sn_75 sn_119 2447.707279156386
Csub_75_119 sn_75 sn_119 4.30463380648255e-15
Rsub_75_230 sn_75 0 23882.36735981968
Csub_75_230 sn_75 0 4.411825403857096e-16
Rsub_75_83 sn_75 sn_83 2229.016070201264
Csub_75_83 sn_75 sn_83 4.726966145775088e-15
Rsub_75_167 sn_75 sn_167 866.6880877158958
Csub_75_167 sn_75 sn_167 1.215718048000206e-14
Rsub_75_222 sn_75 sn_222 5364699.70028251
Csub_75_222 sn_75 sn_222 1.964039758213333e-18
Rsub_75_143 sn_75 sn_143 14162.79283620076
Csub_75_143 sn_75 sn_143 7.439552088411724e-16
Rsub_75_138 sn_75 sn_138 5119632.412876552
Csub_75_138 sn_75 sn_138 2.058054690748764e-18
Rsub_75_98 sn_75 sn_98 2946.592728734117
Csub_75_98 sn_75 sn_98 3.575819419997201e-15
Rsub_75_177 sn_75 sn_177 61470.45153861542
Csub_75_177 sn_75 sn_177 1.714072898197443e-16
Rsub_75_92 sn_75 sn_92 245553.0156440042
Csub_75_92 sn_75 sn_92 4.290920017657406e-17
Rsub_75_199 sn_75 sn_199 28339877.06610969
Csub_75_199 sn_75 sn_199 3.717900214475553e-19
Rsub_75_158 sn_75 sn_158 625446.95900027
Csub_75_158 sn_75 sn_158 1.684632621616992e-17
Rsub_75_79 sn_75 sn_79 802519.5607026991
Csub_75_79 sn_75 sn_79 1.312925443587205e-17
Rsub_75_175 sn_75 sn_175 11007.85244163234
Csub_75_175 sn_75 sn_175 9.571788464733051e-16
Rsub_75_96 sn_75 sn_96 1605039.121405398
Csub_75_96 sn_75 sn_96 6.564627217936026e-18
Rsub_75_108 sn_75 sn_108 167272.4409993596
Csub_75_108 sn_75 sn_108 6.298995482627256e-17
Rsub_75_182 sn_75 sn_182 43327158.12902398
Csub_75_182 sn_75 sn_182 2.431842741878754e-19
Rsub_75_173 sn_75 sn_173 37524.0147905714
Csub_75_173 sn_75 sn_173 2.807930750756843e-16
Rsub_75_111 sn_75 sn_111 349231.3087032868
Csub_75_111 sn_75 sn_111 3.017050086761261e-17
Rsub_75_220 sn_75 sn_220 2826264.539866027
Csub_75_220 sn_75 sn_220 3.728059901543915e-18
Rsub_75_141 sn_75 sn_141 75840132.05079687
Csub_75_141 sn_75 sn_141 1.389301840241099e-19
Rsub_75_225 sn_75 sn_225 545396.8936856507
Csub_75_225 sn_75 sn_225 1.931892833313953e-17
Rsub_75_174 sn_75 sn_174 40561594.84419266
Csub_75_174 sn_75 sn_174 2.597650201552305e-19
Rsub_154_172 sn_154 sn_172 7292064.310871795
Csub_154_172 sn_154 sn_172 1.444924654123123e-18
Rsub_154_202 sn_154 sn_202 124071.2354557602
Csub_154_202 sn_154 sn_202 8.492285470943804e-17
Rsub_154_166 sn_154 sn_166 5091076.576081391
Csub_154_166 sn_154 sn_166 2.069598314771362e-18
Rsub_154_215 sn_154 sn_215 547097.2254035216
Csub_154_215 sn_154 sn_215 1.925888674441481e-17
Rsub_154_212 sn_154 sn_212 3324283.530150432
Csub_154_212 sn_154 sn_212 3.169550192294578e-18
Rsub_154_209 sn_154 sn_209 390440.8526773225
Csub_154_209 sn_154 sn_209 2.698611948513957e-17
Rsub_154_177 sn_154 sn_177 44086.65855545876
Csub_154_177 sn_154 sn_177 2.389948308052343e-16
Rsub_154_214 sn_154 sn_214 9309018.119749861
Csub_154_214 sn_154 sn_214 1.131857663900768e-18
Rsub_154_197 sn_154 sn_197 19095632.30404346
Csub_154_197 sn_154 sn_197 5.517745280421494e-19
Rsub_154_171 sn_154 sn_171 8725772.681140203
Csub_154_171 sn_154 sn_171 1.207512948968227e-18
Rsub_154_158 sn_154 sn_158 2174064.555877824
Csub_154_158 sn_154 sn_158 4.846444634656066e-18
Rsub_154_222 sn_154 sn_222 1407041.378338328
Csub_154_222 sn_154 sn_222 7.488396336057479e-18
Rsub_154_175 sn_154 sn_175 306805.948339751
Csub_154_175 sn_154 sn_175 3.434250072153784e-17
Rsub_154_210 sn_154 sn_210 1418631.77686238
Csub_154_210 sn_154 sn_210 7.427215204169314e-18
Rsub_154_160 sn_154 sn_160 230983.6874843465
Csub_154_160 sn_154 sn_160 4.561570393556058e-17
Rsub_154_195 sn_154 sn_195 836865.8131883305
Csub_154_195 sn_154 sn_195 1.25904097600637e-17
Rsub_154_174 sn_154 sn_174 27601591.12777517
Csub_154_174 sn_154 sn_174 3.817346417985033e-19
Rsub_154_230 sn_154 0 14459.2712851082
Csub_154_230 sn_154 0 7.287008656571557e-16
Rsub_154_156 sn_154 sn_156 11126.7310558582
Csub_154_156 sn_154 sn_156 9.46952294374237e-16
Rsub_154_161 sn_154 sn_161 40418.2131641422
Csub_154_161 sn_154 sn_161 2.606865241528699e-16
Rsub_154_198 sn_154 sn_198 10081441.09090943
Csub_154_198 sn_154 sn_198 1.045136643384336e-18
Rsub_154_229 sn_154 sn_229 1049618.399155586
Csub_154_229 sn_154 sn_229 1.003839444002369e-17
Rsub_154_192 sn_154 sn_192 4326712.712508403
Csub_154_192 sn_154 sn_192 2.435216803687781e-18
Rsub_154_155 sn_154 sn_155 303753.126173554
Csub_154_155 sn_154 sn_155 3.4687654527084e-17
Rsub_154_218 sn_154 sn_218 1307486.965814017
Csub_154_218 sn_154 sn_218 8.058576320621434e-18
Rsub_154_169 sn_154 sn_169 178045.1509928849
Csub_154_169 sn_154 sn_169 5.91787164293571e-17
Rsub_154_206 sn_154 sn_206 31146302.5040254
Csub_154_206 sn_154 sn_206 3.382900265888142e-19
Rsub_154_159 sn_154 sn_159 5550.623701113112
Csub_154_159 sn_154 sn_159 1.898252173015626e-15
Rsub_154_185 sn_154 sn_185 530.0503522562857
Csub_154_185 sn_154 sn_185 1.987826903119477e-14
Rsub_154_205 sn_154 sn_205 1081952.118888726
Csub_154_205 sn_154 sn_205 9.73840091283525e-18
Rsub_154_168 sn_154 sn_168 1775844.933821666
Csub_154_168 sn_154 sn_168 5.93322271644248e-18
Rsub_154_228 sn_154 sn_228 9445566.952217726
Csub_154_228 sn_154 sn_228 1.115495084152269e-18
Rsub_154_165 sn_154 sn_165 10829.05588502852
Csub_154_165 sn_154 sn_165 9.72982650943467e-16
Rsub_154_157 sn_154 sn_157 13082.78128485567
Csub_154_157 sn_154 sn_157 8.053703010709806e-16
Rsub_154_183 sn_154 sn_183 3702.783170269204
Csub_154_183 sn_154 sn_183 2.84555779199568e-15
Rsub_154_162 sn_154 sn_162 4542670.273061239
Csub_154_162 sn_154 sn_162 2.319447124461803e-18
Rsub_154_199 sn_154 sn_199 10077627.96220679
Csub_154_199 sn_154 sn_199 1.045532097607097e-18
Rsub_154_201 sn_154 sn_201 8097793.444084505
Csub_154_201 sn_154 sn_201 1.301154885585156e-18
Rsub_154_164 sn_154 sn_164 2813958.653021954
Csub_154_164 sn_154 sn_164 3.744363297916515e-18
Rsub_154_203 sn_154 sn_203 2789828.18536587
Csub_154_203 sn_154 sn_203 3.776749965284404e-18
Rsub_154_211 sn_154 sn_211 69114448.08798881
Csub_154_211 sn_154 sn_211 1.524497958634658e-19
Rsub_154_180 sn_154 sn_180 2675989.032101892
Csub_154_180 sn_154 sn_180 3.937416549855579e-18
Rsub_154_200 sn_154 sn_200 1595492.171930238
Csub_154_200 sn_154 sn_200 6.603907990023471e-18
Rsub_154_219 sn_154 sn_219 1290328.364336381
Csub_154_219 sn_154 sn_219 8.165738112444686e-18
Rsub_154_207 sn_154 sn_207 2856850.843261195
Csub_154_207 sn_154 sn_207 3.688146172238463e-18
Rsub_117_197 sn_117 sn_197 10550157.41198068
Csub_117_197 sn_117 sn_197 9.987039141486973e-19
Rsub_117_127 sn_117 sn_127 2004996.522270263
Csub_117_127 sn_117 sn_127 5.255113106280858e-18
Rsub_117_218 sn_117 sn_218 2639489.092608954
Csub_117_218 sn_117 sn_218 3.991864763424882e-18
Rsub_117_211 sn_117 sn_211 11349200.92129042
Csub_117_211 sn_117 sn_211 9.283898994566384e-19
Rsub_117_200 sn_117 sn_200 5560314.617471709
Csub_117_200 sn_117 sn_200 1.894943762556546e-18
Rsub_117_158 sn_117 sn_158 1373332.083066177
Csub_117_158 sn_117 sn_158 7.672203709612367e-18
Rsub_117_186 sn_117 sn_186 41329580.64859048
Csub_117_186 sn_117 sn_186 2.549380694621042e-19
Rsub_117_180 sn_117 sn_180 10133563.56315042
Csub_117_180 sn_117 sn_180 1.03976093272309e-18
Rsub_117_125 sn_117 sn_125 293421.8752058488
Csub_117_125 sn_117 sn_125 3.590899108949589e-17
Rsub_117_187 sn_117 sn_187 3612913.613571126
Csub_117_187 sn_117 sn_187 2.916339727208531e-18
Rsub_117_196 sn_117 sn_196 4540252.113305873
Csub_117_196 sn_117 sn_196 2.320682472973537e-18
Rsub_117_137 sn_117 sn_137 946911.8738379534
Csub_117_137 sn_117 sn_137 1.112720601920884e-17
Rsub_117_203 sn_117 sn_203 1878098.008202525
Csub_117_203 sn_117 sn_203 5.610188316164702e-18
Rsub_117_214 sn_117 sn_214 1911537.172767291
Csub_117_214 sn_117 sn_214 5.512047399515941e-18
Rsub_117_145 sn_117 sn_145 594421.621146122
Csub_117_145 sn_117 sn_145 1.772560608060368e-17
Rsub_117_222 sn_117 sn_222 299341.6594620751
Csub_117_222 sn_117 sn_222 3.519885445000988e-17
Rsub_117_143 sn_117 sn_143 1511847.022820354
Csub_117_143 sn_117 sn_143 6.969278864321981e-18
Rsub_117_141 sn_117 sn_141 458356.5386570735
Csub_117_141 sn_117 sn_141 2.298752742373996e-17
Rsub_117_220 sn_117 sn_220 23764.82755108811
Csub_117_220 sn_117 sn_220 4.433646101398943e-16
Rsub_117_215 sn_117 sn_215 280187.8263902505
Csub_117_215 sn_117 sn_215 3.760507241865177e-17
Rsub_117_184 sn_117 sn_184 3841103.356177547
Csub_117_184 sn_117 sn_184 2.743087734227315e-18
Rsub_117_181 sn_117 sn_181 591468.1333472766
Csub_117_181 sn_117 sn_181 1.781411864507597e-17
Rsub_117_206 sn_117 sn_206 605023.7954854901
Csub_117_206 sn_117 sn_206 1.741499025468113e-17
Rsub_117_169 sn_117 sn_169 1192793.816963932
Csub_117_169 sn_117 sn_169 8.833449127904562e-18
Rsub_117_189 sn_117 sn_189 324322.2092286755
Csub_117_189 sn_117 sn_189 3.248770266855471e-17
Rsub_117_128 sn_117 sn_128 124199.0798145836
Csub_117_128 sn_117 sn_128 8.483543934431628e-17
Rsub_117_170 sn_117 sn_170 565064.6920535683
Csub_117_170 sn_117 sn_170 1.86465083563054e-17
Rsub_117_205 sn_117 sn_205 79740.68323021202
Csub_117_205 sn_117 sn_205 1.321343519444282e-16
Rsub_117_130 sn_117 sn_130 55393.44030897583
Csub_117_130 sn_117 sn_130 1.902117551005889e-16
Rsub_117_209 sn_117 sn_209 130806.5233867227
Csub_117_209 sn_117 sn_209 8.055013793982915e-17
Rsub_117_163 sn_117 sn_163 1072252.062108568
Csub_117_163 sn_117 sn_163 9.826498707319027e-18
Rsub_117_175 sn_117 sn_175 505083.6867161872
Csub_117_175 sn_117 sn_175 2.086086678176677e-17
Rsub_117_229 sn_117 sn_229 733.6709190267708
Csub_117_229 sn_117 sn_229 1.43613208987578e-14
Rsub_117_121 sn_117 sn_121 114606.5451374792
Csub_117_121 sn_117 sn_121 9.193614107807452e-17
Rsub_117_223 sn_117 sn_223 89381.88140802026
Csub_117_223 sn_117 sn_223 1.178816482294874e-16
Rsub_117_144 sn_117 sn_144 63357499.51063576
Csub_117_144 sn_117 sn_144 1.66302072897641e-19
Rsub_117_172 sn_117 sn_172 1358140.03956886
Csub_117_172 sn_117 sn_172 7.758024353346358e-18
Rsub_117_202 sn_117 sn_202 104682.0218167861
Csub_117_202 sn_117 sn_202 1.006522736126639e-16
Rsub_117_193 sn_117 sn_193 52803.00898691373
Csub_117_193 sn_117 sn_193 1.995432401369641e-16
Rsub_117_230 sn_117 0 9093.487027363055
Csub_117_230 sn_117 0 1.158684613561866e-15
Rsub_117_225 sn_117 sn_225 151293.21804133
Csub_117_225 sn_117 sn_225 6.964280116873225e-17
Rsub_117_146 sn_117 sn_146 55163225.16932666
Csub_117_146 sn_117 sn_146 1.910055742732167e-19
Rsub_117_217 sn_117 sn_217 3102.75201622443
Csub_117_217 sn_117 sn_217 3.395850988778431e-15
Rsub_117_138 sn_117 sn_138 62829548.27485631
Csub_117_138 sn_117 sn_138 1.67699494768556e-19
Rsub_117_199 sn_117 sn_199 4809868.681064187
Csub_117_199 sn_117 sn_199 2.190596916649874e-18
Rsub_117_124 sn_117 sn_124 28824.22501508201
Csub_117_124 sn_117 sn_124 3.6554264673957e-16
Rsub_117_198 sn_117 sn_198 287992.4107059036
Csub_117_198 sn_117 sn_198 3.658597626376275e-17
Rsub_117_119 sn_117 sn_119 2584141.158549685
Csub_117_119 sn_117 sn_119 4.077363756762988e-18
Rsub_117_157 sn_117 sn_157 145958.6694177838
Csub_117_157 sn_117 sn_157 7.218813068287823e-17
Rsub_117_153 sn_117 sn_153 1958961.59303484
Csub_117_153 sn_117 sn_153 5.378606471761804e-18
Rsub_117_194 sn_117 sn_194 624984.3180187962
Csub_117_194 sn_117 sn_194 1.685879661049851e-17
Rsub_117_129 sn_117 sn_129 15878353.09638936
Csub_117_129 sn_117 sn_129 6.635753367032715e-19
Rsub_117_122 sn_117 sn_122 109876.6612802621
Csub_117_122 sn_117 sn_122 9.589373557096551e-17
Rsub_117_177 sn_117 sn_177 56532.0224081538
Csub_117_177 sn_117 sn_177 1.863807989418452e-16
Rsub_117_167 sn_117 sn_167 341680.9171180031
Csub_117_167 sn_117 sn_167 3.083720212150776e-17
Rsub_117_131 sn_117 sn_131 791233.4113464478
Csub_117_131 sn_117 sn_131 1.331653005438684e-17
Rsub_117_210 sn_117 sn_210 1528083.734634448
Csub_117_210 sn_117 sn_210 6.895226526804545e-18
Rsub_117_190 sn_117 sn_190 3916299.068362609
Csub_117_190 sn_117 sn_190 2.690418509492246e-18
Rsub_117_152 sn_117 sn_152 44477253.76151669
Csub_117_152 sn_117 sn_152 2.368959998907699e-19
Rsub_117_133 sn_117 sn_133 816931.2790337319
Csub_117_133 sn_117 sn_133 1.289763750347836e-17
Rsub_117_212 sn_117 sn_212 809852.4499476812
Csub_117_212 sn_117 sn_212 1.30103743007886e-17
Rsub_117_134 sn_117 sn_134 9821944.988842934
Csub_117_134 sn_117 sn_134 1.072749187070253e-18
Rsub_117_139 sn_117 sn_139 433776.7980449224
Csub_117_139 sn_117 sn_139 2.429010391915621e-17
Rsub_117_135 sn_117 sn_135 1222497.716107903
Csub_117_135 sn_117 sn_135 8.618816512619153e-18
Rsub_117_174 sn_117 sn_174 182412055.219762
Csub_117_174 sn_117 sn_174 5.776199105665529e-20
Rsub_117_162 sn_117 sn_162 5988735.620017063
Csub_117_162 sn_117 sn_162 1.759383644689925e-18
Rsub_117_216 sn_117 sn_216 12145112.16727106
Csub_117_216 sn_117 sn_216 8.675492953143712e-19
Rsub_117_219 sn_117 sn_219 1618145.039950532
Csub_117_219 sn_117 sn_219 6.511458022670272e-18
Rsub_117_178 sn_117 sn_178 7638153.858925737
Csub_117_178 sn_117 sn_178 1.379454210642452e-18
Rsub_117_168 sn_117 sn_168 11912196.16620932
Csub_117_168 sn_117 sn_168 8.845122557768373e-19
Rsub_117_228 sn_117 sn_228 6779098.637825392
Csub_117_228 sn_117 sn_228 1.554260243897249e-18
Rsub_117_164 sn_117 sn_164 18815655.99925346
Csub_117_164 sn_117 sn_164 5.599849137679839e-19
Rsub_117_185 sn_117 sn_185 1927466.439086333
Csub_117_185 sn_117 sn_185 5.466493884700042e-18
Rsub_117_221 sn_117 sn_221 831557.8291171866
Csub_117_221 sn_117 sn_221 1.267077662345616e-17
Rsub_33_153 sn_33 sn_153 20057689.48008067
Csub_33_153 sn_33 sn_153 5.253089351439907e-19
Rsub_33_42 sn_33 sn_42 67269401.485916
Csub_33_42 sn_33 sn_42 1.56631146843725e-19
Rsub_33_132 sn_33 sn_132 5808582.314606902
Csub_33_132 sn_33 sn_132 1.813950966268275e-18
Rsub_33_137 sn_33 sn_137 2842296.098007327
Csub_33_137 sn_33 sn_137 3.707032321374576e-18
Rsub_33_186 sn_33 sn_186 3130441.430794419
Csub_33_186 sn_33 sn_186 3.365813970701293e-18
Rsub_33_184 sn_33 sn_184 4893323.832957552
Csub_33_184 sn_33 sn_184 2.153236503839088e-18
Rsub_33_221 sn_33 sn_221 3010736.562131061
Csub_33_221 sn_33 sn_221 3.499636479244821e-18
Rsub_33_154 sn_33 sn_154 15020171.09666185
Csub_33_154 sn_33 sn_154 7.014889134366569e-19
Rsub_33_56 sn_33 sn_56 2613335.869763169
Csub_33_56 sn_33 sn_56 4.03181375350152e-18
Rsub_33_177 sn_33 sn_177 1061913951.766697
Rsub_33_64 sn_33 sn_64 5360596.011875658
Csub_33_64 sn_33 sn_64 1.965543286397236e-18
Rsub_33_222 sn_33 sn_222 3274665.654677269
Csub_33_222 sn_33 sn_222 3.217575353740476e-18
Rsub_33_160 sn_33 sn_160 1242920.804590687
Csub_33_160 sn_33 sn_160 8.477196184434151e-18
Rsub_33_81 sn_33 sn_81 739308.2872958942
Csub_33_81 sn_33 sn_81 1.425181305726791e-17
Rsub_33_162 sn_33 sn_162 1219138.145980394
Csub_33_162 sn_33 sn_162 8.642567322636665e-18
Rsub_33_166 sn_33 sn_166 23792954.45091011
Csub_33_166 sn_33 sn_166 4.428404855718524e-19
Rsub_33_87 sn_33 sn_87 4877026.755481094
Csub_33_87 sn_33 sn_87 2.160431761090601e-18
Rsub_33_35 sn_33 sn_35 3756368.368752799
Csub_33_35 sn_33 sn_35 2.804965452770106e-18
Rsub_33_146 sn_33 sn_146 8198608.217727771
Csub_33_146 sn_33 sn_146 1.285155141264961e-18
Rsub_33_52 sn_33 sn_52 1709959.449036254
Csub_33_52 sn_33 sn_52 6.16183238039267e-18
Rsub_33_120 sn_33 sn_120 13454895.19114877
Csub_33_120 sn_33 sn_120 7.830966612925658e-19
Rsub_33_63 sn_33 sn_63 89051308.1133702
Csub_33_63 sn_33 sn_63 1.183192445507496e-19
Rsub_33_230 sn_33 0 200371.7708197579
Csub_33_230 sn_33 0 5.258467028126418e-17
Rsub_33_57 sn_33 sn_57 200361.1482554923
Csub_33_57 sn_33 sn_57 5.258745816726059e-17
Rsub_33_224 sn_33 sn_224 20286.99231195057
Csub_33_224 sn_33 sn_224 5.193713952374902e-16
Rsub_33_226 sn_33 sn_226 585073.2632603396
Csub_33_226 sn_33 sn_226 1.800882755010049e-17
Rsub_33_59 sn_33 sn_59 1077266.003834408
Csub_33_59 sn_33 sn_59 9.780763028561713e-18
Rsub_33_138 sn_33 sn_138 14132613.65558135
Csub_33_138 sn_33 sn_138 7.455438717146889e-19
Rsub_33_128 sn_33 sn_128 16638111.17907126
Csub_33_128 sn_33 sn_128 6.332740170340746e-19
Rsub_33_170 sn_33 sn_170 53937837.74755763
Csub_33_170 sn_33 sn_170 1.953449367314897e-19
Rsub_33_158 sn_33 sn_158 8229450.689467588
Csub_33_158 sn_33 sn_158 1.280338615518416e-18
Rsub_33_214 sn_33 sn_214 2611066.589191877
Csub_33_214 sn_33 sn_214 4.035317806847291e-18
Rsub_33_47 sn_33 sn_47 6926754.011935646
Csub_33_47 sn_33 sn_47 1.521128581161443e-18
Rsub_33_126 sn_33 sn_126 6573560.496406344
Csub_33_126 sn_33 sn_126 1.602857919690573e-18
Rsub_33_84 sn_33 sn_84 1322885.192128574
Csub_33_84 sn_33 sn_84 7.964775450601564e-18
Rsub_33_181 sn_33 sn_181 39477944.61346144
Csub_33_181 sn_33 sn_181 2.668954426426042e-19
Rsub_33_191 sn_33 sn_191 44755230.02061374
Csub_33_191 sn_33 sn_191 2.354246307610758e-19
Rsub_33_208 sn_33 sn_208 393274.8527376467
Csub_33_208 sn_33 sn_208 2.679165329001822e-17
Rsub_33_44 sn_33 sn_44 73520.06494265547
Csub_33_44 sn_33 sn_44 1.433143932945148e-16
Rsub_33_123 sn_33 sn_123 22377615.01030687
Csub_33_123 sn_33 sn_123 4.708492615221516e-19
Rsub_33_155 sn_33 sn_155 369169.1353186765
Csub_33_155 sn_33 sn_155 2.854107370903213e-17
Rsub_33_116 sn_33 sn_116 5861840.112957382
Csub_33_116 sn_33 sn_116 1.797470299290404e-18
Rsub_33_215 sn_33 sn_215 2259692.049975195
Csub_33_215 sn_33 sn_215 4.662796199307628e-18
Rsub_33_48 sn_33 sn_48 8593047.366298629
Csub_33_48 sn_33 sn_48 1.226163787197706e-18
Rsub_33_93 sn_33 sn_93 1498217.402056085
Csub_33_93 sn_33 sn_93 7.032679962047038e-18
Rsub_33_165 sn_33 sn_165 8898919.78677916
Csub_33_165 sn_33 sn_165 1.184018257798403e-18
Rsub_33_169 sn_33 sn_169 29873094.90007761
Csub_33_169 sn_33 sn_169 3.527081320992499e-19
Rsub_33_171 sn_33 sn_171 17223943.98993712
Csub_33_171 sn_33 sn_171 6.117346589367575e-19
Rsub_33_194 sn_33 sn_194 3519312.425348428
Csub_33_194 sn_33 sn_194 2.99390398713659e-18
Rsub_33_203 sn_33 sn_203 7255290.914171692
Csub_33_203 sn_33 sn_203 1.452248245711166e-18
Rsub_33_36 sn_33 sn_36 5601254.17823648
Csub_33_36 sn_33 sn_36 1.881093620633968e-18
Rsub_33_185 sn_33 sn_185 5693564.322108372
Csub_33_185 sn_33 sn_185 1.850595322391696e-18
Rsub_33_34 sn_33 sn_34 5427620.266633068
Csub_33_34 sn_33 sn_34 1.941271309454766e-18
Rsub_33_192 sn_33 sn_192 10391673.71899669
Csub_33_192 sn_33 sn_192 1.013935174173972e-18
Rsub_33_133 sn_33 sn_133 68026982.99569528
Csub_33_133 sn_33 sn_133 1.548868263479617e-19
Rsub_33_45 sn_33 sn_45 10063.53807810916
Csub_33_45 sn_33 sn_45 1.046995939246221e-15
Rsub_33_212 sn_33 sn_212 16166981.03876382
Csub_33_212 sn_33 sn_212 6.51728574244413e-19
Rsub_33_164 sn_33 sn_164 4911076.296770811
Csub_33_164 sn_33 sn_164 2.145453026082709e-18
Rsub_33_218 sn_33 sn_218 4552321.934669934
Csub_33_218 sn_33 sn_218 2.31452951997648e-18
Rsub_33_51 sn_33 sn_51 29019872.51910247
Csub_33_51 sn_33 sn_51 3.630782146025731e-19
Rsub_33_130 sn_33 sn_130 30217344.21219735
Csub_33_130 sn_33 sn_130 3.486899255023514e-19
Rsub_33_197 sn_33 sn_197 14300774.93197722
Csub_33_197 sn_33 sn_197 7.367771014051774e-19
Rsub_33_118 sn_33 sn_118 5989617.287371057
Csub_33_118 sn_33 sn_118 1.75912466468365e-18
Rsub_33_141 sn_33 sn_141 7831521.642786739
Csub_33_141 sn_33 sn_141 1.34539416256797e-18
Rsub_33_103 sn_33 sn_103 16599805.78382489
Csub_33_103 sn_33 sn_103 6.347353480784044e-19
Rsub_33_43 sn_33 sn_43 7318273.479231444
Csub_33_43 sn_33 sn_43 1.439749898952469e-18
Rsub_33_198 sn_33 sn_198 9338153.488302764
Csub_33_198 sn_33 sn_198 1.128326228030874e-18
Rsub_33_207 sn_33 sn_207 490143.1511828938
Csub_33_207 sn_33 sn_207 2.14967473824772e-17
Rsub_33_40 sn_33 sn_40 187717562.5479545
Csub_33_40 sn_33 sn_40 5.612944979262843e-20
Rsub_33_175 sn_33 sn_175 14983908.95412483
Csub_33_175 sn_33 sn_175 7.031865673028848e-19
Rsub_33_200 sn_33 sn_200 21193486.35425391
Csub_33_200 sn_33 sn_200 4.971566889048031e-19
Rsub_33_227 sn_33 sn_227 42386972.70850782
Csub_33_227 sn_33 sn_227 2.485783444524015e-19
Rsub_33_183 sn_33 sn_183 5624921.071795734
Csub_33_183 sn_33 sn_183 1.873178906467086e-18
Rsub_33_74 sn_33 sn_74 15070986.80849151
Csub_33_74 sn_33 sn_74 6.991236629769581e-19
Rsub_33_77 sn_33 sn_77 21676648.79356959
Csub_33_77 sn_33 sn_77 4.860752970890806e-19
Rsub_33_70 sn_33 sn_70 29344296.14125399
Csub_33_70 sn_33 sn_70 3.59064107433716e-19
Rsub_33_89 sn_33 sn_89 762417.230294582
Csub_33_89 sn_33 sn_89 1.381983916884843e-17
Rsub_200_228 sn_200 sn_228 21629223.28721019
Csub_200_228 sn_200 sn_228 4.871410943573015e-19
Rsub_200_219 sn_200 sn_219 11646906.75819592
Csub_200_219 sn_200 sn_219 9.046593847602916e-19
Rsub_200_201 sn_200 sn_201 13328764.2313856
Csub_200_201 sn_200 sn_201 7.905071557511282e-19
Rsub_200_209 sn_200 sn_209 26537963.91895264
Csub_200_209 sn_200 sn_209 3.970343593204282e-19
Rsub_200_202 sn_200 sn_202 7742850.137631919
Csub_200_202 sn_200 sn_202 1.360801683480922e-18
Rsub_200_210 sn_200 sn_210 5256593.920412996
Csub_200_210 sn_200 sn_210 2.004431702687466e-18
Rsub_200_217 sn_200 sn_217 8885891.600787979
Csub_200_217 sn_200 sn_217 1.185754224291421e-18
Rsub_200_223 sn_200 sn_223 14087442.52893934
Csub_200_223 sn_200 sn_223 7.479344444944687e-19
Rsub_200_204 sn_200 sn_204 4529623.032082709
Csub_200_204 sn_200 sn_204 2.326128118742224e-18
Rsub_200_214 sn_200 sn_214 16726.94610020125
Csub_200_214 sn_200 sn_214 6.299107702692501e-16
Rsub_200_203 sn_200 sn_203 131958.2177139281
Csub_200_203 sn_200 sn_203 7.984711891965699e-17
Rsub_200_212 sn_200 sn_212 24446.87691728768
Csub_200_212 sn_200 sn_212 4.309950730262439e-16
Rsub_200_206 sn_200 sn_206 1909822.589394305
Csub_200_206 sn_200 sn_206 5.516995955928878e-18
Rsub_200_213 sn_200 sn_213 184448.9833890565
Csub_200_213 sn_200 sn_213 5.712410721183262e-17
Rsub_200_230 sn_200 0 67927.07716694829
Csub_200_230 sn_200 0 1.551146308906223e-16
Rsub_200_227 sn_200 sn_227 6345.299636627653
Csub_200_227 sn_200 sn_227 1.660517880260394e-15
Rsub_200_215 sn_200 sn_215 116727.0808351721
Csub_200_215 sn_200 sn_215 9.026597278748327e-17
Rsub_200_218 sn_200 sn_218 473563.1566636738
Csub_200_218 sn_200 sn_218 2.224937340240143e-17
Rsub_200_207 sn_200 sn_207 1919072.798290093
Csub_200_207 sn_200 sn_207 5.490403236197228e-18
Rsub_200_226 sn_200 sn_226 138703.1257419815
Csub_200_226 sn_200 sn_226 7.596428303879895e-17
Rsub_200_211 sn_200 sn_211 43751.85843766307
Csub_200_211 sn_200 sn_211 2.408236787756619e-16
Rsub_200_221 sn_200 sn_221 140758.2797346942
Csub_200_221 sn_200 sn_221 7.485515965447654e-17
Rsub_200_222 sn_200 sn_222 156397.3159964256
Csub_200_222 sn_200 sn_222 6.73699764928882e-17
Rsub_191_196 sn_191 sn_196 12687092.72828824
Csub_191_196 sn_191 sn_196 8.304884127422623e-19
Rsub_191_225 sn_191 sn_225 437128.8618145273
Csub_191_225 sn_191 sn_225 2.410383853057181e-17
Rsub_191_197 sn_191 sn_197 36875439.20487783
Csub_191_197 sn_191 sn_197 2.857317425750484e-19
Rsub_191_199 sn_191 sn_199 79672439.14259084
Csub_191_199 sn_191 sn_199 1.322475327179668e-19
Rsub_191_210 sn_191 sn_210 1382809.426948256
Csub_191_210 sn_191 sn_210 7.619620821853327e-18
Rsub_191_211 sn_191 sn_211 35238703.80884612
Csub_191_211 sn_191 sn_211 2.990031517443325e-19
Rsub_191_230 sn_191 0 47317.73236407189
Csub_191_230 sn_191 0 2.226751574052669e-16
Rsub_191_218 sn_191 sn_218 885402.8500576305
Csub_191_218 sn_191 sn_218 1.190021412461479e-17
Rsub_191_219 sn_191 sn_219 4572607.783567201
Csub_191_219 sn_191 sn_219 2.304261375772369e-18
Rsub_191_213 sn_191 sn_213 7363785.229271277
Csub_191_213 sn_191 sn_213 1.430851549057562e-18
Rsub_191_214 sn_191 sn_214 5242630.195188692
Csub_191_214 sn_191 sn_214 2.009770498765987e-18
Rsub_191_216 sn_191 sn_216 284428.7869915731
Csub_191_216 sn_191 sn_216 3.704436394668508e-17
Rsub_191_192 sn_191 sn_192 3710815.993996076
Csub_191_192 sn_191 sn_192 2.839397997442485e-18
Rsub_191_229 sn_191 sn_229 3182713.855504034
Csub_191_229 sn_191 sn_229 3.310534336603558e-18
Rsub_191_212 sn_191 sn_212 2624119.817909018
Csub_191_212 sn_191 sn_212 4.015244818594376e-18
Rsub_191_195 sn_191 sn_195 110879.6253108563
Csub_191_195 sn_191 sn_195 9.502632672766045e-17
Rsub_191_206 sn_191 sn_206 5196066.438430957
Csub_191_206 sn_191 sn_206 2.027780750511666e-18
Rsub_191_215 sn_191 sn_215 2529318.689466543
Csub_191_215 sn_191 sn_215 4.165739788390305e-18
Rsub_191_226 sn_191 sn_226 1012306.964615414
Csub_191_226 sn_191 sn_226 1.040838784136285e-17
Rsub_191_207 sn_191 sn_207 12221835.24114897
Csub_191_207 sn_191 sn_207 8.621032188975468e-19
Rsub_191_222 sn_191 sn_222 1019017.71325521
Csub_191_222 sn_191 sn_222 1.03398433267383e-17
Rsub_191_221 sn_191 sn_221 8283925.261883069
Csub_191_221 sn_191 sn_221 1.271919189168891e-18
Rsub_191_228 sn_191 sn_228 15725490.54154201
Csub_191_228 sn_191 sn_228 6.700257441506058e-19
Rsub_24_58 sn_24 sn_58 122338103.4850837
Csub_24_58 sn_24 sn_58 8.612593461950046e-20
Rsub_24_197 sn_24 sn_197 274814511.768045
Csub_24_197 sn_24 sn_197 3.834034612816676e-20
Rsub_24_56 sn_24 sn_56 274814511.768045
Csub_24_56 sn_24 sn_56 3.834034612816676e-20
Rsub_24_123 sn_24 sn_123 54797204.95489112
Csub_24_123 sn_24 sn_123 1.922814039676585e-19
Rsub_24_205 sn_24 sn_205 38195246.86009416
Csub_24_205 sn_24 sn_205 2.758584999024673e-19
Rsub_24_106 sn_24 sn_106 274814511.768045
Csub_24_106 sn_24 sn_106 3.834034612816676e-20
Rsub_24_57 sn_24 sn_57 133896180.8960272
Csub_24_57 sn_24 sn_57 7.869144162081644e-20
Rsub_24_104 sn_24 sn_104 367081868.6376702
Csub_24_104 sn_24 sn_104 2.870336130011936e-20
Rsub_24_63 sn_24 sn_63 28161591.48321397
Csub_24_63 sn_24 sn_63 3.74143752085545e-19
Rsub_24_50 sn_24 sn_50 20603129.84991907
Csub_24_50 sn_24 sn_50 5.114020820614002e-19
Rsub_24_81 sn_24 sn_81 60693896.00861883
Csub_24_81 sn_24 sn_81 1.736003815067955e-19
Rsub_24_143 sn_24 sn_143 274814511.768045
Csub_24_143 sn_24 sn_143 3.834034612816676e-20
Rsub_24_179 sn_24 sn_179 36294404.571637
Csub_24_179 sn_24 sn_179 2.903060024427002e-19
Rsub_24_223 sn_24 sn_223 57398457.58845714
Csub_24_223 sn_24 sn_223 1.835673630426768e-19
Rsub_24_80 sn_24 sn_80 42048430.66206488
Csub_24_80 sn_24 sn_80 2.505797085962538e-19
Rsub_24_65 sn_24 sn_65 66712047.74313651
Csub_24_65 sn_24 sn_65 1.579397404018979e-19
Rsub_24_194 sn_24 sn_194 256011391.2036426
Csub_24_194 sn_24 sn_194 4.115630735293659e-20
Rsub_24_176 sn_24 sn_176 71529625.3280964
Csub_24_176 sn_24 sn_176 1.473023723233643e-19
Rsub_24_111 sn_24 sn_111 34462580.60533979
Csub_24_111 sn_24 sn_111 3.057369273326395e-19
Rsub_24_142 sn_24 sn_142 400617185.1158221
Csub_24_142 sn_24 sn_142 2.630062786543669e-20
Rsub_24_95 sn_24 sn_95 34226968.95596592
Csub_24_95 sn_24 sn_95 3.078415595545584e-19
Rsub_24_209 sn_24 sn_209 11224912.11713732
Csub_24_209 sn_24 sn_209 9.386695764097538e-19
Rsub_24_51 sn_24 sn_51 1918741.319233072
Csub_24_51 sn_24 sn_51 5.491351750553572e-18
Rsub_24_218 sn_24 sn_218 20360891.46566788
Csub_24_218 sn_24 sn_218 5.174863546616514e-19
Rsub_24_130 sn_24 sn_130 30426053.63942457
Csub_24_130 sn_24 sn_130 3.462980650430902e-19
Rsub_24_121 sn_24 sn_121 273340392.4207138
Csub_24_121 sn_24 sn_121 3.85471148589437e-20
Rsub_24_225 sn_24 sn_225 13746215.889955
Csub_24_225 sn_24 sn_225 7.665006563682373e-19
Rsub_24_202 sn_24 sn_202 21994401.7845191
Csub_24_202 sn_24 sn_202 4.790529701810836e-19
Rsub_24_35 sn_24 sn_35 4781892.30403367
Csub_24_35 sn_24 sn_35 2.203412965478575e-18
Rsub_24_211 sn_24 sn_211 22076766.82609361
Csub_24_211 sn_24 sn_211 4.772656967947144e-19
Rsub_24_183 sn_24 sn_183 20497539.44616106
Csub_24_183 sn_24 sn_183 5.140365032547044e-19
Rsub_24_145 sn_24 sn_145 31692657.75325064
Csub_24_145 sn_24 sn_145 3.324581858758532e-19
Rsub_24_66 sn_24 sn_66 10940405.43804856
Csub_24_66 sn_24 sn_66 9.630798019227152e-19
Rsub_24_181 sn_24 sn_181 9964921.538938452
Csub_24_181 sn_24 sn_181 1.057357397251764e-18
Rsub_24_138 sn_24 sn_138 1143205.64622796
Csub_24_138 sn_24 sn_138 9.216612546478783e-18
Rsub_24_157 sn_24 sn_157 46299291.78065291
Csub_24_157 sn_24 sn_157 2.275733190941137e-19
Rsub_24_220 sn_24 sn_220 19005496.30562839
Csub_24_220 sn_24 sn_220 5.543913893534929e-19
Rsub_24_53 sn_24 sn_53 15081199.16646595
Csub_24_53 sn_24 sn_53 6.986502456421747e-19
Rsub_24_62 sn_24 sn_62 52082868.32616492
Csub_24_62 sn_24 sn_62 2.023022894254996e-19
Rsub_24_229 sn_24 sn_229 9515918.80722581
Csub_24_229 sn_24 sn_229 1.107248150775439e-18
Rsub_24_141 sn_24 sn_141 6571457.677591773
Csub_24_141 sn_24 sn_141 1.603370822604351e-18
Rsub_24_203 sn_24 sn_203 34229187.80926549
Csub_24_203 sn_24 sn_203 3.078216042093141e-19
Rsub_24_36 sn_24 sn_36 275394493.1506016
Csub_24_36 sn_24 sn_36 3.825960127847598e-20
Rsub_24_139 sn_24 sn_139 9718412.535375336
Csub_24_139 sn_24 sn_139 1.084177427525006e-18
Rsub_24_60 sn_24 sn_60 3445043.820844387
Csub_24_60 sn_24 sn_60 3.058446873296227e-18
Rsub_24_227 sn_24 sn_227 13436757.80309115
Csub_24_227 sn_24 sn_227 7.841537115304753e-19
Rsub_24_156 sn_24 sn_156 120777296.9914417
Csub_24_156 sn_24 sn_156 8.723894113126757e-20
Rsub_24_77 sn_24 sn_77 21730378.4579021
Csub_24_77 sn_24 sn_77 4.848734467575958e-19
Rsub_24_69 sn_24 sn_69 22973509.84843588
Csub_24_69 sn_24 sn_69 4.586362106505621e-19
Rsub_24_135 sn_24 sn_135 35178701.39823624
Csub_24_135 sn_24 sn_135 2.995131452680136e-19
Rsub_24_190 sn_24 sn_190 34199190.03611964
Csub_24_190 sn_24 sn_190 3.080916095118581e-19
Rsub_24_32 sn_24 sn_32 371495040.0568605
Csub_24_32 sn_24 sn_32 2.83623800215941e-20
Rsub_24_199 sn_24 sn_199 177985.8298294982
Csub_24_199 sn_24 sn_199 5.919844019225263e-17
Rsub_24_170 sn_24 sn_170 522441.6746122476
Csub_24_170 sn_24 sn_170 2.016776994302781e-17
Rsub_24_129 sn_24 sn_129 10931809.21154818
Csub_24_129 sn_24 sn_129 9.638371195775573e-19
Rsub_24_198 sn_24 sn_198 1268609.085883725
Csub_24_198 sn_24 sn_198 8.305539996105411e-18
Rsub_24_31 sn_24 sn_31 29022234790.72956
Rsub_24_109 sn_24 sn_109 116162895.4909327
Csub_24_109 sn_24 sn_109 9.070438075514783e-20
Rsub_24_188 sn_24 sn_188 1903059.825594296
Csub_24_188 sn_24 sn_188 5.536601298879094e-18
Rsub_24_222 sn_24 sn_222 1791859.049280146
Csub_24_222 sn_24 sn_222 5.880196607240332e-18
Rsub_24_41 sn_24 sn_41 2410085.243370521
Csub_24_41 sn_24 sn_41 4.37183022103179e-18
Rsub_24_208 sn_24 sn_208 60594703.41463684
Csub_24_208 sn_24 sn_208 1.738845626511455e-19
Rsub_24_48 sn_24 sn_48 113328.3681718053
Csub_24_48 sn_24 sn_48 9.297304525074201e-17
Rsub_24_215 sn_24 sn_215 580633.2504278749
Csub_24_215 sn_24 sn_215 1.814653827431611e-17
Rsub_24_206 sn_24 sn_206 219268.79949608
Csub_24_206 sn_24 sn_206 4.805281702843624e-17
Rsub_24_39 sn_24 sn_39 7998596.478483342
Csub_24_39 sn_24 sn_39 1.317291543656905e-18
Rsub_24_99 sn_24 sn_99 3989894.521132814
Csub_24_99 sn_24 sn_99 2.640792493742034e-18
Rsub_24_178 sn_24 sn_178 815276.7316130436
Csub_24_178 sn_24 sn_178 1.292381236170365e-17
Rsub_24_133 sn_24 sn_133 200337.5585094088
Csub_24_133 sn_24 sn_133 5.259365034008418e-17
Rsub_24_212 sn_24 sn_212 1113886.943936781
Csub_24_212 sn_24 sn_212 9.459203700683648e-18
Rsub_24_45 sn_24 sn_45 11077902.370322
Csub_24_45 sn_24 sn_45 9.51126228595183e-19
Rsub_24_185 sn_24 sn_185 96488060.63034831
Csub_24_185 sn_24 sn_185 1.091998681846857e-19
Rsub_24_27 sn_24 sn_27 17775979.01926621
Csub_24_27 sn_24 sn_27 5.927371702458808e-19
Rsub_24_201 sn_24 sn_201 458796.90537878
Csub_24_201 sn_24 sn_201 2.296546332092442e-17
Rsub_24_34 sn_24 sn_34 4360378.521670342
Csub_24_34 sn_24 sn_34 2.416414870834141e-18
Rsub_24_43 sn_24 sn_43 18649487.19697359
Csub_24_43 sn_24 sn_43 5.649744355405036e-19
Rsub_24_117 sn_24 sn_117 9295909.513061998
Csub_24_117 sn_24 sn_117 1.13345375053671e-18
Rsub_24_47 sn_24 sn_47 10689633.77873342
Csub_24_47 sn_24 sn_47 9.856730099764403e-19
Rsub_24_214 sn_24 sn_214 15784064.17633621
Csub_24_214 sn_24 sn_214 6.675393222251661e-19
Rsub_24_192 sn_24 sn_192 32659926.80072692
Csub_24_192 sn_24 sn_192 3.226119754192311e-19
Rsub_24_25 sn_24 sn_25 63891021.93054669
Csub_24_25 sn_24 sn_25 1.649133662893009e-19
Rsub_24_219 sn_24 sn_219 26141940.48348092
Csub_24_219 sn_24 sn_219 4.030490203620501e-19
Rsub_24_52 sn_24 sn_52 1187531.803005713
Csub_24_52 sn_24 sn_52 8.872590591310093e-18
Rsub_24_61 sn_24 sn_61 3654214.739455565
Csub_24_61 sn_24 sn_61 2.883378305184061e-18
Rsub_24_76 sn_24 sn_76 2726406.868560911
Csub_24_76 sn_24 sn_76 3.864604224604053e-18
Rsub_24_72 sn_24 sn_72 8829156.885695247
Csub_24_72 sn_24 sn_72 1.193373686597518e-18
Rsub_24_114 sn_24 sn_114 2924845.190642347
Csub_24_114 sn_24 sn_114 3.602407243959468e-18
Rsub_24_125 sn_24 sn_125 77379940.16716218
Csub_24_125 sn_24 sn_125 1.361655679684976e-19
Rsub_24_204 sn_24 sn_204 2253118.398960189
Csub_24_204 sn_24 sn_204 4.676400275765611e-18
Rsub_24_37 sn_24 sn_37 17373646.13419453
Csub_24_37 sn_24 sn_37 6.064635725193148e-19
Rsub_24_46 sn_24 sn_46 3913841.396455517
Csub_24_46 sn_24 sn_46 2.692107940748987e-18
Rsub_24_213 sn_24 sn_213 9552984.382259574
Csub_24_213 sn_24 sn_213 1.102952028456871e-18
Rsub_24_83 sn_24 sn_83 20317737.24780777
Csub_24_83 sn_24 sn_83 5.185854789694584e-19
Rsub_24_207 sn_24 sn_207 39336338.6978151
Csub_24_207 sn_24 sn_207 2.678562329649465e-19
Rsub_24_40 sn_24 sn_40 77936105.25323063
Csub_24_40 sn_24 sn_40 1.351938676945015e-19
Rsub_24_49 sn_24 sn_49 6904883.978062688
Csub_24_49 sn_24 sn_49 1.525946494641353e-18
Rsub_24_216 sn_24 sn_216 24435106.43727282
Csub_24_216 sn_24 sn_216 4.312026849270383e-19
Rsub_24_177 sn_24 sn_177 3706579.777563373
Csub_24_177 sn_24 sn_177 2.842643119678504e-18
Rsub_24_97 sn_24 sn_97 3373695.668817603
Csub_24_97 sn_24 sn_97 3.12312802829746e-18
Rsub_24_150 sn_24 sn_150 50477846.72248802
Csub_24_150 sn_24 sn_150 2.087348051939777e-19
Rsub_24_195 sn_24 sn_195 791128.5269678705
Csub_24_195 sn_24 sn_195 1.331829550201255e-17
Rsub_24_116 sn_24 sn_116 71798399.45052479
Csub_24_116 sn_24 sn_116 1.467509524288286e-19
Rsub_24_131 sn_24 sn_131 9068857.584106732
Csub_24_131 sn_24 sn_131 1.161831399877235e-18
Rsub_24_93 sn_24 sn_93 32727746.31837458
Csub_24_93 sn_24 sn_93 3.219434482207052e-19
Rsub_24_79 sn_24 sn_79 11544335.71405953
Csub_24_79 sn_24 sn_79 9.126972537188008e-19
Rsub_24_96 sn_24 sn_96 28421080.45283732
Csub_24_96 sn_24 sn_96 3.707277603226421e-19
Rsub_24_151 sn_24 sn_151 27586912.85882008
Csub_24_151 sn_24 sn_151 3.819377527363045e-19
Rsub_24_148 sn_24 sn_148 35473437.43258649
Csub_24_148 sn_24 sn_148 2.970245982575969e-19
Rsub_24_85 sn_24 sn_85 66366829.12911654
Csub_24_85 sn_24 sn_85 1.587612914537666e-19
Rsub_24_110 sn_24 sn_110 129022982.0514413
Csub_24_110 sn_24 sn_110 8.166361786638224e-20
Rsub_24_169 sn_24 sn_169 23927131.17225577
Csub_24_169 sn_24 sn_169 4.403571588409802e-19
Rsub_24_71 sn_24 sn_71 31759912.65842951
Csub_24_71 sn_24 sn_71 3.317541712267107e-19
Rsub_24_75 sn_24 sn_75 55376214.22523969
Csub_24_75 sn_24 sn_75 1.902709249746369e-19
Rsub_24_226 sn_24 sn_226 19959200.35802638
Csub_24_226 sn_24 sn_226 5.279010838724741e-19
Rsub_24_59 sn_24 sn_59 273340392.4207138
Csub_24_59 sn_24 sn_59 3.85471148589437e-20
Rsub_24_166 sn_24 sn_166 4361281.484140512
Csub_24_166 sn_24 sn_166 2.415914574774678e-18
Rsub_24_128 sn_24 sn_128 35880759.2267333
Csub_24_128 sn_24 sn_128 2.936527467451049e-19
Rsub_24_132 sn_24 sn_132 9397700.366545891
Csub_24_132 sn_24 sn_132 1.121176787008232e-18
Rsub_24_230 sn_24 0 147836.0012062359
Csub_24_230 sn_24 0 7.12714319669082e-17
Rsub_24_101 sn_24 sn_101 5722794.210451007
Csub_24_101 sn_24 sn_101 1.841143174952579e-18
Rsub_24_191 sn_24 sn_191 61812125.41957767
Csub_24_191 sn_24 sn_191 1.704598156220785e-19
Rsub_24_134 sn_24 sn_134 19725268.8319554
Csub_24_134 sn_24 sn_134 5.341617187574474e-19
Rsub_24_154 sn_24 sn_154 16497603.73694232
Csub_24_154 sn_24 sn_154 6.386675101570138e-19
Rsub_24_122 sn_24 sn_122 148733020.3620039
Csub_24_122 sn_24 sn_122 7.084158902027992e-20
Rsub_24_87 sn_24 sn_87 21054982.3094696
Csub_24_87 sn_24 sn_87 5.004270888174129e-19
Rsub_24_153 sn_24 sn_153 7491278.522156358
Csub_24_153 sn_24 sn_153 1.406500034816097e-18
Rsub_24_78 sn_24 sn_78 67337687.55712485
Csub_24_78 sn_24 sn_78 1.564723097045996e-19
Rsub_24_115 sn_24 sn_115 118393403.7147783
Csub_24_115 sn_24 sn_115 8.899552822734501e-20
Rsub_24_160 sn_24 sn_160 13346672.06596603
Csub_24_160 sn_24 sn_160 7.894464964864161e-19
Rsub_24_100 sn_24 sn_100 106781554.2064543
Csub_24_100 sn_24 sn_100 9.867325476325699e-20
Rsub_24_161 sn_24 sn_161 307706665.4963932
Csub_24_161 sn_24 sn_161 3.424197355371721e-20
Rsub_24_137 sn_24 sn_137 102178706.2032597
Csub_24_137 sn_24 sn_137 1.031181925642142e-19
Rsub_24_196 sn_24 sn_196 91504579.40409826
Csub_24_196 sn_24 sn_196 1.151470622655864e-19
Rsub_24_112 sn_24 sn_112 42451488.95057898
Csub_24_112 sn_24 sn_112 2.482005640484442e-19
Rsub_24_159 sn_24 sn_159 36047643.98498689
Csub_24_159 sn_24 sn_159 2.922932635103208e-19
Rsub_24_186 sn_24 sn_186 28745091.60826069
Csub_24_186 sn_24 sn_186 3.665489623697026e-19
Rsub_24_217 sn_24 sn_217 22713369.99577098
Csub_24_217 sn_24 sn_217 4.638890443906737e-19
Rsub_24_94 sn_24 sn_94 181160513.5526607
Csub_24_94 sn_24 sn_94 5.816103794145628e-20
Rsub_24_127 sn_24 sn_127 32102429.25718652
Csub_24_127 sn_24 sn_127 3.28214522889145e-19
Rsub_24_126 sn_24 sn_126 43811230.41782758
Csub_24_126 sn_24 sn_126 2.404973200191729e-19
Rsub_24_155 sn_24 sn_155 9615974.83238028
Csub_24_155 sn_24 sn_155 1.09572702569375e-18
Rsub_24_182 sn_24 sn_182 39669080.24452727
Csub_24_182 sn_24 sn_182 2.656094731030123e-19
Rsub_24_84 sn_24 sn_84 273340392.4207138
Csub_24_84 sn_24 sn_84 3.85471148589437e-20
Rsub_24_30 sn_24 sn_30 273340392.4207138
Csub_24_30 sn_24 sn_30 3.85471148589437e-20
Rsub_24_144 sn_24 sn_144 26619889.93876365
Csub_24_144 sn_24 sn_144 3.958124367331386e-19
Rsub_24_73 sn_24 sn_73 55814189.34420302
Csub_24_73 sn_24 sn_73 1.88777865020167e-19
Rsub_24_224 sn_24 sn_224 22338126.75287366
Csub_24_224 sn_24 sn_224 4.716816060180403e-19
Rsub_24_221 sn_24 sn_221 22092586.66328834
Csub_24_221 sn_24 sn_221 4.769239411760992e-19
Rsub_24_54 sn_24 sn_54 31846497.83550305
Csub_24_54 sn_24 sn_54 3.308521884150081e-19
Rsub_24_98 sn_24 sn_98 33337608.62797483
Csub_24_98 sn_24 sn_98 3.160539683517805e-19
Rsub_24_175 sn_24 sn_175 76248175.92492284
Csub_24_175 sn_24 sn_175 1.381866959362367e-19
Rsub_24_105 sn_24 sn_105 19909952.19410308
Csub_24_105 sn_24 sn_105 5.292068709914176e-19
Rsub_24_140 sn_24 sn_140 17809240.37991096
Csub_24_140 sn_24 sn_140 5.916301469048214e-19
Rsub_24_82 sn_24 sn_82 271429618.8387992
Csub_24_82 sn_24 sn_82 3.881847363344518e-20
Rsub_24_180 sn_24 sn_180 29135174.56650246
Csub_24_180 sn_24 sn_180 3.61641337627134e-19
Rsub_24_158 sn_24 sn_158 5257971.891014782
Csub_24_158 sn_24 sn_158 2.00390639596905e-18
Rsub_24_164 sn_24 sn_164 24238422.28030094
Csub_24_164 sn_24 sn_164 4.347017054320906e-19
Rsub_24_189 sn_24 sn_189 51022934.29835575
Csub_24_189 sn_24 sn_189 2.065048521243034e-19
Rsub_24_67 sn_24 sn_67 32954746.43778654
Csub_24_67 sn_24 sn_67 3.197258252956444e-19
Rsub_24_107 sn_24 sn_107 38991841.07056761
Csub_24_107 sn_24 sn_107 2.702227751482939e-19
Rsub_24_200 sn_24 sn_200 106310823.7393247
Csub_24_200 sn_24 sn_200 9.911016707071685e-20
Rsub_24_136 sn_24 sn_136 147874010.2176408
Csub_24_136 sn_24 sn_136 7.125311261067728e-20
Rsub_24_92 sn_24 sn_92 67496489.56324175
Csub_24_92 sn_24 sn_92 1.56104170311816e-19
Rsub_24_165 sn_24 sn_165 47407813.99827683
Csub_24_165 sn_24 sn_165 2.222520427247073e-19
Rsub_24_162 sn_24 sn_162 941403963.683751
Csub_24_162 sn_24 sn_162 1.119230841242725e-20
Rsub_24_184 sn_24 sn_184 59440219.6510148
Csub_24_184 sn_24 sn_184 1.772618534065278e-19
Rsub_24_146 sn_24 sn_146 18884708.60866623
Csub_24_146 sn_24 sn_146 5.579373089926729e-19
Rsub_24_70 sn_24 sn_70 30610128.52381789
Csub_24_70 sn_24 sn_70 3.442155917127729e-19
Rsub_24_118 sn_24 sn_118 18427962.88015697
Csub_24_118 sn_24 sn_118 5.717660476500944e-19
Rsub_24_187 sn_24 sn_187 274814511.768045
Csub_24_187 sn_24 sn_187 3.834034612816676e-20
Rsub_24_171 sn_24 sn_171 274685165.459406
Csub_24_171 sn_24 sn_171 3.835840018738516e-20
Rsub_24_89 sn_24 sn_89 135608437.5975532
Csub_24_89 sn_24 sn_89 7.769784601087473e-20
Rsub_24_86 sn_24 sn_86 165156536.3606933
Csub_24_86 sn_24 sn_86 6.379695127063495e-20
Rsub_44_119 sn_44 sn_119 2893186.829303809
Csub_44_119 sn_44 sn_119 3.641826167432612e-18
Rsub_44_75 sn_44 sn_75 1446593.414651904
Csub_44_75 sn_44 sn_75 7.283652334865225e-18
Rsub_44_98 sn_44 sn_98 553509.0651967539
Csub_44_98 sn_44 sn_98 1.903579212110037e-17
Rsub_44_96 sn_44 sn_96 768405.4923150822
Csub_44_96 sn_44 sn_96 1.371213975902914e-17
Rsub_44_205 sn_44 sn_205 1945815.342939341
Csub_44_205 sn_44 sn_205 5.414945226155753e-18
Rsub_44_87 sn_44 sn_87 526004.4226728143
Csub_44_87 sn_44 sn_87 2.003116903217354e-17
Rsub_44_159 sn_44 sn_159 2189042.260806758
Csub_44_159 sn_44 sn_159 4.81328464547178e-18
Rsub_44_154 sn_44 sn_154 950529.4461656333
Csub_44_154 sn_44 sn_154 1.108485754411229e-17
Rsub_44_115 sn_44 sn_115 656866.8458254454
Csub_44_115 sn_44 sn_115 1.604051653572108e-17
Rsub_44_121 sn_44 sn_121 12735424.52530423
Csub_44_121 sn_44 sn_121 8.273366530730785e-19
Rsub_44_68 sn_44 sn_68 64428108.02176928
Csub_44_68 sn_44 sn_68 1.635386142127576e-19
Rsub_44_191 sn_44 sn_191 501817.8005908593
Csub_44_191 sn_44 sn_191 2.099663162570946e-17
Rsub_44_117 sn_44 sn_117 2375622.670210934
Csub_44_117 sn_44 sn_117 4.435251285632181e-18
Rsub_44_95 sn_44 sn_95 16947818.7538807
Csub_44_95 sn_44 sn_95 6.217014505077453e-19
Rsub_44_196 sn_44 sn_196 405703.80716812
Csub_44_196 sn_44 sn_196 2.597087657563878e-17
Rsub_44_112 sn_44 sn_112 789558.2640078209
Csub_44_112 sn_44 sn_112 1.334478275073267e-17
Rsub_44_58 sn_44 sn_58 76435217.73236507
Csub_44_58 sn_44 sn_58 1.378485443597883e-19
Rsub_44_78 sn_44 sn_78 8209357.498557219
Csub_44_78 sn_44 sn_78 1.283472367244546e-18
Rsub_44_157 sn_44 sn_157 40496.82466839984
Csub_44_157 sn_44 sn_157 2.601804854703027e-16
Rsub_44_178 sn_44 sn_178 1692038.99634871
Csub_44_178 sn_44 sn_178 6.22709259359088e-18
Rsub_44_88 sn_44 sn_88 11109917.50869388
Csub_44_88 sn_44 sn_88 9.483853947596687e-19
Rsub_44_105 sn_44 sn_105 6755083.117085219
Csub_44_105 sn_44 sn_105 1.559785915228891e-18
Rsub_44_86 sn_44 sn_86 3186683.496915504
Csub_44_86 sn_44 sn_86 3.306410414598316e-18
Rsub_44_136 sn_44 sn_136 453877.1758118959
Csub_44_136 sn_44 sn_136 2.321439381344155e-17
Rsub_44_110 sn_44 sn_110 9415099.468056681
Csub_44_110 sn_44 sn_110 1.119104852580467e-18
Rsub_44_97 sn_44 sn_97 3725325.620901091
Csub_44_97 sn_44 sn_97 2.828338935827417e-18
Rsub_44_79 sn_44 sn_79 222599.146808288
Csub_44_79 sn_44 sn_79 4.733388987921179e-17
Rsub_44_82 sn_44 sn_82 4494561.149934568
Csub_44_82 sn_44 sn_82 2.344274146182968e-18
Rsub_44_133 sn_44 sn_133 13600912.21461371
Csub_44_133 sn_44 sn_133 7.746894719979821e-19
Rsub_44_174 sn_44 sn_174 3086917.456648206
Csub_44_174 sn_44 sn_174 3.413270244572908e-18
Rsub_44_103 sn_44 sn_103 2836280.965925258
Csub_44_103 sn_44 sn_103 3.714894126785767e-18
Rsub_44_214 sn_44 sn_214 410378.8596519299
Csub_44_214 sn_44 sn_214 2.567501530455713e-17
Rsub_44_47 sn_44 sn_47 863078.9428490313
Csub_44_47 sn_44 sn_47 1.220801826939373e-17
Rsub_44_169 sn_44 sn_169 4097354.671969683
Csub_44_169 sn_44 sn_169 2.571533183180575e-18
Rsub_44_74 sn_44 sn_74 1620021.567833596
Csub_44_74 sn_44 sn_74 6.503915572136553e-18
Rsub_44_64 sn_44 sn_64 1185466.903971127
Csub_44_64 sn_44 sn_64 8.888045264641675e-18
Rsub_44_197 sn_44 sn_197 745993.3922209161
Csub_44_197 sn_44 sn_197 1.412409762888323e-17
Rsub_44_180 sn_44 sn_180 5064616.921057134
Csub_44_180 sn_44 sn_180 2.080410752967814e-18
Rsub_44_56 sn_44 sn_56 590869.8612187228
Csub_44_56 sn_44 sn_56 1.783215593446846e-17
Rsub_44_144 sn_44 sn_144 7195174.711746023
Csub_44_144 sn_44 sn_144 1.464381884296616e-18
Rsub_44_109 sn_44 sn_109 942653.420727196
Csub_44_109 sn_44 sn_109 1.117747336460285e-17
Rsub_44_228 sn_44 sn_228 3315380.13592253
Csub_44_228 sn_44 sn_228 3.178061962809627e-18
Rsub_44_61 sn_44 sn_61 2616726.502421917
Csub_44_61 sn_44 sn_61 4.02658951651154e-18
Rsub_44_139 sn_44 sn_139 229489.0015137336
Csub_44_139 sn_44 sn_139 4.591280380641445e-17
Rsub_44_118 sn_44 sn_118 1429297.756831679
Csub_44_118 sn_44 sn_118 7.371790413766689e-18
Rsub_44_203 sn_44 sn_203 1054484.551509244
Csub_44_203 sn_44 sn_203 9.992070047066626e-18
Rsub_44_150 sn_44 sn_150 1223274.620585077
Csub_44_150 sn_44 sn_150 8.613342682766144e-18
Rsub_44_200 sn_44 sn_200 3816321.802794162
Csub_44_200 sn_44 sn_200 2.760900166887289e-18
Rsub_44_80 sn_44 sn_80 843810.1729028745
Csub_44_80 sn_44 sn_80 1.248679364220321e-17
Rsub_44_101 sn_44 sn_101 4100042.843329181
Csub_44_101 sn_44 sn_101 2.569847171078465e-18
Rsub_44_201 sn_44 sn_201 4725514.389106729
Csub_44_201 sn_44 sn_201 2.229700861036153e-18
Rsub_44_135 sn_44 sn_135 367271.9225229762
Csub_44_135 sn_44 sn_135 2.868850804017246e-17
Rsub_44_142 sn_44 sn_142 260459.696335309
Csub_44_142 sn_44 sn_142 4.045341237235264e-17
Rsub_44_126 sn_44 sn_126 9435917.354895594
Csub_44_126 sn_44 sn_126 1.116635840050401e-18
Rsub_44_164 sn_44 sn_164 172710.9487288721
Csub_44_164 sn_44 sn_164 6.100645951965997e-17
Rsub_44_128 sn_44 sn_128 233697.9843912495
Csub_44_128 sn_44 sn_128 4.508589806487234e-17
Rsub_44_207 sn_44 sn_207 74687.99720247503
Csub_44_207 sn_44 sn_207 1.410733169570229e-16
Rsub_44_170 sn_44 sn_170 723797.6404662754
Csub_44_170 sn_44 sn_170 1.455722278321096e-17
Rsub_44_132 sn_44 sn_132 26223.20750554424
Csub_44_132 sn_44 sn_132 4.017999514362355e-16
Rsub_44_123 sn_44 sn_123 887900.9730937857
Csub_44_123 sn_44 sn_123 1.186673268925123e-17
Rsub_44_211 sn_44 sn_211 1454902.481291584
Csub_44_211 sn_44 sn_211 7.242054802790822e-18
Rsub_44_184 sn_44 sn_184 134415.729501804
Csub_44_184 sn_44 sn_184 7.838728057558616e-17
Rsub_44_190 sn_44 sn_190 74883.46799621035
Csub_44_190 sn_44 sn_190 1.407050686109146e-16
Rsub_44_116 sn_44 sn_116 39717.06994150768
Csub_44_116 sn_44 sn_116 2.652885401100167e-16
Rsub_44_195 sn_44 sn_195 416890.1641118198
Csub_44_195 sn_44 sn_195 2.527400358480002e-17
Rsub_44_120 sn_44 sn_120 6490152.504958414
Csub_44_120 sn_44 sn_120 1.623456997995075e-18
Rsub_44_199 sn_44 sn_199 5937749.748802251
Csub_44_199 sn_44 sn_199 1.774491002143598e-18
Rsub_44_125 sn_44 sn_125 431420.789090898
Csub_44_125 sn_44 sn_125 2.442275330410659e-17
Rsub_44_204 sn_44 sn_204 1164698.293780924
Csub_44_204 sn_44 sn_204 9.046534676397387e-18
Rsub_44_49 sn_44 sn_49 6537794.274710737
Csub_44_49 sn_44 sn_49 1.61162665258325e-18
Rsub_44_216 sn_44 sn_216 95352.90834522191
Csub_44_216 sn_44 sn_216 1.104998650285844e-16
Rsub_44_137 sn_44 sn_137 448478.8655627274
Csub_44_137 sn_44 sn_137 2.34938239263725e-17
Rsub_44_51 sn_44 sn_51 9900075.064032244
Csub_44_51 sn_44 sn_51 1.064283193216371e-18
Rsub_44_218 sn_44 sn_218 407803.1389280079
Csub_44_218 sn_44 sn_218 2.583718097395536e-17
Rsub_44_208 sn_44 sn_208 51455.685273064
Csub_44_208 sn_44 sn_208 2.047681115568708e-16
Rsub_44_217 sn_44 sn_217 1855892.068516474
Csub_44_217 sn_44 sn_217 5.677314797003496e-18
Rsub_44_50 sn_44 sn_50 1556911.754120104
Csub_44_50 sn_44 sn_50 6.767553443120313e-18
Rsub_44_129 sn_44 sn_129 10497582.56440144
Csub_44_129 sn_44 sn_129 1.00370570439336e-18
Rsub_44_72 sn_44 sn_72 190424215.5422311
Csub_44_72 sn_44 sn_72 5.533163664204929e-20
Rsub_44_146 sn_44 sn_146 135569.173211774
Csub_44_146 sn_44 sn_146 7.772034934351079e-17
Rsub_44_192 sn_44 sn_192 228097.0913379308
Csub_44_192 sn_44 sn_192 4.619297615952486e-17
Rsub_44_155 sn_44 sn_155 17334.60327881708
Csub_44_155 sn_44 sn_155 6.078295149163063e-16
Rsub_44_219 sn_44 sn_219 466533.4361513981
Csub_44_219 sn_44 sn_219 2.258462670789309e-17
Rsub_44_52 sn_44 sn_52 28137.16065698138
Csub_44_52 sn_44 sn_52 3.744686121915323e-16
Rsub_44_131 sn_44 sn_131 1304506.575081364
Csub_44_131 sn_44 sn_131 8.076987654564195e-18
Rsub_44_210 sn_44 sn_210 499099.4300720608
Csub_44_210 sn_44 sn_210 2.111099085147968e-17
Rsub_44_55 sn_44 sn_55 36038558.08756954
Csub_44_55 sn_44 sn_55 2.923669553212301e-19
Rsub_44_222 sn_44 sn_222 69857.6024686615
Csub_44_222 sn_44 sn_222 1.508280148457246e-16
Rsub_44_162 sn_44 sn_162 22050.95245404687
Csub_44_162 sn_44 sn_162 4.778244170716675e-16
Rsub_44_177 sn_44 sn_177 2443569.058900394
Csub_44_177 sn_44 sn_177 4.311923767348495e-18
Rsub_44_141 sn_44 sn_141 46098.56380568754
Csub_44_141 sn_44 sn_141 2.285642465271344e-16
Rsub_44_66 sn_44 sn_66 405199.7366175969
Csub_44_66 sn_44 sn_66 2.600318447929718e-17
Rsub_44_93 sn_44 sn_93 97953.26741003919
Csub_44_93 sn_44 sn_93 1.075664322469566e-16
Rsub_44_84 sn_44 sn_84 169248.9395454686
Csub_44_84 sn_44 sn_84 6.225435462417998e-17
Rsub_44_163 sn_44 sn_163 4458404.586898769
Csub_44_163 sn_44 sn_163 2.363285632082819e-18
Rsub_44_107 sn_44 sn_107 217464.1147227371
Csub_44_107 sn_44 sn_107 4.845159632734731e-17
Rsub_44_181 sn_44 sn_181 162083.9307978697
Csub_44_181 sn_44 sn_181 6.500634239534673e-17
Rsub_44_60 sn_44 sn_60 6952334.56989595
Csub_44_60 sn_44 sn_60 1.515531710434887e-18
Rsub_44_227 sn_44 sn_227 283298.2916391654
Csub_44_227 sn_44 sn_227 3.719218863363366e-17
Rsub_44_160 sn_44 sn_160 91012.74576927631
Csub_44_160 sn_44 sn_160 1.157693179474084e-16
Rsub_44_189 sn_44 sn_189 1864739.703650201
Csub_44_189 sn_44 sn_189 5.65037762729296e-18
Rsub_44_158 sn_44 sn_158 54277.08366370889
Csub_44_158 sn_44 sn_158 1.941239799749038e-16
Rsub_44_230 sn_44 0 12547.34580269395
Csub_44_230 sn_44 0 8.397380344748122e-16
Rsub_44_63 sn_44 sn_63 65386045.0834431
Csub_44_63 sn_44 sn_63 1.611426947261263e-19
Rsub_44_54 sn_44 sn_54 3534896.681852941
Csub_44_54 sn_44 sn_54 2.980704798621422e-18
Rsub_44_221 sn_44 sn_221 1778345.783095321
Csub_44_221 sn_44 sn_221 5.924878953456733e-18
Rsub_44_99 sn_44 sn_99 20824774.3646314
Csub_44_99 sn_44 sn_99 5.059590715242067e-19
Rsub_44_226 sn_44 sn_226 74721.42110440298
Csub_44_226 sn_44 sn_226 1.41010212954972e-16
Rsub_44_59 sn_44 sn_59 177932.0250324459
Csub_44_59 sn_44 sn_59 5.921634118595949e-17
Rsub_44_138 sn_44 sn_138 404168.3650803011
Csub_44_138 sn_44 sn_138 2.606954035142406e-17
Rsub_44_168 sn_44 sn_168 3746722.439658764
Csub_44_168 sn_44 sn_168 2.812186830468718e-18
Rsub_44_224 sn_44 sn_224 8323.430000077502
Csub_44_224 sn_44 sn_224 1.265882394893919e-15
Rsub_44_57 sn_44 sn_57 404006.5770869072
Csub_44_57 sn_44 sn_57 2.60799801285499e-17
Rsub_44_171 sn_44 sn_171 259650.006156741
Csub_44_171 sn_44 sn_171 4.057956191947679e-17
Rsub_44_179 sn_44 sn_179 510923.2325636555
Csub_44_179 sn_44 sn_179 2.062243959696483e-17
Rsub_44_70 sn_44 sn_70 12546422.19476969
Csub_44_70 sn_44 sn_70 8.397998519946517e-19
Rsub_44_90 sn_44 sn_90 49646988.1298109
Csub_44_90 sn_44 sn_90 2.122280504646221e-19
Rsub_44_166 sn_44 sn_166 196909.4619093044
Csub_44_166 sn_44 sn_166 5.350927984904583e-17
Rsub_44_185 sn_44 sn_185 8540097.806797795
Csub_44_185 sn_44 sn_185 1.233766139521624e-18
Rsub_44_165 sn_44 sn_165 793082.1572550086
Csub_44_165 sn_44 sn_165 1.32854880239628e-17
Rsub_44_188 sn_44 sn_188 18364518.36874923
Csub_44_188 sn_44 sn_188 5.737413468005704e-19
Rsub_44_45 sn_44 sn_45 1478.821483746375
Csub_44_45 sn_44 sn_45 7.124919145438284e-15
Rsub_44_212 sn_44 sn_212 283294.5125351181
Csub_44_212 sn_44 sn_212 3.719268477155507e-17
Rsub_44_46 sn_44 sn_46 761515.7474338738
Csub_44_46 sn_44 sn_46 1.383619910387334e-17
Rsub_44_213 sn_44 sn_213 641194.8499454744
Csub_44_213 sn_44 sn_213 1.643257662335559e-17
Rsub_44_156 sn_44 sn_156 5640275.126713511
Csub_44_156 sn_44 sn_156 1.868079706312026e-18
Rsub_44_140 sn_44 sn_140 5332523.663653472
Csub_44_140 sn_44 sn_140 1.975890622679607e-18
Rsub_44_229 sn_44 sn_229 3687217.935798974
Csub_44_229 sn_44 sn_229 2.85757003944137e-18
Rsub_44_127 sn_44 sn_127 667720.4578571379
Csub_44_127 sn_44 sn_127 1.57797823598874e-17
Rsub_44_215 sn_44 sn_215 298775.2681683204
Csub_44_215 sn_44 sn_215 3.526558127392956e-17
Rsub_44_48 sn_44 sn_48 239952.3759158159
Csub_44_48 sn_44 sn_48 4.391072796014566e-17
Rsub_44_153 sn_44 sn_153 1133739.564665508
Csub_44_153 sn_44 sn_153 9.2935660275194e-18
Rsub_44_198 sn_44 sn_198 2298318.380679973
Csub_44_198 sn_44 sn_198 4.584431639585421e-18
Rsub_44_182 sn_44 sn_182 813459.2245217796
Csub_44_182 sn_44 sn_182 1.295268795854426e-17
Rsub_211_223 sn_211 sn_223 6921429.856331909
Csub_211_223 sn_211 sn_223 1.522298675408947e-18
Rsub_211_217 sn_211 sn_217 4573459.300978605
Csub_211_217 sn_211 sn_217 2.303832352892144e-18
Rsub_211_229 sn_211 sn_229 3827404.696869223
Csub_211_229 sn_211 sn_229 2.752905516066471e-18
Rsub_211_215 sn_211 sn_215 155786.3127644162
Csub_211_215 sn_211 sn_215 6.763420556826145e-17
Rsub_211_218 sn_211 sn_218 260510.4129202964
Csub_211_218 sn_211 sn_218 4.044553683715382e-17
Rsub_211_221 sn_211 sn_221 24400.89849349658
Csub_211_221 sn_211 sn_221 4.318071936997821e-16
Rsub_211_226 sn_211 sn_226 113257.4671100495
Csub_211_226 sn_211 sn_226 9.303124792639018e-17
Rsub_211_212 sn_211 sn_212 21533.15339863245
Csub_211_212 sn_211 sn_212 4.893144681214767e-16
Rsub_211_227 sn_211 sn_227 19204.24060354642
Csub_211_227 sn_211 sn_227 5.486540040684684e-16
Rsub_211_230 sn_211 0 48557.52404887632
Csub_211_230 sn_211 0 2.169897190726682e-16
Rsub_211_213 sn_211 sn_213 339964.8328773243
Csub_211_213 sn_211 sn_213 3.099286303543071e-17
Rsub_211_222 sn_211 sn_222 279623.6690327329
Csub_211_222 sn_211 sn_222 3.768094288540572e-17
Rsub_211_214 sn_211 sn_214 44099.23866404995
Csub_211_214 sn_211 sn_214 2.38926653190034e-16
Rsub_211_225 sn_211 sn_225 5722156.766284248
Csub_211_225 sn_211 sn_225 1.841348276984029e-18
Rsub_211_220 sn_211 sn_220 8907975.267975884
Csub_211_220 sn_211 sn_220 1.182814633546255e-18
Rsub_211_224 sn_211 sn_224 3115269.027621333
Csub_211_224 sn_211 sn_224 3.382206611630952e-18
Rsub_211_219 sn_211 sn_219 11189080.88810331
Csub_211_219 sn_211 sn_219 9.416755145127979e-19
Rsub_211_216 sn_211 sn_216 2424794.562768422
Csub_211_216 sn_211 sn_216 4.34530976933582e-18
Rsub_202_220 sn_202 sn_220 1389812.963618079
Csub_202_220 sn_202 sn_220 7.581224076943806e-18
Rsub_202_205 sn_202 sn_205 321277.3982679575
Csub_202_205 sn_202 sn_205 3.279559520536884e-17
Rsub_202_218 sn_202 sn_218 6177527.447854806
Csub_202_218 sn_202 sn_218 1.705615003926672e-18
Rsub_202_204 sn_202 sn_204 5662895.717875268
Csub_202_204 sn_202 sn_204 1.860617611052056e-18
Rsub_202_224 sn_202 sn_224 4217500.799233944
Csub_202_224 sn_202 sn_224 2.498276586964446e-18
Rsub_202_215 sn_202 sn_215 553285772.9726386
Csub_202_215 sn_202 sn_215 1.904347448809434e-20
Rsub_202_222 sn_202 sn_222 3395866.235194712
Csub_202_222 sn_202 sn_222 3.102738085802682e-18
Rsub_202_206 sn_202 sn_206 2027077.680479625
Csub_202_206 sn_202 sn_206 5.197868638037084e-18
Rsub_202_223 sn_202 sn_223 165922.2970129204
Csub_202_223 sn_202 sn_223 6.350251709334475e-17
Rsub_202_229 sn_202 sn_229 157489.6026648474
Csub_202_229 sn_202 sn_229 6.690272452240944e-17
Rsub_202_219 sn_202 sn_219 2978579.001441463
Csub_202_219 sn_202 sn_219 3.537419520224556e-18
Rsub_202_230 sn_202 0 17362.14792752995
Csub_202_230 sn_202 0 6.068652073585337e-16
Rsub_202_213 sn_202 sn_213 21659292.31432886
Csub_202_213 sn_202 sn_213 4.864648091599704e-19
Rsub_202_225 sn_202 sn_225 7247.018782566895
Csub_202_225 sn_202 sn_225 1.453905918882962e-15
Rsub_202_208 sn_202 sn_208 8912949.206236368
Csub_202_208 sn_202 sn_208 1.182154554954453e-18
Rsub_202_203 sn_202 sn_203 142199708.0189665
Csub_202_203 sn_202 sn_203 7.409637930356827e-20
Rsub_202_217 sn_202 sn_217 97073.31531127372
Csub_202_217 sn_202 sn_217 1.085415025585959e-16
Rsub_202_228 sn_202 sn_228 114519913.6350252
Csub_202_228 sn_202 sn_228 9.200568851116806e-20
Rsub_202_211 sn_202 sn_211 4272087.084988399
Csub_202_211 sn_202 sn_211 2.466355037390023e-18
Rsub_202_226 sn_202 sn_226 2629185.785096057
Csub_202_226 sn_202 sn_226 4.007508165439535e-18
Rsub_202_207 sn_202 sn_207 6384253.478217241
Csub_202_207 sn_202 sn_207 1.650386147445424e-18
Rsub_35_106 sn_35 sn_106 57804811.12813609
Csub_35_106 sn_35 sn_106 1.822769298367527e-19
Rsub_35_60 sn_35 sn_60 5007284.74325183
Csub_35_60 sn_35 sn_60 2.104230944012063e-18
Rsub_35_111 sn_35 sn_111 1504521.589342568
Csub_35_111 sn_35 sn_111 7.003211902618251e-18
Rsub_35_163 sn_35 sn_163 20798708.35346012
Csub_35_163 sn_35 sn_163 5.065931654586198e-19
Rsub_35_149 sn_35 sn_149 40093035.50463272
Csub_35_149 sn_35 sn_149 2.628008423311455e-19
Rsub_35_157 sn_35 sn_157 1075059.444877098
Csub_35_157 sn_35 sn_157 9.800838039643976e-18
Rsub_35_198 sn_35 sn_198 1455122.955422968
Csub_35_198 sn_35 sn_198 7.240957517000554e-18
Rsub_35_65 sn_35 sn_65 7351626.375155216
Csub_35_65 sn_35 sn_65 1.433218034289391e-18
Rsub_35_219 sn_35 sn_219 1710278.802325225
Csub_35_219 sn_35 sn_219 6.160681806910679e-18
Rsub_35_52 sn_35 sn_52 28407.44375583352
Csub_35_52 sn_35 sn_52 3.709057243162302e-16
Rsub_35_140 sn_35 sn_140 1663012.045544167
Csub_35_140 sn_35 sn_140 6.335783033238511e-18
Rsub_35_96 sn_35 sn_96 9310787.444420811
Csub_35_96 sn_35 sn_96 1.131642577507625e-18
Rsub_35_196 sn_35 sn_196 212399.2129134203
Csub_35_196 sn_35 sn_196 4.960697997748681e-17
Rsub_35_70 sn_35 sn_70 12944324.60865359
Csub_35_70 sn_35 sn_70 8.139848018942688e-19
Rsub_35_181 sn_35 sn_181 1226786.37613611
Csub_35_181 sn_35 sn_181 8.588686430815886e-18
Rsub_35_164 sn_35 sn_164 8081674.268702463
Csub_35_164 sn_35 sn_164 1.303750083449189e-18
Rsub_35_77 sn_35 sn_77 2265177.4145802
Csub_35_77 sn_35 sn_77 4.651504749433811e-18
Rsub_35_46 sn_35 sn_46 6015205.293125647
Csub_35_46 sn_35 sn_46 1.751641546510708e-18
Rsub_35_213 sn_35 sn_213 1837126.035585427
Csub_35_213 sn_35 sn_213 5.73530792016259e-18
Rsub_35_208 sn_35 sn_208 1036279.999506759
Csub_35_208 sn_35 sn_208 1.016760287494217e-17
Rsub_35_41 sn_35 sn_41 2417959.044340308
Csub_35_41 sn_35 sn_41 4.357593866981594e-18
Rsub_35_141 sn_35 sn_141 696056.178863666
Csub_35_141 sn_35 sn_141 1.513740387942702e-17
Rsub_35_79 sn_35 sn_79 7142365.892926035
Csub_35_79 sn_35 sn_79 1.475209147807112e-18
Rsub_35_158 sn_35 sn_158 1122861.359841457
Csub_35_158 sn_35 sn_158 9.38360146591713e-18
Rsub_35_174 sn_35 sn_174 3299601.376587377
Csub_35_174 sn_35 sn_174 3.193259518253503e-18
Rsub_35_95 sn_35 sn_95 2299333.645362138
Csub_35_95 sn_35 sn_95 4.582407395935155e-18
Rsub_35_88 sn_35 sn_88 1664504.637446981
Csub_35_88 sn_35 sn_88 6.330101620137791e-18
Rsub_35_178 sn_35 sn_178 5481157.431665084
Csub_35_178 sn_35 sn_178 1.922309956170917e-18
Rsub_35_83 sn_35 sn_83 7888787.49495904
Csub_35_83 sn_35 sn_83 1.335627751281531e-18
Rsub_35_162 sn_35 sn_162 940286.6177418241
Csub_35_162 sn_35 sn_162 1.120560827243744e-17
Rsub_35_76 sn_35 sn_76 2971540.717126003
Csub_35_76 sn_35 sn_76 3.545798124691561e-18
Rsub_35_155 sn_35 sn_155 354275.3472415903
Csub_35_155 sn_35 sn_155 2.974094467556863e-17
Rsub_35_80 sn_35 sn_80 3470639.702375342
Csub_35_80 sn_35 sn_80 3.035890903633334e-18
Rsub_35_186 sn_35 sn_186 8922628.142746627
Csub_35_186 sn_35 sn_186 1.180872197480885e-18
Rsub_35_42 sn_35 sn_42 11194202.34286468
Csub_35_42 sn_35 sn_42 9.412446889479435e-19
Rsub_35_209 sn_35 sn_209 27331622.6529774
Csub_35_209 sn_35 sn_209 3.85505230919109e-19
Rsub_35_182 sn_35 sn_182 1410916.023698309
Csub_35_182 sn_35 sn_182 7.467831766919516e-18
Rsub_35_71 sn_35 sn_71 8116295.052970611
Csub_35_71 sn_35 sn_71 1.298188820571966e-18
Rsub_35_176 sn_35 sn_176 5593961.938757263
Csub_35_176 sn_35 sn_176 1.883545797698215e-18
Rsub_35_218 sn_35 sn_218 41207.66966401158
Csub_35_218 sn_35 sn_218 2.556922919480681e-16
Rsub_35_51 sn_35 sn_51 2445770.754229923
Csub_35_51 sn_35 sn_51 4.308042151541519e-18
Rsub_35_142 sn_35 sn_142 422163.6679030354
Csub_35_142 sn_35 sn_142 2.495829059513021e-17
Rsub_35_221 sn_35 sn_221 48875.50394163972
Csub_35_221 sn_35 sn_221 2.155780023222102e-16
Rsub_35_54 sn_35 sn_54 2214993.446242327
Csub_35_54 sn_35 sn_54 4.756891502367579e-18
Rsub_35_184 sn_35 sn_184 10420508.02244971
Csub_35_184 sn_35 sn_184 1.011129541816046e-18
Rsub_35_207 sn_35 sn_207 176449.9920037391
Csub_35_207 sn_35 sn_207 5.971370915112721e-17
Rsub_35_40 sn_35 sn_40 117923853.3344776
Csub_35_40 sn_35 sn_40 8.934989151299578e-20
Rsub_35_128 sn_35 sn_128 951217.9152878399
Csub_35_128 sn_35 sn_128 1.107683458531334e-17
Rsub_35_49 sn_35 sn_49 2415922.734108896
Csub_35_49 sn_35 sn_49 4.361266754715293e-18
Rsub_35_216 sn_35 sn_216 1004186.333525997
Csub_35_216 sn_35 sn_216 1.049255815425536e-17
Rsub_35_160 sn_35 sn_160 87026.5734342725
Csub_35_160 sn_35 sn_160 1.210720253186547e-16
Rsub_35_202 sn_35 sn_202 5204369.01021158
Csub_35_202 sn_35 sn_202 2.02454581555539e-18
Rsub_35_153 sn_35 sn_153 3078933.585928239
Csub_35_153 sn_35 sn_153 3.422121071524658e-18
Rsub_35_74 sn_35 sn_74 3206249.760691268
Csub_35_74 sn_35 sn_74 3.286232916539332e-18
Rsub_35_64 sn_35 sn_64 1343835.967408353
Csub_35_64 sn_35 sn_64 7.840602393274291e-18
Rsub_35_222 sn_35 sn_222 70990.06067501761
Csub_35_222 sn_35 sn_222 1.484219537501809e-16
Rsub_35_199 sn_35 sn_199 12785681.86782366
Csub_35_199 sn_35 sn_199 8.240845980022409e-19
Rsub_35_215 sn_35 sn_215 389904.4062405843
Csub_35_215 sn_35 sn_215 2.702324809258153e-17
Rsub_35_48 sn_35 sn_48 414026.7449869544
Csub_35_48 sn_35 sn_48 2.544879921359185e-17
Rsub_35_203 sn_35 sn_203 142892.8097204076
Csub_35_203 sn_35 sn_203 7.373697474943837e-17
Rsub_35_36 sn_35 sn_36 1432650.021654056
Csub_35_36 sn_35 sn_36 7.354541125169687e-18
Rsub_35_45 sn_35 sn_45 46624.14036975592
Csub_35_45 sn_35 sn_45 2.259877269300774e-16
Rsub_35_212 sn_35 sn_212 103860.0883723206
Csub_35_212 sn_35 sn_212 1.014488208835189e-16
Rsub_35_72 sn_35 sn_72 16270691.82218453
Csub_35_72 sn_35 sn_72 6.475744004851636e-19
Rsub_35_230 sn_35 0 22803.81996579939
Csub_35_230 sn_35 0 4.620490566068476e-16
Rsub_35_63 sn_35 sn_63 76390241.80302198
Csub_35_63 sn_35 sn_63 1.379297048096683e-19
Rsub_35_93 sn_35 sn_93 601801.2131738693
Csub_35_93 sn_35 sn_93 1.750824569904257e-17
Rsub_35_226 sn_35 sn_226 5170.905844037053
Csub_35_226 sn_35 sn_226 2.037647526376909e-15
Rsub_35_59 sn_35 sn_59 1282612.718992678
Csub_35_59 sn_35 sn_59 8.214859673701829e-18
Rsub_35_39 sn_35 sn_39 14113973.61863671
Csub_35_39 sn_35 sn_39 7.465284962922961e-19
Rsub_35_166 sn_35 sn_166 55637.37043895152
Csub_35_166 sn_35 sn_166 1.893778124146113e-16
Rsub_35_44 sn_35 sn_44 112497.959796772
Csub_35_44 sn_35 sn_44 9.365932965597061e-17
Rsub_35_211 sn_35 sn_211 105327.961166544
Csub_35_211 sn_35 sn_211 1.000350086105794e-16
Rsub_35_192 sn_35 sn_192 229848.2430413715
Csub_35_192 sn_35 sn_192 4.58410443465234e-17
Rsub_35_197 sn_35 sn_197 1011730.591982962
Csub_35_197 sn_35 sn_197 1.041431739409876e-17
Rsub_35_118 sn_35 sn_118 1871610.806458288
Csub_35_118 sn_35 sn_118 5.629633824442669e-18
Rsub_35_170 sn_35 sn_170 4991605.497728594
Csub_35_170 sn_35 sn_170 2.110840591674278e-18
Rsub_35_138 sn_35 sn_138 325326.6572073556
Csub_35_138 sn_35 sn_138 3.23873966943763e-17
Rsub_35_116 sn_35 sn_116 17347574.60582205
Csub_35_116 sn_35 sn_116 6.073750216755855e-19
Rsub_35_148 sn_35 sn_148 1045903.073601792
Csub_35_148 sn_35 sn_148 1.007405348369936e-17
Rsub_35_132 sn_35 sn_132 665346.3025635461
Csub_35_132 sn_35 sn_132 1.583608935923061e-17
Rsub_35_131 sn_35 sn_131 552083.0240730508
Csub_35_131 sn_35 sn_131 1.908496194013715e-17
Rsub_35_224 sn_35 sn_224 423476.15721681
Csub_35_224 sn_35 sn_224 2.488093679577707e-17
Rsub_35_57 sn_35 sn_57 1567374.082594634
Csub_35_57 sn_35 sn_57 6.722379564161152e-18
Rsub_35_66 sn_35 sn_66 9289577.241099704
Csub_35_66 sn_35 sn_66 1.13422637314577e-18
Rsub_35_177 sn_35 sn_177 1679441.761429693
Csub_35_177 sn_35 sn_177 6.273801059502292e-18
Rsub_35_190 sn_35 sn_190 673910.1433598325
Csub_35_190 sn_35 sn_190 1.563484925408531e-17
Rsub_35_229 sn_35 sn_229 3346561.567500801
Csub_35_229 sn_35 sn_229 3.148450518452169e-18
Rsub_35_62 sn_35 sn_62 13125983.42631933
Csub_35_62 sn_35 sn_62 8.027195494627062e-19
Rsub_35_151 sn_35 sn_151 2672442.680438485
Csub_35_151 sn_35 sn_151 3.942641531417696e-18
Rsub_35_134 sn_35 sn_134 14288149.46989887
Csub_35_134 sn_35 sn_134 7.374281410218604e-19
Rsub_35_214 sn_35 sn_214 15510523.68822284
Csub_35_214 sn_35 sn_214 6.793119119653171e-19
Rsub_35_47 sn_35 sn_47 7472282.3679818
Csub_35_47 sn_35 sn_47 1.410075661404083e-18
Rsub_35_195 sn_35 sn_195 758204.5018191197
Csub_35_195 sn_35 sn_195 1.389662482476743e-17
Rsub_35_200 sn_35 sn_200 590137.2510327247
Csub_35_200 sn_35 sn_200 1.785429318991714e-17
Rsub_35_115 sn_35 sn_115 5187207.488775799
Csub_35_115 sn_35 sn_115 2.031243887010321e-18
Rsub_35_43 sn_35 sn_43 1260409.13114355
Csub_35_43 sn_35 sn_43 8.359574079466095e-18
Rsub_35_210 sn_35 sn_210 3591778.481296047
Csub_35_210 sn_35 sn_210 2.933500369551757e-18
Rsub_35_133 sn_35 sn_133 5112408.426800976
Csub_35_133 sn_35 sn_133 2.0609627836059e-18
Rsub_35_114 sn_35 sn_114 9947255.604249459
Csub_35_114 sn_35 sn_114 1.059235222399314e-18
Rsub_35_37 sn_35 sn_37 7678322.623372588
Csub_35_37 sn_35 sn_37 1.372237664272826e-18
Rsub_35_204 sn_35 sn_204 9066560.412094137
Csub_35_204 sn_35 sn_204 1.162125770228707e-18
Rsub_35_135 sn_35 sn_135 1360359.331708507
Csub_35_135 sn_35 sn_135 7.745367901433062e-18
Rsub_35_120 sn_35 sn_120 2483311.30066811
Csub_35_120 sn_35 sn_120 4.242916906710514e-18
Rsub_35_144 sn_35 sn_144 3030779.156179761
Csub_35_144 sn_35 sn_144 3.476493323753434e-18
Rsub_35_180 sn_35 sn_180 3390107.795318811
Csub_35_180 sn_35 sn_180 3.10800839925479e-18
Rsub_35_129 sn_35 sn_129 8288761.652121117
Csub_35_129 sn_35 sn_129 1.271177040002554e-18
Rsub_35_123 sn_35 sn_123 6959452.799768209
Csub_35_123 sn_35 sn_123 1.513981602487616e-18
Rsub_35_61 sn_35 sn_61 27331622.6529774
Csub_35_61 sn_35 sn_61 3.85505230919109e-19
Rsub_35_228 sn_35 sn_228 11318033.50967781
Csub_35_228 sn_35 sn_228 9.309464840531244e-19
Rsub_35_75 sn_35 sn_75 5670781.930834627
Csub_35_75 sn_35 sn_75 1.858030097214343e-18
Rsub_35_156 sn_35 sn_156 7978907.119227655
Csub_35_156 sn_35 sn_156 1.32054219265682e-18
Rsub_35_56 sn_35 sn_56 3861941.365808357
Csub_35_56 sn_35 sn_56 2.728286761553297e-18
Rsub_35_223 sn_35 sn_223 27718276.90801509
Csub_35_223 sn_35 sn_223 3.80127651411955e-19
Rsub_35_183 sn_35 sn_183 15615442.34593177
Csub_35_183 sn_35 sn_183 6.747476804571619e-19
Rsub_35_86 sn_35 sn_86 6115990.303243928
Csub_35_86 sn_35 sn_86 1.722776358334224e-18
Rsub_35_175 sn_35 sn_175 10876894.65883397
Csub_35_175 sn_35 sn_175 9.68703277242141e-19
Rsub_35_125 sn_35 sn_125 3069644.296290067
Csub_35_125 sn_35 sn_125 3.43247701857973e-18
Rsub_35_185 sn_35 sn_185 3096937.656362241
Csub_35_185 sn_35 sn_185 3.402226544852855e-18
Rsub_35_110 sn_35 sn_110 6007552.121841869
Csub_35_110 sn_35 sn_110 1.753873006598167e-18
Rsub_35_117 sn_35 sn_117 5237737.33579441
Csub_35_117 sn_35 sn_117 2.01164793626138e-18
Rsub_35_82 sn_35 sn_82 537252141.9233009
Csub_35_82 sn_35 sn_82 1.961180362075543e-20
Rsub_35_169 sn_35 sn_169 13696434.70444359
Csub_35_169 sn_35 sn_169 7.692865865896918e-19
Rsub_35_172 sn_35 sn_172 9611299.315810367
Csub_35_172 sn_35 sn_172 1.096260053507826e-18
Rsub_35_103 sn_35 sn_103 1756594.904848001
Csub_35_103 sn_35 sn_103 5.998243233628034e-18
Rsub_35_137 sn_35 sn_137 15976005.314837
Csub_35_137 sn_35 sn_137 6.595192787301289e-19
Rsub_35_89 sn_35 sn_89 11745187.20740345
Csub_35_89 sn_35 sn_89 8.970894474622294e-19
Rsub_35_68 sn_35 sn_68 15129102.16333402
Csub_35_68 sn_35 sn_68 6.964381222677963e-19
Rsub_35_94 sn_35 sn_94 8881946.229544874
Csub_35_94 sn_35 sn_94 1.186280937750049e-18
Rsub_35_97 sn_35 sn_97 3082471.346550002
Csub_35_97 sn_35 sn_97 3.418193494003687e-18
Rsub_35_38 sn_35 sn_38 2613447.36949091
Csub_35_38 sn_35 sn_38 4.031641740802483e-18
Rsub_35_201 sn_35 sn_201 7764324.696744437
Csub_35_201 sn_35 sn_201 1.357037979960823e-18
Rsub_35_127 sn_35 sn_127 355853.8785442528
Csub_35_127 sn_35 sn_127 2.96090168957361e-17
Rsub_35_159 sn_35 sn_159 500718.757938724
Csub_35_159 sn_35 sn_159 2.104271776357021e-17
Rsub_35_58 sn_35 sn_58 6012486.370229236
Csub_35_58 sn_35 sn_58 1.752433661122508e-18
Rsub_35_78 sn_35 sn_78 9565409.644018631
Csub_35_78 sn_35 sn_78 1.10151931745219e-18
Rsub_35_107 sn_35 sn_107 7129792.153524495
Csub_35_107 sn_35 sn_107 1.477810751751223e-18
Rsub_35_130 sn_35 sn_130 16123451.60943962
Csub_35_130 sn_35 sn_130 6.534880841557101e-19
Rsub_35_154 sn_35 sn_154 12133899.52779934
Csub_35_154 sn_35 sn_154 8.68350976377414e-19
Rsub_35_105 sn_35 sn_105 7193509.176717602
Csub_35_105 sn_35 sn_105 1.464720937082032e-18
Rsub_35_165 sn_35 sn_165 13407367.11004981
Csub_35_165 sn_35 sn_165 7.858726784867499e-19
Rsub_35_139 sn_35 sn_139 3597208.812284062
Csub_35_139 sn_35 sn_139 2.929071969981031e-18
Rsub_35_167 sn_35 sn_167 7038867.859268771
Csub_35_167 sn_35 sn_167 1.496900313074577e-18
Rsub_35_112 sn_35 sn_112 5917644.46133016
Csub_35_112 sn_35 sn_112 1.780519862435539e-18
Rsub_35_98 sn_35 sn_98 28977098.34138619
Csub_35_98 sn_35 sn_98 3.636141679231352e-19
Rsub_35_69 sn_35 sn_69 10426551.65417004
Csub_35_69 sn_35 sn_69 1.010543452112088e-18
Rsub_35_108 sn_35 sn_108 32921125.46971484
Csub_35_108 sn_35 sn_108 3.200523479041699e-19
Rsub_35_152 sn_35 sn_152 7666228.968109358
Csub_35_152 sn_35 sn_152 1.374402401240633e-18
Rsub_35_217 sn_35 sn_217 626890.3299449885
Csub_35_217 sn_35 sn_217 1.680753873353671e-17
Rsub_35_136 sn_35 sn_136 27162461.4163984
Csub_35_136 sn_35 sn_136 3.879060642077512e-19
Rsub_35_87 sn_35 sn_87 27145857.22721162
Csub_35_87 sn_35 sn_87 3.881433330338153e-19
Rsub_35_121 sn_35 sn_121 18397921.41672073
Csub_35_121 sn_35 sn_121 5.726996688144373e-19
Rsub_35_171 sn_35 sn_171 3211732.076494285
Csub_35_171 sn_35 sn_171 3.280623430373723e-18
Rsub_35_188 sn_35 sn_188 9834573.893028514
Csub_35_188 sn_35 sn_188 1.071371634077512e-18
Rsub_35_85 sn_35 sn_85 34001408.55237771
Csub_35_85 sn_35 sn_85 3.098837357281538e-19
Rsub_35_145 sn_35 sn_145 20046517.75231636
Csub_35_145 sn_35 sn_145 5.25601684662291e-19
Rsub_128_225 sn_128 sn_225 338178.0864578905
Csub_128_225 sn_128 sn_225 3.115661222342977e-17
Rsub_128_212 sn_128 sn_212 3878330.785175504
Csub_128_212 sn_128 sn_212 2.716757307681067e-18
Rsub_128_207 sn_128 sn_207 10366591.83484261
Csub_128_207 sn_128 sn_207 1.016388382034718e-18
Rsub_128_193 sn_128 sn_193 3667554.816547424
Csub_128_193 sn_128 sn_193 2.872890530413087e-18
Rsub_128_218 sn_128 sn_218 2409422.420931109
Csub_128_218 sn_128 sn_218 4.373032893982216e-18
Rsub_128_191 sn_128 sn_191 247674.9806750054
Csub_128_191 sn_128 sn_191 4.254157393497804e-17
Rsub_128_187 sn_128 sn_187 326018.3315884619
Csub_128_187 sn_128 sn_187 3.231868420064909e-17
Rsub_128_184 sn_128 sn_184 12638878.68165317
Csub_128_184 sn_128 sn_184 8.3365651080463e-19
Rsub_128_223 sn_128 sn_223 346857.4485672538
Csub_128_223 sn_128 sn_223 3.037698497106667e-17
Rsub_128_190 sn_128 sn_190 8706910.590198115
Csub_128_190 sn_128 sn_190 1.210128827335329e-18
Rsub_128_194 sn_128 sn_194 1367699.900073285
Csub_128_194 sn_128 sn_194 7.70379781534343e-18
Rsub_128_226 sn_128 sn_226 1663579.933104838
Csub_128_226 sn_128 sn_226 6.333620220198939e-18
Rsub_128_145 sn_128 sn_145 2608381.862549941
Csub_128_145 sn_128 sn_145 4.039471234449387e-18
Rsub_128_156 sn_128 sn_156 163931.6099193837
Csub_128_156 sn_128 sn_156 6.427365355230456e-17
Rsub_128_175 sn_128 sn_175 146461.3482922389
Csub_128_175 sn_128 sn_175 7.194036942228765e-17
Rsub_128_159 sn_128 sn_159 69544.39996291079
Csub_128_159 sn_128 sn_159 1.515072889815613e-16
Rsub_128_214 sn_128 sn_214 4469350.263254392
Csub_128_214 sn_128 sn_214 2.357497819953315e-18
Rsub_128_166 sn_128 sn_166 1251190.857612974
Csub_128_166 sn_128 sn_166 8.421164075904084e-18
Rsub_128_170 sn_128 sn_170 3508259.740694053
Csub_128_170 sn_128 sn_170 3.003336206841267e-18
Rsub_128_177 sn_128 sn_177 25676.85277958313
Csub_128_177 sn_128 sn_177 4.103494923103682e-16
Rsub_128_192 sn_128 sn_192 954939.7714723122
Csub_128_192 sn_128 sn_192 1.103366287277469e-17
Rsub_128_150 sn_128 sn_150 1906735.270199516
Csub_128_150 sn_128 sn_150 5.525928883209617e-18
Rsub_128_130 sn_128 sn_130 22404.39222395984
Csub_128_130 sn_128 sn_130 4.702865133275971e-16
Rsub_128_209 sn_128 sn_209 298950.801783635
Csub_128_209 sn_128 sn_209 3.524487453910814e-17
Rsub_128_142 sn_128 sn_142 1401780.879572143
Csub_128_142 sn_128 sn_142 7.516498231482502e-18
Rsub_128_221 sn_128 sn_221 5894163.446214503
Csub_128_221 sn_128 sn_221 1.787613051178112e-18
Rsub_128_179 sn_128 sn_179 23880.03500072567
Csub_128_179 sn_128 sn_179 4.412256306119241e-16
Rsub_128_158 sn_128 sn_158 405673.9003574397
Csub_128_158 sn_128 sn_158 2.597279118263781e-17
Rsub_128_195 sn_128 sn_195 402890.547168116
Csub_128_195 sn_128 sn_195 2.615222316902212e-17
Rsub_128_153 sn_128 sn_153 327754.732178585
Csub_128_153 sn_128 sn_153 3.214746414855408e-17
Rsub_128_135 sn_128 sn_135 77037.74694940272
Csub_128_135 sn_128 sn_135 1.367704004784851e-16
Rsub_128_188 sn_128 sn_188 13088835.20179693
Csub_128_188 sn_128 sn_188 8.049977969608385e-19
Rsub_128_151 sn_128 sn_151 1210.664346404953
Csub_128_151 sn_128 sn_151 8.703059219938134e-15
Rsub_128_230 sn_128 0 3319.381925956813
Csub_128_230 sn_128 0 3.174230545704035e-15
Rsub_128_208 sn_128 sn_208 2368205.849108473
Csub_128_208 sn_128 sn_208 4.449141744243446e-18
Rsub_128_129 sn_128 sn_129 8166919.809719993
Csub_128_129 sn_128 sn_129 1.290141662673097e-18
Rsub_128_134 sn_128 sn_134 930.5484379823349
Csub_128_134 sn_128 sn_134 1.132287484687607e-14
Rsub_128_213 sn_128 sn_213 2161783.154886378
Csub_128_213 sn_128 sn_213 4.873977983598357e-18
Rsub_128_185 sn_128 sn_185 25090.07703256714
Csub_128_185 sn_128 sn_185 4.199462396450019e-16
Rsub_128_220 sn_128 sn_220 64738.6535001491
Csub_128_220 sn_128 sn_220 1.627541342392259e-16
Rsub_128_141 sn_128 sn_141 37420.95281581772
Csub_128_141 sn_128 sn_141 2.815664142516506e-16
Rsub_128_183 sn_128 sn_183 974.0529989039726
Csub_128_183 sn_128 sn_183 1.081715626776562e-14
Rsub_128_139 sn_128 sn_139 601.3230856062409
Csub_128_139 sn_128 sn_139 1.752216695889423e-14
Rsub_128_157 sn_128 sn_157 713.5371644634901
Csub_128_157 sn_128 sn_157 1.476655180273953e-14
Rsub_128_180 sn_128 sn_180 240763.124333038
Csub_128_180 sn_128 sn_180 4.376286248742689e-17
Rsub_128_152 sn_128 sn_152 40536.06026331672
Csub_128_152 sn_128 sn_152 2.599286520146862e-16
Rsub_128_189 sn_128 sn_189 48112.47767016781
Csub_128_189 sn_128 sn_189 2.189969008551634e-16
Rsub_128_136 sn_128 sn_136 193217.757075423
Csub_128_136 sn_128 sn_136 5.453165206817438e-17
Rsub_128_215 sn_128 sn_215 818057.0651468355
Csub_128_215 sn_128 sn_215 1.287988815344902e-17
Rsub_128_168 sn_128 sn_168 761827.4157962723
Csub_128_168 sn_128 sn_168 1.383053862824971e-17
Rsub_128_131 sn_128 sn_131 854402.0197551737
Csub_128_131 sn_128 sn_131 1.233199741879028e-17
Rsub_128_210 sn_128 sn_210 2639500.483322789
Csub_128_210 sn_128 sn_210 3.991847536608871e-18
Rsub_128_178 sn_128 sn_178 1425960.155874501
Csub_128_178 sn_128 sn_178 7.389044819256032e-18
Rsub_128_138 sn_128 sn_138 663004.409843276
Csub_128_138 sn_128 sn_138 1.589202627584433e-17
Rsub_128_222 sn_128 sn_222 388652.2782926906
Csub_128_222 sn_128 sn_222 2.711030937092582e-17
Rsub_128_143 sn_128 sn_143 4506106.866266975
Csub_128_143 sn_128 sn_143 2.338267558878117e-18
Rsub_128_165 sn_128 sn_165 116323.5931202587
Csub_128_165 sn_128 sn_165 9.057907531567634e-17
Rsub_128_155 sn_128 sn_155 296106.0500635647
Csub_128_155 sn_128 sn_155 3.558347929725904e-17
Rsub_128_160 sn_128 sn_160 1036601.254156659
Csub_128_160 sn_128 sn_160 1.016445181788064e-17
Rsub_128_149 sn_128 sn_149 268940.0718804062
Csub_128_149 sn_128 sn_149 3.917781172794296e-17
Rsub_128_228 sn_128 sn_228 3976376.237374525
Csub_128_228 sn_128 sn_228 2.649770261474781e-18
Rsub_128_205 sn_128 sn_205 144159.8154849892
Csub_128_205 sn_128 sn_205 7.308890807596187e-17
Rsub_128_132 sn_128 sn_132 27701.01224098424
Csub_128_132 sn_128 sn_132 3.803645661237262e-16
Rsub_128_211 sn_128 sn_211 5700061.163696325
Csub_128_211 sn_128 sn_211 1.848486042454568e-18
Rsub_128_174 sn_128 sn_174 5619800.145136896
Csub_128_174 sn_128 sn_174 1.874885802006281e-18
Rsub_128_182 sn_128 sn_182 13614597.49458926
Csub_128_182 sn_128 sn_182 7.73910760594827e-19
Rsub_128_198 sn_128 sn_198 4656909.336409941
Csub_128_198 sn_128 sn_198 2.262548557656199e-18
Rsub_128_200 sn_128 sn_200 1691057.233400839
Csub_128_200 sn_128 sn_200 6.230707804631997e-18
Rsub_128_154 sn_128 sn_154 10917.29338111722
Csub_128_154 sn_128 sn_154 9.651186548173312e-16
Rsub_128_219 sn_128 sn_219 115485.5365626703
Csub_128_219 sn_128 sn_219 9.123639042463289e-17
Rsub_128_140 sn_128 sn_140 4315860.436708014
Csub_128_140 sn_128 sn_140 2.441340181580769e-18
Rsub_128_133 sn_128 sn_133 20888306.57943546
Csub_128_133 sn_128 sn_133 5.04420186584353e-19
Rsub_128_216 sn_128 sn_216 125289.7469174612
Csub_128_216 sn_128 sn_216 8.409693340007508e-17
Rsub_128_147 sn_128 sn_147 1733121.833521809
Csub_128_147 sn_128 sn_147 6.079482295147842e-18
Rsub_128_146 sn_128 sn_146 11579399.27280686
Csub_128_146 sn_128 sn_146 9.099335167562579e-19
Rsub_128_144 sn_128 sn_144 16130547.91059438
Csub_128_144 sn_128 sn_144 6.532005955798778e-19
Rsub_128_181 sn_128 sn_181 3559132.560753731
Csub_128_181 sn_128 sn_181 2.960407717997065e-18
Rsub_128_162 sn_128 sn_162 7540074.358488161
Csub_128_162 sn_128 sn_162 1.397397824116769e-18
Rsub_128_148 sn_128 sn_148 76250772.95045125
Csub_128_148 sn_128 sn_148 1.381819894347399e-19
Rsub_128_186 sn_128 sn_186 3937184268.689699
Rsub_128_202 sn_128 sn_202 187810.1549129561
Csub_128_202 sn_128 sn_202 5.610177738851935e-17
Rsub_128_164 sn_128 sn_164 7177729.423504817
Csub_128_164 sn_128 sn_164 1.467941027106193e-18
Rsub_128_204 sn_128 sn_204 4327189.549781488
Csub_128_204 sn_128 sn_204 2.434948453497274e-18
Rsub_128_197 sn_128 sn_197 8657249.777887953
Csub_128_197 sn_128 sn_197 1.21707052153467e-18
Rsub_165_171 sn_165 sn_171 7469278.695806497
Csub_165_171 sn_165 sn_171 1.410642704782931e-18
Rsub_165_227 sn_165 sn_227 396366.6610299634
Csub_165_227 sn_165 sn_227 2.658266836784614e-17
Rsub_165_230 sn_165 0 10306.57457047689
Csub_165_230 sn_165 0 1.022307016766917e-15
Rsub_165_192 sn_165 sn_192 8716511.765664119
Csub_165_192 sn_165 sn_192 1.208795879073447e-18
Rsub_165_226 sn_165 sn_226 1525065.815173709
Csub_165_226 sn_165 sn_226 6.908871340106638e-18
Rsub_165_205 sn_165 sn_205 278273.0338497188
Csub_165_205 sn_165 sn_205 3.786383235365961e-17
Rsub_165_178 sn_165 sn_178 12024920.40722748
Csub_165_178 sn_165 sn_178 8.762206439135457e-19
Rsub_165_215 sn_165 sn_215 1433322.816029103
Csub_165_215 sn_165 sn_215 7.351088941303826e-18
Rsub_165_183 sn_165 sn_183 13828.93245132065
Csub_165_183 sn_165 sn_183 7.619158990991946e-16
Rsub_165_185 sn_165 sn_185 883.9736019002529
Csub_165_185 sn_165 sn_185 1.191945492442311e-14
Rsub_165_222 sn_165 sn_222 2302309.205787008
Csub_165_222 sn_165 sn_222 4.576484981142345e-18
Rsub_165_216 sn_165 sn_216 1794317.046582937
Csub_165_216 sn_165 sn_216 5.872141449191201e-18
Rsub_165_199 sn_165 sn_199 3629740.39560836
Csub_165_199 sn_165 sn_199 2.902820134183189e-18
Rsub_165_182 sn_165 sn_182 14894427.19086275
Csub_165_182 sn_165 sn_182 7.074111254640119e-19
Rsub_165_219 sn_165 sn_219 1926749.959326893
Csub_165_219 sn_165 sn_219 5.468526650915776e-18
Rsub_165_169 sn_165 sn_169 659.6402136360367
Csub_165_169 sn_165 sn_169 1.597307635953744e-14
Rsub_165_206 sn_165 sn_206 5701099.600652736
Csub_165_206 sn_165 sn_206 1.848149346667027e-18
Rsub_165_177 sn_165 sn_177 23798.25420855378
Csub_165_177 sn_165 sn_177 4.42741867109012e-16
Rsub_165_191 sn_165 sn_191 2738.978064258149
Csub_165_191 sn_165 sn_191 3.84686669810326e-15
Rsub_165_228 sn_165 sn_228 16454271.84528508
Csub_165_228 sn_165 sn_228 6.403494242286509e-19
Rsub_165_181 sn_165 sn_181 23043.9652921766
Csub_165_181 sn_165 sn_181 4.572339598952237e-16
Rsub_165_175 sn_165 sn_175 311863.0960248346
Csub_165_175 sn_165 sn_175 3.378560540356769e-17
Rsub_165_212 sn_165 sn_212 1826426.618272578
Csub_165_212 sn_165 sn_212 5.768906013971333e-18
Rsub_165_184 sn_165 sn_184 7007925.323402981
Csub_165_184 sn_165 sn_184 1.503509671691762e-18
Rsub_165_221 sn_165 sn_221 15107941.02768454
Csub_165_221 sn_165 sn_221 6.974135974533147e-19
Rsub_165_195 sn_165 sn_195 287581.7182377087
Csub_165_195 sn_165 sn_195 3.66382243168906e-17
Rsub_165_180 sn_165 sn_180 4242857.121646122
Csub_165_180 sn_165 sn_180 2.48334629240169e-18
Rsub_165_176 sn_165 sn_176 8113618.283957366
Csub_165_176 sn_165 sn_176 1.298617106878597e-18
Rsub_165_166 sn_165 sn_166 5065364.068121384
Csub_165_166 sn_165 sn_166 2.080103889973247e-18
Rsub_165_210 sn_165 sn_210 1259769.432462447
Csub_165_210 sn_165 sn_210 8.36381898998338e-18
Rsub_165_197 sn_165 sn_197 39861001.16079443
Csub_165_197 sn_165 sn_197 2.643306288200617e-19
Rsub_165_211 sn_165 sn_211 75053.58354267798
Csub_165_211 sn_165 sn_211 1.403861482008864e-16
Rsub_165_204 sn_165 sn_204 3944981.982680162
Csub_165_204 sn_165 sn_204 2.670857192374722e-18
Rsub_165_190 sn_165 sn_190 4026317.035929765
Csub_165_190 sn_165 sn_190 2.616903589112648e-18
Rsub_134_193 sn_134 sn_193 19998680.56455167
Csub_134_193 sn_134 sn_193 5.268589329291188e-19
Rsub_134_171 sn_134 sn_171 13425513.17762704
Csub_134_171 sn_134 sn_171 7.848104845473269e-19
Rsub_134_178 sn_134 sn_178 14216558.08145619
Csub_134_178 sn_134 sn_178 7.411416632534699e-19
Rsub_134_205 sn_134 sn_205 123441.6730863537
Csub_134_205 sn_134 sn_205 8.535596803568269e-17
Rsub_134_168 sn_134 sn_168 1448567.684183308
Csub_134_168 sn_134 sn_168 7.273725361456196e-18
Rsub_134_184 sn_134 sn_184 25359727.80810945
Csub_134_184 sn_134 sn_184 4.154809382007908e-19
Rsub_134_201 sn_134 sn_201 9662828.312956516
Csub_134_201 sn_134 sn_201 1.090414023821787e-18
Rsub_134_199 sn_134 sn_199 20720762.19434545
Csub_134_199 sn_134 sn_199 5.084988381897135e-19
Rsub_134_181 sn_134 sn_181 59048.41962984238
Csub_134_181 sn_134 sn_181 1.784380271018292e-16
Rsub_134_204 sn_134 sn_204 13858624.28611521
Csub_134_204 sn_134 sn_204 7.602835090050301e-19
Rsub_134_210 sn_134 sn_210 4619977.498392983
Csub_134_210 sn_134 sn_210 2.28063524246493e-18
Rsub_134_198 sn_134 sn_198 7676224.180895508
Csub_134_198 sn_134 sn_198 1.372612791644761e-18
Rsub_134_194 sn_134 sn_194 2753746.479476264
Csub_134_194 sn_134 sn_194 3.826235850234819e-18
Rsub_134_182 sn_134 sn_182 14636291.53764156
Csub_134_182 sn_134 sn_182 7.198875121564989e-19
Rsub_134_170 sn_134 sn_170 1950282.039814561
Csub_134_170 sn_134 sn_170 5.402543471728757e-18
Rsub_134_211 sn_134 sn_211 9193646.50716191
Csub_134_211 sn_134 sn_211 1.146061412522443e-18
Rsub_134_148 sn_134 sn_148 4562447.253427507
Csub_134_148 sn_134 sn_148 2.309392945707929e-18
Rsub_134_158 sn_134 sn_158 5192719.429218721
Csub_134_158 sn_134 sn_158 2.029087772958164e-18
Rsub_134_143 sn_134 sn_143 20155302.58202494
Csub_134_143 sn_134 sn_143 5.22764838649792e-19
Rsub_134_222 sn_134 sn_222 3818839.69475402
Csub_134_222 sn_134 sn_222 2.759079810735202e-18
Rsub_134_180 sn_134 sn_180 2785012.214297197
Csub_134_180 sn_134 sn_180 3.783280894834029e-18
Rsub_134_160 sn_134 sn_160 3680257.155970001
Csub_134_160 sn_134 sn_160 2.862974801947749e-18
Rsub_134_144 sn_134 sn_144 8440013.180490192
Csub_134_144 sn_134 sn_144 1.248396569638775e-18
Rsub_134_219 sn_134 sn_219 6766341.740900281
Csub_134_219 sn_134 sn_219 1.557190562596103e-18
Rsub_134_140 sn_134 sn_140 3683776.004414296
Csub_134_140 sn_134 sn_140 2.86024000634242e-18
Rsub_134_195 sn_134 sn_195 1092034.030825437
Csub_134_195 sn_134 sn_195 9.648493732622766e-18
Rsub_134_137 sn_134 sn_137 146042.8623593916
Csub_134_137 sn_134 sn_137 7.21465146054256e-17
Rsub_134_216 sn_134 sn_216 3612297.769252652
Csub_134_216 sn_134 sn_216 2.916836920786265e-18
Rsub_134_164 sn_134 sn_164 2532872.017845999
Csub_134_164 sn_134 sn_164 4.159895734167581e-18
Rsub_134_156 sn_134 sn_156 143740.6658398632
Csub_134_156 sn_134 sn_156 7.33020362794782e-17
Rsub_134_212 sn_134 sn_212 3407390.618404193
Csub_134_212 sn_134 sn_212 3.092244090043491e-18
Rsub_134_174 sn_134 sn_174 27375542.89654288
Csub_134_174 sn_134 sn_174 3.848867414994937e-19
Rsub_134_175 sn_134 sn_175 101811.5133486055
Csub_134_175 sn_134 sn_175 1.034900980810764e-16
Rsub_134_186 sn_134 sn_186 46262044.32543189
Csub_134_186 sn_134 sn_186 2.277565476378596e-19
Rsub_134_152 sn_134 sn_152 228948.5130759797
Csub_134_152 sn_134 sn_152 4.602119210415367e-17
Rsub_134_189 sn_134 sn_189 46853.02033608082
Csub_134_189 sn_134 sn_189 2.248837625973925e-16
Rsub_134_159 sn_134 sn_159 102685.6609279601
Csub_134_159 sn_134 sn_159 1.026091024492889e-16
Rsub_134_135 sn_134 sn_135 3494913.573054757
Csub_134_135 sn_134 sn_135 3.014805168134817e-18
Rsub_134_214 sn_134 sn_214 186467.8793740624
Csub_134_214 sn_134 sn_214 5.650562197413837e-17
Rsub_134_177 sn_134 sn_177 15424.8718928264
Csub_134_177 sn_134 sn_177 6.830840201097665e-16
Rsub_134_226 sn_134 sn_226 3321746.02453971
Csub_134_226 sn_134 sn_226 3.171971434417545e-18
Rsub_134_147 sn_134 sn_147 635375.3008335257
Csub_134_147 sn_134 sn_147 1.658308638753753e-17
Rsub_134_165 sn_134 sn_165 12319.74810642963
Csub_134_165 sn_134 sn_165 8.552515368987985e-16
Rsub_134_157 sn_134 sn_157 14804.89470989362
Csub_134_157 sn_134 sn_157 7.116891885214707e-16
Rsub_134_154 sn_134 sn_154 848.451035481602
Csub_134_154 sn_134 sn_154 1.241849330321016e-14
Rsub_134_191 sn_134 sn_191 93371.14673707134
Csub_134_191 sn_134 sn_191 1.128451761645408e-16
Rsub_134_228 sn_134 sn_228 9360871.441698706
Csub_134_228 sn_134 sn_228 1.125587886539542e-18
Rsub_134_183 sn_134 sn_183 906.4115452015685
Csub_134_183 sn_134 sn_183 1.162439242748931e-14
Rsub_134_218 sn_134 sn_218 290406.5052357457
Csub_134_218 sn_134 sn_218 3.62818439403646e-17
Rsub_134_139 sn_134 sn_139 365.7230051319444
Csub_134_139 sn_134 sn_139 2.881001018360516e-14
Rsub_134_162 sn_134 sn_162 14224868.58396317
Csub_134_162 sn_134 sn_162 7.407086708771858e-19
Rsub_134_185 sn_134 sn_185 6173.534495977969
Csub_134_185 sn_134 sn_185 1.706718170781175e-15
Rsub_134_213 sn_134 sn_213 12584715.73177941
Csub_134_213 sn_134 sn_213 8.372444580232244e-19
Rsub_134_230 sn_134 0 5149.850951773906
Csub_134_230 sn_134 0 2.045978340130529e-15
Rsub_134_151 sn_134 sn_151 8956.947534454212
Csub_134_151 sn_134 sn_151 1.176347573958636e-15
Rsub_134_188 sn_134 sn_188 15248608.3973916
Csub_134_188 sn_134 sn_188 6.909800047086494e-19
Rsub_134_153 sn_134 sn_153 1447469.248602609
Csub_134_153 sn_134 sn_153 7.279245146245387e-18
Rsub_134_172 sn_134 sn_172 4203833.762186198
Csub_134_172 sn_134 sn_172 2.506398706106427e-18
Rsub_134_161 sn_134 sn_161 236545.0110981304
Csub_134_161 sn_134 sn_161 4.454324973211527e-17
Rsub_134_155 sn_134 sn_155 2962966.995518582
Csub_134_155 sn_134 sn_155 3.556058342251596e-18
Rsub_134_192 sn_134 sn_192 3523040.24016472
Csub_134_192 sn_134 sn_192 2.990736064296945e-18
Rsub_134_206 sn_134 sn_206 3810591.548179697
Csub_134_206 sn_134 sn_206 2.765051926718106e-18
Rsub_134_169 sn_134 sn_169 617699.4417217697
Csub_134_169 sn_134 sn_169 1.705762186357285e-17
Rsub_134_179 sn_134 sn_179 537210.008748031
Csub_134_179 sn_134 sn_179 1.961334176700337e-17
Rsub_134_215 sn_134 sn_215 1838872.309785589
Csub_134_215 sn_134 sn_215 5.729861418957656e-18
Rsub_134_150 sn_134 sn_150 6727021.966823788
Csub_134_150 sn_134 sn_150 1.566292417981337e-18
Rsub_134_138 sn_134 sn_138 1802208.652251586
Csub_134_138 sn_134 sn_138 5.846428208557462e-18
Rsub_134_197 sn_134 sn_197 38461923.26427644
Csub_134_197 sn_134 sn_197 2.739458302652359e-19
Rsub_0_84 sn_0 sn_84 132564423.9499776
Csub_0_84 sn_0 sn_84 7.948198459494594e-20
Rsub_0_185 sn_0 sn_185 21094.96652588939
Csub_0_185 sn_0 sn_185 4.994785599350824e-16
Rsub_0_131 sn_0 sn_131 20651907.27908075
Csub_0_131 sn_0 sn_131 5.101942091761607e-19
Rsub_0_48 sn_0 sn_48 1891214.145693169
Csub_0_48 sn_0 sn_48 5.571279977058421e-18
Rsub_0_141 sn_0 sn_141 329974.2882571776
Csub_0_141 sn_0 sn_141 3.193122578695587e-17
Rsub_0_197 sn_0 sn_197 34668920.73780531
Csub_0_197 sn_0 sn_197 3.039172630124686e-19
Rsub_0_30 sn_0 sn_30 13573765.32171757
Csub_0_30 sn_0 sn_30 7.762388145441101e-19
Rsub_0_148 sn_0 sn_148 5310276.397866858
Csub_0_148 sn_0 sn_148 1.984168565399442e-18
Rsub_0_169 sn_0 sn_169 111775.2924620812
Csub_0_169 sn_0 sn_169 9.426487079695552e-17
Rsub_0_101 sn_0 sn_101 4480909.309286836
Csub_0_101 sn_0 sn_101 2.351416369974903e-18
Rsub_0_140 sn_0 sn_140 17033172.4204008
Csub_0_140 sn_0 sn_140 6.185860884969585e-19
Rsub_0_70 sn_0 sn_70 19497679.03713444
Csub_0_70 sn_0 sn_70 5.403968073411543e-19
Rsub_0_104 sn_0 sn_104 115303.0463315919
Csub_0_104 sn_0 sn_104 9.138079033860799e-17
Rsub_0_150 sn_0 sn_150 9176198.2428752
Csub_0_150 sn_0 sn_150 1.148240613743386e-18
Rsub_0_15 sn_0 sn_15 101313866.9451462
Csub_0_15 sn_0 sn_15 1.03998433974835e-19
Rsub_0_143 sn_0 sn_143 21080448.10442965
Csub_0_143 sn_0 sn_143 4.99822558326735e-19
Rsub_0_1 sn_0 sn_1 76875406.70149396
Csub_0_1 sn_0 sn_1 1.3705922289482e-19
Rsub_0_54 sn_0 sn_54 6100003.070240645
Csub_0_54 sn_0 sn_54 1.727291508037608e-18
Rsub_0_51 sn_0 sn_51 4801261.247981014
Csub_0_51 sn_0 sn_51 2.194524096488337e-18
Rsub_0_146 sn_0 sn_146 4701124.513363692
Csub_0_146 sn_0 sn_146 2.241268758629638e-18
Rsub_0_160 sn_0 sn_160 3047994.071475029
Csub_0_160 sn_0 sn_160 3.456858266502807e-18
Rsub_0_129 sn_0 sn_129 4862675.165654814
Csub_0_129 sn_0 sn_129 2.166808010670634e-18
Rsub_0_61 sn_0 sn_61 14621197.30219294
Csub_0_61 sn_0 sn_61 7.206306901179498e-19
Rsub_0_213 sn_0 sn_213 10339720.86729003
Csub_0_213 sn_0 sn_213 1.01902978208652e-18
Rsub_0_46 sn_0 sn_46 3454142.455519045
Csub_0_46 sn_0 sn_46 3.050390549293865e-18
Rsub_0_132 sn_0 sn_132 1028683.195412799
Csub_0_132 sn_0 sn_132 1.024269041160124e-17
Rsub_0_165 sn_0 sn_165 138667.8400127671
Csub_0_165 sn_0 sn_165 7.598361308043672e-17
Rsub_0_176 sn_0 sn_176 4993277.215447793
Csub_0_176 sn_0 sn_176 2.110133895557229e-18
Rsub_0_59 sn_0 sn_59 25195729.67683164
Csub_0_59 sn_0 sn_59 4.181852892285422e-19
Rsub_0_226 sn_0 sn_226 5131224.18147501
Csub_0_226 sn_0 sn_226 2.053405411572021e-18
Rsub_0_152 sn_0 sn_152 1282942.10333118
Csub_0_152 sn_0 sn_152 8.212750579213087e-18
Rsub_0_40 sn_0 sn_40 1835758153.497793
Rsub_0_124 sn_0 sn_124 3800160.650701059
Csub_0_124 sn_0 sn_124 2.772641598792993e-18
Rsub_0_208 sn_0 sn_208 9183038.576122319
Csub_0_208 sn_0 sn_208 1.147385303338146e-18
Rsub_0_199 sn_0 sn_199 30584620.11624749
Csub_0_199 sn_0 sn_199 3.445026769069693e-19
Rsub_0_32 sn_0 sn_32 26044168.63266962
Csub_0_32 sn_0 sn_32 4.04562097982007e-19
Rsub_0_37 sn_0 sn_37 83834211.28043145
Csub_0_37 sn_0 sn_37 1.256823836152607e-19
Rsub_0_107 sn_0 sn_107 16046151.58406453
Csub_0_107 sn_0 sn_107 6.566361689299885e-19
Rsub_0_68 sn_0 sn_68 203197.2751685229
Csub_0_68 sn_0 sn_68 5.185346847535976e-17
Rsub_0_133 sn_0 sn_133 20129163.05222065
Csub_0_133 sn_0 sn_133 5.234436958404795e-19
Rsub_0_17 sn_0 sn_17 36029774.66326121
Csub_0_17 sn_0 sn_17 2.924382292341625e-19
Rsub_0_97 sn_0 sn_97 4188573.740277052
Csub_0_97 sn_0 sn_97 2.515530143569364e-18
Rsub_0_7 sn_0 sn_7 404827005.0244715
Csub_0_7 sn_0 sn_7 2.60271260846175e-20
Rsub_0_98 sn_0 sn_98 597119.3912353402
Csub_0_98 sn_0 sn_98 1.764552224712009e-17
Rsub_0_75 sn_0 sn_75 260137.1237670519
Csub_0_75 sn_0 sn_75 4.050357499787394e-17
Rsub_0_24 sn_0 sn_24 20782064.14197618
Csub_0_24 sn_0 sn_24 5.069988924222463e-19
Rsub_0_142 sn_0 sn_142 13895060.87700452
Csub_0_142 sn_0 sn_142 7.582898409367345e-19
Rsub_0_85 sn_0 sn_85 163947.424311205
Csub_0_85 sn_0 sn_85 6.426745370655928e-17
Rsub_0_200 sn_0 sn_200 1106936.232381577
Csub_0_200 sn_0 sn_200 9.518600253567201e-18
Rsub_0_219 sn_0 sn_219 2316811.4891898
Csub_0_219 sn_0 sn_219 4.547838074609453e-18
Rsub_0_76 sn_0 sn_76 7366056.203931696
Csub_0_76 sn_0 sn_76 1.430410413730764e-18
Rsub_0_47 sn_0 sn_47 19370731.84526823
Csub_0_47 sn_0 sn_47 5.439383285254549e-19
Rsub_0_214 sn_0 sn_214 2098235.488806893
Csub_0_214 sn_0 sn_214 5.021592456345926e-18
Rsub_0_201 sn_0 sn_201 27814940.47177451
Csub_0_201 sn_0 sn_201 3.788066170021827e-19
Rsub_0_34 sn_0 sn_34 3853129.383992235
Csub_0_34 sn_0 sn_34 2.734526264807939e-18
Rsub_0_96 sn_0 sn_96 77241.80278046007
Csub_0_96 sn_0 sn_96 1.364090832030066e-16
Rsub_0_8 sn_0 sn_8 89072960.22819594
Csub_0_8 sn_0 sn_8 1.182904831638759e-19
Rsub_0_175 sn_0 sn_175 206779.1368749554
Csub_0_175 sn_0 sn_175 5.095525429435213e-17
Rsub_0_210 sn_0 sn_210 7470466.038539669
Csub_0_210 sn_0 sn_210 1.41041849971246e-18
Rsub_0_43 sn_0 sn_43 11624920.11716496
Csub_0_43 sn_0 sn_43 9.063704004875e-19
Rsub_0_122 sn_0 sn_122 86506.02959658546
Csub_0_122 sn_0 sn_122 1.218005675600432e-16
Rsub_0_166 sn_0 sn_166 1538173.644113492
Csub_0_166 sn_0 sn_166 6.849996125309101e-18
Rsub_0_87 sn_0 sn_87 40258.56759585816
Csub_0_87 sn_0 sn_87 2.617202779791402e-16
Rsub_0_194 sn_0 sn_194 1864854.21112567
Csub_0_194 sn_0 sn_194 5.650030677663502e-18
Rsub_0_27 sn_0 sn_27 34697056.13819926
Csub_0_27 sn_0 sn_27 3.036708203791964e-19
Rsub_0_106 sn_0 sn_106 72598.83446767337
Csub_0_106 sn_0 sn_106 1.451329567408091e-16
Rsub_0_89 sn_0 sn_89 30250.95022749872
Csub_0_89 sn_0 sn_89 3.483025631588963e-16
Rsub_0_205 sn_0 sn_205 4032.211243240278
Csub_0_205 sn_0 sn_205 2.613078250772125e-15
Rsub_0_38 sn_0 sn_38 3043463.274527521
Csub_0_38 sn_0 sn_38 3.462004483647244e-18
Rsub_0_117 sn_0 sn_117 61743.63515779716
Csub_0_117 sn_0 sn_117 1.706489013045975e-16
Rsub_0_223 sn_0 sn_223 112372.232218435
Csub_0_223 sn_0 sn_223 9.376412031887589e-17
Rsub_0_65 sn_0 sn_65 74278.23521087854
Csub_0_65 sn_0 sn_65 1.41851559508873e-16
Rsub_0_91 sn_0 sn_91 3156.121286080391
Csub_0_91 sn_0 sn_91 3.338427945940993e-15
Rsub_0_66 sn_0 sn_66 146116.8452889716
Csub_0_66 sn_0 sn_66 7.210998486445736e-17
Rsub_0_145 sn_0 sn_145 920605.3632529203
Csub_0_145 sn_0 sn_145 1.14451684976066e-17
Rsub_0_20 sn_0 sn_20 87675051.23067039
Csub_0_20 sn_0 sn_20 1.201765308868635e-19
Rsub_0_187 sn_0 sn_187 20454.66249618078
Csub_0_187 sn_0 sn_187 5.151140237194007e-16
Rsub_0_108 sn_0 sn_108 66877.56411046196
Csub_0_108 sn_0 sn_108 1.575488527785918e-16
Rsub_0_179 sn_0 sn_179 42771.62452639707
Csub_0_179 sn_0 sn_179 2.463428410517181e-16
Rsub_0_100 sn_0 sn_100 296449.8975195531
Csub_0_100 sn_0 sn_100 3.554220659339254e-17
Rsub_0_79 sn_0 sn_79 136689.1189241122
Csub_0_79 sn_0 sn_79 7.708355709044918e-17
Rsub_0_167 sn_0 sn_167 111114.0406950472
Csub_0_167 sn_0 sn_167 9.482585131745325e-17
Rsub_0_71 sn_0 sn_71 19160.73622412389
Csub_0_71 sn_0 sn_71 5.49899720918045e-16
Rsub_0_42 sn_0 sn_42 78949965.70051029
Csub_0_42 sn_0 sn_42 1.33457733752529e-19
Rsub_0_209 sn_0 sn_209 528.1668311257524
Csub_0_209 sn_0 sn_209 1.994915788212635e-14
Rsub_0_130 sn_0 sn_130 365116.4223512859
Csub_0_130 sn_0 sn_130 2.885787342671932e-17
Rsub_0_111 sn_0 sn_111 982.0873850542852
Csub_0_111 sn_0 sn_111 1.072866189157658e-14
Rsub_0_193 sn_0 sn_193 92304.6280583133
Csub_0_193 sn_0 sn_193 1.141490272359214e-16
Rsub_0_202 sn_0 sn_202 11070607.38596942
Csub_0_202 sn_0 sn_202 9.517529738778064e-19
Rsub_0_35 sn_0 sn_35 1978266.405698111
Csub_0_35 sn_0 sn_35 5.326119612546207e-18
Rsub_0_212 sn_0 sn_212 2794604.810628321
Csub_0_212 sn_0 sn_212 3.770294627046406e-18
Rsub_0_45 sn_0 sn_45 298649.9599585545
Csub_0_45 sn_0 sn_45 3.528037808440427e-17
Rsub_0_119 sn_0 sn_119 29888.64980353378
Csub_0_119 sn_0 sn_119 3.525245727555166e-16
Rsub_0_198 sn_0 sn_198 2710054.682919919
Csub_0_198 sn_0 sn_198 3.887922841054109e-18
Rsub_0_230 sn_0 0 10080.2295664562
Csub_0_230 sn_0 0 1.04526225645615e-15
Rsub_0_121 sn_0 sn_121 822846.5196290775
Csub_0_121 sn_0 sn_121 1.280491956990914e-17
Rsub_0_120 sn_0 sn_120 61249832.76515319
Csub_0_120 sn_0 sn_120 1.72024690134738e-19
Rsub_0_157 sn_0 sn_157 44731.75602032282
Csub_0_157 sn_0 sn_157 2.355481751586725e-16
Rsub_0_83 sn_0 sn_83 36552.4599769689
Csub_0_83 sn_0 sn_83 2.882564814753608e-16
Rsub_0_4 sn_0 sn_4 276058724.6117304
Csub_0_4 sn_0 sn_4 3.816754394214237e-20
Rsub_0_109 sn_0 sn_109 2775.003075792357
Csub_0_109 sn_0 sn_109 3.796926783305089e-15
Rsub_0_69 sn_0 sn_69 9749.102079794004
Csub_0_69 sn_0 sn_69 1.080764506924994e-15
Rsub_0_102 sn_0 sn_102 33934.56331996641
Csub_0_102 sn_0 sn_102 3.104941531995654e-16
Rsub_0_14 sn_0 sn_14 199467809.7854992
Csub_0_14 sn_0 sn_14 5.282297686810003e-20
Rsub_0_181 sn_0 sn_181 212585.4713202259
Csub_0_181 sn_0 sn_181 4.95635164378589e-17
Rsub_0_149 sn_0 sn_149 1083979.639357618
Csub_0_149 sn_0 sn_149 9.720185803927158e-18
Rsub_0_94 sn_0 sn_94 60638.27503750303
Csub_0_94 sn_0 sn_94 1.737596179263591e-16
Rsub_0_173 sn_0 sn_173 16002873.92578601
Csub_0_173 sn_0 sn_173 6.584119546959738e-19
Rsub_0_113 sn_0 sn_113 27494.98143871218
Csub_0_113 sn_0 sn_113 3.832147886957625e-16
Rsub_0_5 sn_0 sn_5 125230349.0568367
Csub_0_5 sn_0 sn_5 8.413682131835263e-20
Rsub_0_172 sn_0 sn_172 2696099.643041863
Csub_0_172 sn_0 sn_172 3.908046770238157e-18
Rsub_0_53 sn_0 sn_53 333714.9946863921
Csub_0_53 sn_0 sn_53 3.157329958197304e-17
Rsub_0_220 sn_0 sn_220 22207.70216328623
Csub_0_220 sn_0 sn_220 4.744517656423236e-16
Rsub_0_229 sn_0 sn_229 81455.94328078811
Csub_0_229 sn_0 sn_229 1.293519303546645e-16
Rsub_0_62 sn_0 sn_62 80025.85128476463
Csub_0_62 sn_0 sn_62 1.316634978956599e-16
Rsub_0_224 sn_0 sn_224 20719861.40684484
Csub_0_224 sn_0 sn_224 5.085209449687369e-19
Rsub_0_57 sn_0 sn_57 9055007.831357153
Csub_0_57 sn_0 sn_57 1.163608436178548e-18
Rsub_0_19 sn_0 sn_19 344557070.5925023
Csub_0_19 sn_0 sn_19 3.0579791858897e-20
Rsub_0_177 sn_0 sn_177 446107.0042059349
Csub_0_177 sn_0 sn_177 2.361873587029823e-17
Rsub_0_163 sn_0 sn_163 332002.245968463
Csub_0_163 sn_0 sn_163 3.17361813968899e-17
Rsub_0_183 sn_0 sn_183 56783.29792782703
Csub_0_183 sn_0 sn_183 1.855560329662805e-16
Rsub_0_77 sn_0 sn_77 29306.13850390532
Csub_0_77 sn_0 sn_77 3.595316217053269e-16
Rsub_0_90 sn_0 sn_90 182360263.2615166
Csub_0_90 sn_0 sn_90 5.777839598268177e-20
Rsub_0_55 sn_0 sn_55 97481213.68425958
Csub_0_55 sn_0 sn_55 1.080873237417574e-19
Rsub_0_222 sn_0 sn_222 815272.9356908804
Csub_0_222 sn_0 sn_222 1.292387253515432e-17
Rsub_0_99 sn_0 sn_99 4084064.529685398
Csub_0_99 sn_0 sn_99 2.579901327622177e-18
Rsub_0_11 sn_0 sn_11 383345301.7723926
Csub_0_11 sn_0 sn_11 2.748562054501435e-20
Rsub_0_178 sn_0 sn_178 15229188.56132359
Csub_0_178 sn_0 sn_178 6.918611231191074e-19
Rsub_0_195 sn_0 sn_195 4111263.715318646
Csub_0_195 sn_0 sn_195 2.562833287237417e-18
Rsub_0_217 sn_0 sn_217 65647.66569269379
Csub_0_217 sn_0 sn_217 1.605005050987312e-16
Rsub_0_153 sn_0 sn_153 1437904.483392477
Csub_0_153 sn_0 sn_153 7.327665796945748e-18
Rsub_0_22 sn_0 sn_22 43954085.22651092
Csub_0_22 sn_0 sn_22 2.397156816694462e-19
Rsub_0_189 sn_0 sn_189 564116.5910328251
Csub_0_189 sn_0 sn_189 1.867784722115521e-17
Rsub_0_39 sn_0 sn_39 40609744.78277856
Csub_0_39 sn_0 sn_39 2.594570233964687e-19
Rsub_0_206 sn_0 sn_206 1594057.164388276
Csub_0_206 sn_0 sn_206 6.609852982451483e-18
Rsub_0_135 sn_0 sn_135 2338276.846862751
Csub_0_135 sn_0 sn_135 4.506088967337946e-18
Rsub_167_195 sn_167 sn_195 10066455.08530576
Csub_167_195 sn_167 sn_195 1.046692545979801e-18
Rsub_167_209 sn_167 sn_209 229438.0226485337
Csub_167_209 sn_167 sn_209 4.592300517848512e-17
Rsub_167_172 sn_167 sn_172 7080606.045377874
Csub_167_172 sn_167 sn_172 1.488076505697994e-18
Rsub_167_213 sn_167 sn_213 3606130.973053822
Csub_167_213 sn_167 sn_213 2.921824964473564e-18
Rsub_167_202 sn_167 sn_202 11856.71937175017
Csub_167_202 sn_167 sn_202 8.886508292786488e-16
Rsub_167_173 sn_167 sn_173 60324.6528178938
Csub_167_173 sn_167 sn_173 1.746629779045262e-16
Rsub_167_187 sn_167 sn_187 1850388.052439651
Csub_167_187 sn_167 sn_187 5.694202082821566e-18
Rsub_167_175 sn_167 sn_175 2805.237115796061
Csub_167_175 sn_167 sn_175 3.756004596866313e-15
Rsub_167_230 sn_167 0 18225.47208822967
Csub_167_230 sn_167 0 5.781185503027186e-16
Rsub_167_179 sn_167 sn_179 119042.852144313
Csub_167_179 sn_167 sn_179 8.851000553529127e-17
Rsub_167_214 sn_167 sn_214 2782515.555292733
Csub_167_214 sn_167 sn_214 3.786675507415632e-18
Rsub_167_174 sn_167 sn_174 37738413.502304
Csub_167_174 sn_167 sn_174 2.791978391350959e-19
Rsub_167_180 sn_167 sn_180 7704471.898017333
Csub_167_180 sn_167 sn_180 1.367580236737765e-18
Rsub_167_217 sn_167 sn_217 810901.4130038824
Csub_167_217 sn_167 sn_217 1.299354438562257e-17
Rsub_167_223 sn_167 sn_223 579483.9164663047
Csub_167_223 sn_167 sn_223 1.81825296661925e-17
Rsub_167_206 sn_167 sn_206 2620114.760251983
Csub_167_206 sn_167 sn_206 4.021382445560013e-18
Rsub_167_189 sn_167 sn_189 110499.1163580625
Csub_167_189 sn_167 sn_189 9.535355439483755e-17
Rsub_79_113 sn_79 sn_113 1123190.251402435
Csub_79_113 sn_79 sn_113 9.380853768160793e-18
Rsub_79_146 sn_79 sn_146 24447516.44895666
Csub_79_146 sn_79 sn_146 4.309837984659445e-19
Rsub_79_85 sn_79 sn_85 227219.0604627197
Csub_79_85 sn_79 sn_85 4.637147729056271e-17
Rsub_79_202 sn_79 sn_202 109734.568635756
Csub_79_202 sn_79 sn_202 9.601790605478158e-17
Rsub_79_141 sn_79 sn_141 276789.9599187535
Csub_79_141 sn_79 sn_141 3.806671132624459e-17
Rsub_79_194 sn_79 sn_194 1825581.453927674
Csub_79_194 sn_79 sn_194 5.771576765069085e-18
Rsub_79_118 sn_79 sn_118 6728079.737801167
Csub_79_118 sn_79 sn_118 1.566046169612353e-18
Rsub_79_119 sn_79 sn_119 1616517.528008926
Csub_79_119 sn_79 sn_119 6.518013767043929e-18
Rsub_79_83 sn_79 sn_83 342455.5606676715
Csub_79_83 sn_79 sn_83 3.076744755345031e-17
Rsub_79_95 sn_79 sn_95 41629480.76315053
Csub_79_95 sn_79 sn_95 2.531014874333156e-19
Rsub_79_196 sn_79 sn_196 10381096.25136319
Csub_79_196 sn_79 sn_196 1.014968289196472e-18
Rsub_79_129 sn_79 sn_129 28499216.8740997
Csub_79_129 sn_79 sn_129 3.697113344825148e-19
Rsub_79_126 sn_79 sn_126 5183888.498318609
Csub_79_126 sn_79 sn_126 2.03254439319972e-18
Rsub_79_84 sn_79 sn_84 6200728.539350056
Csub_79_84 sn_79 sn_84 1.699233152260268e-18
Rsub_79_101 sn_79 sn_101 28545773.44009319
Csub_79_101 sn_79 sn_101 3.691083558952118e-19
Rsub_79_115 sn_79 sn_115 196210.7827555934
Csub_79_115 sn_79 sn_115 5.369981891033274e-17
Rsub_79_207 sn_79 sn_207 10737710.87427612
Csub_79_207 sn_79 sn_207 9.812597513192325e-19
Rsub_79_171 sn_79 sn_171 2812670.111921629
Csub_79_171 sn_79 sn_171 3.7460786665207e-18
Rsub_79_154 sn_79 sn_154 629955.6430091972
Csub_79_154 sn_79 sn_154 1.672575461329136e-17
Rsub_79_177 sn_79 sn_177 39724.35791979705
Csub_79_177 sn_79 sn_177 2.652398692888384e-16
Rsub_79_144 sn_79 sn_144 64416598.36123338
Csub_79_144 sn_79 sn_144 1.635678345376737e-19
Rsub_79_213 sn_79 sn_213 150785294.1084633
Csub_79_213 sn_79 sn_213 6.987739463936626e-20
Rsub_79_184 sn_79 sn_184 23247480.88870294
Csub_79_184 sn_79 sn_184 4.532311932064082e-19
Rsub_79_197 sn_79 sn_197 6728412.211413638
Csub_79_197 sn_79 sn_197 1.565968785972506e-18
Rsub_79_223 sn_79 sn_223 290834.2748904624
Csub_79_223 sn_79 sn_223 3.622847928153717e-17
Rsub_79_211 sn_79 sn_211 6847014.011200804
Csub_79_211 sn_79 sn_211 1.538843572540339e-18
Rsub_79_185 sn_79 sn_185 223606.6447085729
Csub_79_185 sn_79 sn_185 4.712061895996975e-17
Rsub_79_89 sn_79 sn_89 343151.2252738426
Csub_79_89 sn_79 sn_89 3.070507323359153e-17
Rsub_79_180 sn_79 sn_180 1504144.653362573
Csub_79_180 sn_79 sn_180 7.00496689508904e-18
Rsub_79_97 sn_79 sn_97 4927912.910270485
Csub_79_97 sn_79 sn_97 2.138122912089303e-18
Rsub_79_82 sn_79 sn_82 6266079.629596042
Csub_79_82 sn_79 sn_82 1.681511267821099e-18
Rsub_79_161 sn_79 sn_161 384613.3277348899
Csub_79_161 sn_79 sn_161 2.739500361124431e-17
Rsub_79_112 sn_79 sn_112 5221933.821845159
Csub_79_112 sn_79 sn_112 2.017735931112769e-18
Rsub_79_191 sn_79 sn_191 237151.0997565567
Csub_79_191 sn_79 sn_191 4.442941024960898e-17
Rsub_79_175 sn_79 sn_175 178261.3385287989
Csub_79_175 sn_79 sn_175 5.910694707662474e-17
Rsub_79_96 sn_79 sn_96 724.6396118319387
Csub_79_96 sn_79 sn_96 1.454030849292526e-14
Rsub_79_179 sn_79 sn_179 16811.67152232127
Csub_79_179 sn_79 sn_179 6.267362224059905e-16
Rsub_79_100 sn_79 sn_100 522217.3521694189
Csub_79_100 sn_79 sn_100 2.01764331622817e-17
Rsub_79_209 sn_79 sn_209 205086.0881257129
Csub_79_209 sn_79 sn_209 5.137590559419802e-17
Rsub_79_130 sn_79 sn_130 37029.59771328248
Csub_79_130 sn_79 sn_130 2.845422082036439e-16
Rsub_79_205 sn_79 sn_205 52074.09675748801
Csub_79_205 sn_79 sn_205 2.023363660304853e-16
Rsub_79_94 sn_79 sn_94 217640.907101576
Csub_79_94 sn_79 sn_94 4.841223850125049e-17
Rsub_79_195 sn_79 sn_195 1658647.326943404
Csub_79_195 sn_79 sn_195 6.352455601063121e-18
Rsub_79_121 sn_79 sn_121 1397319.027135629
Csub_79_121 sn_79 sn_121 7.54049955494329e-18
Rsub_79_200 sn_79 sn_200 5224104.023846784
Csub_79_200 sn_79 sn_200 2.016897721433853e-18
Rsub_79_181 sn_79 sn_181 81016.73493006162
Csub_79_181 sn_79 sn_181 1.300531737217713e-16
Rsub_79_106 sn_79 sn_106 1203123.167173038
Csub_79_106 sn_79 sn_106 8.757610018421833e-18
Rsub_79_217 sn_79 sn_217 19388.62303369203
Csub_79_217 sn_79 sn_217 5.434363999919194e-16
Rsub_79_138 sn_79 sn_138 808865.5581503449
Csub_79_138 sn_79 sn_138 1.302624817692086e-17
Rsub_79_143 sn_79 sn_143 3854248.834020244
Csub_79_143 sn_79 sn_143 2.733732033393322e-18
Rsub_79_222 sn_79 sn_222 45189.18956730469
Csub_79_222 sn_79 sn_222 2.331638076079453e-16
Rsub_79_151 sn_79 sn_151 24417.29299508398
Csub_79_151 sn_79 sn_151 4.315172654213286e-16
Rsub_79_230 sn_79 0 21482.49874270595
Csub_79_230 sn_79 0 4.904682471263964e-16
Rsub_79_160 sn_79 sn_160 1859882.146860915
Csub_79_160 sn_79 sn_160 5.6651350302025e-18
Rsub_79_206 sn_79 sn_206 1965597.16706554
Csub_79_206 sn_79 sn_206 5.360449067984783e-18
Rsub_79_169 sn_79 sn_169 78112.5443660793
Csub_79_169 sn_79 sn_169 1.348884943863833e-16
Rsub_79_90 sn_79 sn_90 197493867.2299453
Csub_79_90 sn_79 sn_90 5.335094020900509e-20
Rsub_79_157 sn_79 sn_157 1701.646279609385
Csub_79_157 sn_79 sn_157 6.191935203271896e-15
Rsub_79_183 sn_79 sn_183 52660.79940771632
Csub_79_183 sn_79 sn_183 2.000821032102696e-16
Rsub_79_104 sn_79 sn_104 1860004.431508643
Csub_79_104 sn_79 sn_104 5.664762579992295e-18
Rsub_79_220 sn_79 sn_220 797.1860237026701
Csub_79_220 sn_79 sn_220 1.321709511826544e-14
Rsub_79_189 sn_79 sn_189 179351.6787628164
Csub_79_189 sn_79 sn_189 5.87476157174083e-17
Rsub_79_110 sn_79 sn_110 10449192.04253995
Csub_79_110 sn_79 sn_110 1.008353895625105e-18
Rsub_79_152 sn_79 sn_152 82502.08420577184
Csub_79_152 sn_79 sn_152 1.277117251480645e-16
Rsub_79_190 sn_79 sn_190 1122142.587809862
Csub_79_190 sn_79 sn_190 9.38961199467043e-18
Rsub_79_111 sn_79 sn_111 44198.58421884162
Csub_79_111 sn_79 sn_111 2.383896156053423e-16
Rsub_79_128 sn_79 sn_128 31277.16227802151
Csub_79_128 sn_79 sn_128 3.368746630071999e-16
Rsub_79_145 sn_79 sn_145 20676.35364341794
Csub_79_145 sn_79 sn_145 5.09590989008072e-16
Rsub_79_187 sn_79 sn_187 13059.68055713605
Csub_79_187 sn_79 sn_187 8.067948872204747e-16
Rsub_79_87 sn_79 sn_87 78286.67883461466
Csub_79_87 sn_79 sn_87 1.345884594809413e-16
Rsub_79_166 sn_79 sn_166 901593.8121825644
Csub_79_166 sn_79 sn_166 1.168650822560932e-17
Rsub_79_155 sn_79 sn_155 4664093.907850771
Csub_79_155 sn_79 sn_155 2.259063327283057e-18
Rsub_79_117 sn_79 sn_117 78410.41800480998
Csub_79_117 sn_79 sn_117 1.343760659659238e-16
Rsub_79_215 sn_79 sn_215 717884.5208399188
Csub_79_215 sn_79 sn_215 1.467712869738772e-17
Rsub_79_98 sn_79 sn_98 388319.992879074
Csub_79_98 sn_79 sn_98 2.713350766235503e-17
Rsub_79_80 sn_79 sn_80 7787906.804971182
Csub_79_80 sn_79 sn_80 1.352928812078792e-18
Rsub_79_193 sn_79 sn_193 536737.1930881181
Csub_79_193 sn_79 sn_193 1.963061930105557e-17
Rsub_79_188 sn_79 sn_188 10680013.73948019
Csub_79_188 sn_79 sn_188 9.865608564978149e-19
Rsub_79_163 sn_79 sn_163 788024.3096753904
Csub_79_163 sn_79 sn_163 1.337075947132935e-17
Rsub_79_226 sn_79 sn_226 412146.2749473337
Csub_79_226 sn_79 sn_226 2.556491261161201e-17
Rsub_79_172 sn_79 sn_172 650589.740089506
Csub_79_172 sn_79 sn_172 1.619528076292815e-17
Rsub_79_208 sn_79 sn_208 2449607.199749171
Csub_79_208 sn_79 sn_208 4.301295123278905e-18
Rsub_79_228 sn_79 sn_228 12399486.33646583
Csub_79_228 sn_79 sn_228 8.497516119875953e-19
Rsub_79_142 sn_79 sn_142 5500211.969737279
Csub_79_142 sn_79 sn_142 1.915650444056119e-18
Rsub_79_227 sn_79 sn_227 14942790.01503487
Csub_79_227 sn_79 sn_227 7.051215664296018e-19
Rsub_79_167 sn_79 sn_167 449748.7112872812
Csub_79_167 sn_79 sn_167 2.342749014682495e-17
Rsub_79_86 sn_79 sn_86 6174648.489196029
Csub_79_86 sn_79 sn_86 1.70641025487783e-18
Rsub_79_135 sn_79 sn_135 2664296.445897531
Csub_79_135 sn_79 sn_135 3.954696377144526e-18
Rsub_79_162 sn_79 sn_162 3318126.450595198
Csub_79_162 sn_79 sn_162 3.175431575351805e-18
Rsub_79_229 sn_79 sn_229 320767.4899735905
Csub_79_229 sn_79 sn_229 3.284772874924916e-17
Rsub_79_219 sn_79 sn_219 1483713.36317048
Csub_79_219 sn_79 sn_219 7.101427919820758e-18
Rsub_79_203 sn_79 sn_203 3634825.980589341
Csub_79_203 sn_79 sn_203 2.898758718710831e-18
Rsub_79_170 sn_79 sn_170 2235118.424495874
Csub_79_170 sn_79 sn_170 4.714060510957705e-18
Rsub_79_210 sn_79 sn_210 2678078.604821711
Csub_79_210 sn_79 sn_210 3.934344377816144e-18
Rsub_79_133 sn_79 sn_133 6947089.973670602
Csub_79_133 sn_79 sn_133 1.516675837244539e-18
Rsub_79_204 sn_79 sn_204 1823592.693575551
Csub_79_204 sn_79 sn_204 5.777871088949655e-18
Rsub_79_186 sn_79 sn_186 18725311.36476922
Csub_79_186 sn_79 sn_186 5.626866916645187e-19
Rsub_79_92 sn_79 sn_92 129018.490827511
Csub_79_92 sn_79 sn_92 8.166646063405415e-17
Rsub_104_175 sn_104 sn_175 745651.5957242887
Csub_104_175 sn_104 sn_175 1.413057192212589e-17
Rsub_104_122 sn_104 sn_122 200953.5025110767
Csub_104_122 sn_104 sn_122 5.243244517049023e-17
Rsub_104_143 sn_104 sn_143 42081278.7701287
Csub_104_143 sn_104 sn_143 2.503841092801889e-19
Rsub_104_217 sn_104 sn_217 341648.3109530325
Csub_104_217 sn_104 sn_217 3.084014515639882e-17
Rsub_104_133 sn_104 sn_133 137938905.4846993
Csub_104_133 sn_104 sn_133 7.638514649080454e-20
Rsub_104_144 sn_104 sn_144 88791978.85907818
Csub_104_144 sn_104 sn_144 1.186648122681494e-19
Rsub_104_109 sn_104 sn_109 2207554.135294462
Csub_104_109 sn_104 sn_109 4.772921911074475e-18
Rsub_104_105 sn_104 sn_105 48831210.47251616
Csub_104_105 sn_104 sn_105 2.157735472922648e-19
Rsub_104_179 sn_104 sn_179 63449.29963439274
Csub_104_179 sn_104 sn_179 1.660614626629967e-16
Rsub_104_209 sn_104 sn_209 29557.83186858033
Csub_104_209 sn_104 sn_209 3.564701074516286e-16
Rsub_104_130 sn_104 sn_130 2517683.115886891
Csub_104_130 sn_104 sn_130 4.184991922034784e-18
Rsub_104_167 sn_104 sn_167 1022413.227531428
Csub_104_167 sn_104 sn_167 1.030550389852631e-17
Rsub_104_157 sn_104 sn_157 688537.7863937783
Csub_104_157 sn_104 sn_157 1.530269465299052e-17
Rsub_104_111 sn_104 sn_111 580699.6509877023
Csub_104_111 sn_104 sn_111 1.814446329407754e-17
Rsub_104_222 sn_104 sn_222 12018316.95683589
Csub_104_222 sn_104 sn_222 8.767020823358271e-19
Rsub_104_150 sn_104 sn_150 21544776.79594444
Csub_104_150 sn_104 sn_150 4.890504831878034e-19
Rsub_104_187 sn_104 sn_187 112965.0681689534
Csub_104_187 sn_104 sn_187 9.327205013917555e-17
Rsub_104_128 sn_104 sn_128 467464.4983634184
Csub_104_128 sn_104 sn_128 2.253964427056593e-17
Rsub_104_202 sn_104 sn_202 422887.8015759688
Csub_104_202 sn_104 sn_202 2.49155531631886e-17
Rsub_104_127 sn_104 sn_127 909370.9615234808
Csub_104_127 sn_104 sn_127 1.158656252293134e-17
Rsub_183_218 sn_183 sn_218 9148821.366434066
Csub_183_218 sn_183 sn_218 1.151676601850278e-18
Rsub_183_211 sn_183 sn_211 34146403.89801685
Csub_183_211 sn_183 sn_211 3.085678812240002e-19
Rsub_183_209 sn_183 sn_209 2857846.834673855
Csub_183_209 sn_183 sn_209 3.686860812270385e-18
Rsub_183_187 sn_183 sn_187 2030523.3226805
Csub_183_187 sn_183 sn_187 5.189048253984474e-18
Rsub_183_204 sn_183 sn_204 9079386.898077974
Csub_183_204 sn_183 sn_204 1.160484030530793e-18
Rsub_183_190 sn_183 sn_190 10417657.25244145
Csub_183_190 sn_183 sn_190 1.011406235289677e-18
Rsub_183_213 sn_183 sn_213 25169431.46355883
Csub_183_213 sn_183 sn_213 4.186222290116122e-19
Rsub_183_208 sn_183 sn_208 1219057.930199451
Csub_183_208 sn_183 sn_208 8.643136016108864e-18
Rsub_183_200 sn_183 sn_200 24021481.67284697
Csub_183_200 sn_183 sn_200 4.38627543701439e-19
Rsub_183_207 sn_183 sn_207 33103818.31746877
Csub_183_207 sn_183 sn_207 3.182860478868064e-19
Rsub_183_199 sn_183 sn_199 13713874.84544203
Csub_183_199 sn_183 sn_199 7.683082732618002e-19
Rsub_183_202 sn_183 sn_202 69509.67628754598
Csub_183_202 sn_183 sn_202 1.515829747018663e-16
Rsub_183_216 sn_183 sn_216 197442.4203099842
Csub_183_216 sn_183 sn_216 5.336484168745372e-17
Rsub_183_210 sn_183 sn_210 20030573.87618061
Csub_183_210 sn_183 sn_210 5.260200515153227e-19
Rsub_183_197 sn_183 sn_197 38461923.26427644
Csub_183_197 sn_183 sn_197 2.739458302652359e-19
Rsub_183_215 sn_183 sn_215 1646294.857670045
Csub_183_215 sn_183 sn_215 6.400119306174589e-18
Rsub_183_198 sn_183 sn_198 4605734.508537305
Csub_183_198 sn_183 sn_198 2.287687986074602e-18
Rsub_183_212 sn_183 sn_212 3273746.181666635
Csub_183_212 sn_183 sn_212 3.218479050463824e-18
Rsub_183_195 sn_183 sn_195 955823.4075850394
Csub_183_195 sn_183 sn_195 1.102346251265308e-17
Rsub_183_229 sn_183 sn_229 229110.9664037357
Csub_183_229 sn_183 sn_229 4.598856033657847e-17
Rsub_183_222 sn_183 sn_222 635736.6550024108
Csub_183_222 sn_183 sn_222 1.657366052330276e-17
Rsub_183_219 sn_183 sn_219 3460735.843990141
Csub_183_219 sn_183 sn_219 3.044578950030957e-18
Rsub_183_217 sn_183 sn_217 206477.0089556766
Csub_183_217 sn_183 sn_217 5.102981467777759e-17
Rsub_183_226 sn_183 sn_226 5080670.189572464
Csub_183_226 sn_183 sn_226 2.073837330329966e-18
Rsub_183_189 sn_183 sn_189 20424.02270166763
Csub_183_189 sn_183 sn_189 5.158867895975113e-16
Rsub_183_206 sn_183 sn_206 14492563.63383493
Csub_183_206 sn_183 sn_206 7.270268924423486e-19
Rsub_183_230 sn_183 0 5351.76514623191
Csub_183_230 sn_183 0 1.968786599249141e-15
Rsub_183_228 sn_183 sn_228 51908333.73881117
Csub_183_228 sn_183 sn_228 2.029825028722124e-19
Rsub_183_191 sn_183 sn_191 42062.06150624157
Csub_183_191 sn_183 sn_191 2.504985044697939e-16
Rsub_183_188 sn_183 sn_188 33737317.94088908
Csub_183_188 sn_183 sn_188 3.12309458644309e-19
Rsub_183_186 sn_183 sn_186 22787228.03363405
Csub_183_186 sn_183 sn_186 4.62385485706208e-19
Rsub_6_194 sn_6 sn_194 6331463.426242332
Csub_6_194 sn_6 sn_194 1.664146626601192e-18
Rsub_6_126 sn_6 sn_126 116324550.4140606
Csub_6_126 sn_6 sn_126 9.057832989446412e-20
Rsub_6_127 sn_6 sn_127 177716555.8230564
Csub_6_127 sn_6 sn_127 5.928813696299998e-20
Rsub_6_153 sn_6 sn_153 218661000.9525916
Csub_6_153 sn_6 sn_153 4.818638649017454e-20
Rsub_6_86 sn_6 sn_86 350526248.0826146
Csub_6_86 sn_6 sn_86 3.005904282450964e-20
Rsub_6_66 sn_6 sn_66 350526248.0826146
Csub_6_66 sn_6 sn_66 3.005904282450964e-20
Rsub_6_122 sn_6 sn_122 350526248.0826146
Csub_6_122 sn_6 sn_122 3.005904282450964e-20
Rsub_6_213 sn_6 sn_213 350526248.0826146
Csub_6_213 sn_6 sn_213 3.005904282450964e-20
Rsub_6_100 sn_6 sn_100 353571150.3410364
Csub_6_100 sn_6 sn_100 2.98001788100275e-20
Rsub_6_135 sn_6 sn_135 153917574.7117043
Csub_6_135 sn_6 sn_135 6.845536334603367e-20
Rsub_6_150 sn_6 sn_150 353571150.3410364
Csub_6_150 sn_6 sn_150 2.98001788100275e-20
Rsub_6_72 sn_6 sn_72 353571150.3410364
Csub_6_72 sn_6 sn_72 2.98001788100275e-20
Rsub_6_165 sn_6 sn_165 306599741.3072614
Csub_6_165 sn_6 sn_165 3.43655981485998e-20
Rsub_6_181 sn_6 sn_181 93677030.59364717
Csub_6_181 sn_6 sn_181 1.124767025113683e-19
Rsub_6_125 sn_6 sn_125 353571150.3410364
Csub_6_125 sn_6 sn_125 2.98001788100275e-20
Rsub_6_70 sn_6 sn_70 353571150.3410364
Csub_6_70 sn_6 sn_70 2.98001788100275e-20
Rsub_6_157 sn_6 sn_157 264220507.8547304
Csub_6_157 sn_6 sn_157 3.98776142994283e-20
Rsub_6_195 sn_6 sn_195 86636679.70430236
Csub_6_195 sn_6 sn_195 1.216168894998265e-19
Rsub_6_114 sn_6 sn_114 353571150.3410364
Csub_6_114 sn_6 sn_114 2.98001788100275e-20
Rsub_6_115 sn_6 sn_115 353571150.3410364
Csub_6_115 sn_6 sn_115 2.98001788100275e-20
Rsub_6_130 sn_6 sn_130 106398174.6913616
Csub_6_130 sn_6 sn_130 9.90287994394085e-20
Rsub_6_116 sn_6 sn_116 204938427.5904131
Csub_6_116 sn_6 sn_116 5.141292253538736e-20
Rsub_6_77 sn_6 sn_77 288570299.0064869
Csub_6_77 sn_6 sn_77 3.651270951482483e-20
Rsub_6_48 sn_6 sn_48 113648422.1069857
Csub_6_48 sn_6 sn_48 9.271121681136259e-20
Rsub_6_215 sn_6 sn_215 282761904.7891729
Csub_6_215 sn_6 sn_215 3.726274057350828e-20
Rsub_6_210 sn_6 sn_210 83815366.44274612
Csub_6_210 sn_6 sn_210 1.257106417285358e-19
Rsub_6_26 sn_6 sn_26 267419749.140449
Csub_6_26 sn_6 sn_26 3.940054366252596e-20
Rsub_6_164 sn_6 sn_164 28605454.09768049
Csub_6_164 sn_6 sn_164 3.683382709552709e-19
Rsub_6_146 sn_6 sn_146 43746249.43936198
Csub_6_146 sn_6 sn_146 2.408545563851124e-19
Rsub_6_225 sn_6 sn_225 355456089.8343452
Csub_6_225 sn_6 sn_225 2.964215216326823e-20
Rsub_6_29 sn_6 sn_29 9609143.577563642
Csub_6_29 sn_6 sn_29 1.09650599110951e-18
Rsub_6_186 sn_6 sn_186 4591516.08114089
Csub_6_186 sn_6 sn_186 2.294772209446759e-18
Rsub_6_107 sn_6 sn_107 1001286403.027549
Csub_6_107 sn_6 sn_107 1.052294675166992e-20
Rsub_6_42 sn_6 sn_42 3631623.477990805
Csub_6_42 sn_6 sn_42 2.901314953514759e-18
Rsub_6_162 sn_6 sn_162 33480785.08622875
Csub_6_162 sn_6 sn_162 3.147024024404925e-19
Rsub_6_207 sn_6 sn_207 8667763.978500497
Csub_6_207 sn_6 sn_207 1.215594186501233e-18
Rsub_6_138 sn_6 sn_138 2731001.083120104
Csub_6_138 sn_6 sn_138 3.858103011146491e-18
Rsub_6_13 sn_6 sn_13 464278756.4748092
Csub_6_13 sn_6 sn_13 2.269430456442107e-20
Rsub_6_180 sn_6 sn_180 355456089.8343452
Csub_6_180 sn_6 sn_180 2.964215216326823e-20
Rsub_6_189 sn_6 sn_189 185935837.9096076
Csub_6_189 sn_6 sn_189 5.666730857637189e-20
Rsub_6_22 sn_6 sn_22 141321554.9804592
Csub_6_22 sn_6 sn_22 7.455680418805826e-20
Rsub_6_141 sn_6 sn_141 23013757.15517217
Csub_6_141 sn_6 sn_141 4.578341307413165e-19
Rsub_6_53 sn_6 sn_53 61411315.79582387
Csub_6_53 sn_6 sn_53 1.715723456774803e-19
Rsub_6_220 sn_6 sn_220 881776875.1907926
Csub_6_220 sn_6 sn_220 1.19491492674382e-20
Rsub_6_214 sn_6 sn_214 350526248.0826146
Csub_6_214 sn_6 sn_214 3.005904282450964e-20
Rsub_6_205 sn_6 sn_205 408375091.2696911
Csub_6_205 sn_6 sn_205 2.580099454516364e-20
Rsub_6_84 sn_6 sn_84 148756.1091130394
Csub_6_84 sn_6 sn_84 7.083059354707478e-17
Rsub_6_30 sn_6 sn_30 45162250.45020461
Csub_6_30 sn_6 sn_30 2.333028889658058e-19
Rsub_6_197 sn_6 sn_197 44097098.66604841
Csub_6_197 sn_6 sn_197 2.389382481152289e-19
Rsub_6_160 sn_6 sn_160 12093996.51616897
Csub_6_160 sn_6 sn_160 8.712160192987765e-19
Rsub_6_175 sn_6 sn_175 176021057.6502174
Csub_6_175 sn_6 sn_175 5.985922163453713e-20
Rsub_6_8 sn_6 sn_8 97555.75681058022
Csub_6_8 sn_6 sn_8 1.080047333617455e-16
Rsub_6_87 sn_6 sn_87 204187545.6348456
Csub_6_87 sn_6 sn_87 5.160198909032727e-20
Rsub_6_56 sn_6 sn_56 15150630.66465186
Csub_6_56 sn_6 sn_56 6.954485087418051e-19
Rsub_6_93 sn_6 sn_93 23314.49869549966
Csub_6_93 sn_6 sn_93 4.519283746926041e-16
Rsub_6_59 sn_6 sn_59 9680128.831022678
Csub_6_59 sn_6 sn_59 1.088465214271002e-18
Rsub_6_226 sn_6 sn_226 5115517.138252111
Csub_6_226 sn_6 sn_226 2.059710331814106e-18
Rsub_6_82 sn_6 sn_82 177255557.2721986
Csub_6_82 sn_6 sn_82 5.944233097329572e-20
Rsub_6_212 sn_6 sn_212 114135932.3440425
Csub_6_212 sn_6 sn_212 9.231521823004556e-20
Rsub_6_45 sn_6 sn_45 10750042.67590312
Csub_6_45 sn_6 sn_45 9.801341092206241e-19
Rsub_6_36 sn_6 sn_36 26738478.723185
Csub_6_36 sn_6 sn_36 3.940569548219581e-19
Rsub_6_203 sn_6 sn_203 161516733.1033387
Csub_6_203 sn_6 sn_203 6.523462491956635e-20
Rsub_6_184 sn_6 sn_184 86885373.84096408
Csub_6_184 sn_6 sn_184 1.212687824940029e-19
Rsub_6_219 sn_6 sn_219 918174002.8648295
Csub_6_219 sn_6 sn_219 1.14754757479026e-20
Rsub_6_131 sn_6 sn_131 106207734.7710858
Csub_6_131 sn_6 sn_131 9.92063668897538e-20
Rsub_6_74 sn_6 sn_74 4184267.345949234
Csub_6_74 sn_6 sn_74 2.518119094954655e-18
Rsub_6_222 sn_6 sn_222 20609905.84105307
Csub_6_222 sn_6 sn_222 5.112339466026225e-19
Rsub_6_64 sn_6 sn_64 21032457.02641556
Csub_6_64 sn_6 sn_64 5.009630348464178e-19
Rsub_6_120 sn_6 sn_120 3644976.155030594
Csub_6_120 sn_6 sn_120 2.890686537877109e-18
Rsub_6_224 sn_6 sn_224 1358012.049857942
Csub_6_224 sn_6 sn_224 7.75875553043303e-18
Rsub_6_57 sn_6 sn_57 23427822.15836692
Csub_6_57 sn_6 sn_57 4.49742337593554e-19
Rsub_6_218 sn_6 sn_218 134231607.9722249
Csub_6_218 sn_6 sn_218 7.849480209169663e-20
Rsub_6_139 sn_6 sn_139 137284901.6280943
Csub_6_139 sn_6 sn_139 7.674903341354614e-20
Rsub_6_171 sn_6 sn_171 66636392.43644556
Csub_6_171 sn_6 sn_171 1.581190565242434e-19
Rsub_6_208 sn_6 sn_208 1437304.261365505
Csub_6_208 sn_6 sn_208 7.330725849389644e-18
Rsub_6_155 sn_6 sn_155 40484394.96754112
Csub_6_155 sn_6 sn_155 2.602603672520674e-19
Rsub_6_31 sn_6 sn_31 49052340.87147281
Csub_6_31 sn_6 sn_31 2.148008293801462e-19
Rsub_6_198 sn_6 sn_198 59544786.30077196
Csub_6_198 sn_6 sn_198 1.769505637153223e-19
Rsub_6_15 sn_6 sn_15 4510031894.323488
Rsub_6_182 sn_6 sn_182 279010077.5640628
Csub_6_182 sn_6 sn_182 3.776380980292995e-20
Rsub_6_227 sn_6 sn_227 34704130.64654552
Csub_6_227 sn_6 sn_227 3.036089164584451e-19
Rsub_6_148 sn_6 sn_148 73806271.21998909
Csub_6_148 sn_6 sn_148 1.427586481211692e-19
Rsub_6_200 sn_6 sn_200 353571150.3410364
Csub_6_200 sn_6 sn_200 2.98001788100275e-20
Rsub_6_33 sn_6 sn_33 173568826.8411393
Csub_6_33 sn_6 sn_33 6.070493010748774e-20
Rsub_6_191 sn_6 sn_191 74968547.57253893
Csub_6_191 sn_6 sn_191 1.405453866107648e-19
Rsub_6_44 sn_6 sn_44 7252513.230585502
Csub_6_44 sn_6 sn_44 1.452804450986073e-18
Rsub_6_211 sn_6 sn_211 96217125.21013212
Csub_6_211 sn_6 sn_211 1.095073613893471e-19
Rsub_6_132 sn_6 sn_132 52871813.05532336
Csub_6_132 sn_6 sn_132 1.992835670531095e-19
Rsub_6_9 sn_6 sn_9 6743056.409939506
Csub_6_9 sn_6 sn_9 1.562567901211511e-18
Rsub_6_192 sn_6 sn_192 104455670.3953618
Csub_6_192 sn_6 sn_192 1.008703832195007e-19
Rsub_6_25 sn_6 sn_25 22392455.58006355
Csub_6_25 sn_6 sn_25 4.705372068086558e-19
Rsub_6_183 sn_6 sn_183 710912179.6686904
Csub_6_183 sn_6 sn_183 1.482107608163411e-20
Rsub_6_199 sn_6 sn_199 105829584.2677282
Csub_6_199 sn_6 sn_199 9.956085129820365e-20
Rsub_6_32 sn_6 sn_32 17532134.59803065
Csub_6_32 sn_6 sn_32 6.00981212145927e-19
Rsub_6_190 sn_6 sn_190 111336020.9084146
Csub_6_190 sn_6 sn_190 9.463678885108844e-20
Rsub_6_49 sn_6 sn_49 28920957.26520755
Csub_6_49 sn_6 sn_49 3.643200121493068e-19
Rsub_6_216 sn_6 sn_216 12310877.48565384
Csub_6_216 sn_6 sn_216 8.558677896444361e-19
Rsub_6_137 sn_6 sn_137 128460409.6878942
Csub_6_137 sn_6 sn_137 8.20212509661872e-20
Rsub_6_158 sn_6 sn_158 28482731.84291719
Csub_6_158 sn_6 sn_158 3.699253133561383e-19
Rsub_6_79 sn_6 sn_79 220444218.7976981
Csub_6_79 sn_6 sn_79 4.779659706975279e-20
Rsub_6_230 sn_6 0 1955808.231424471
Csub_6_230 sn_6 0 5.387278431973865e-18
Rsub_6_202 sn_6 sn_202 170277929.8280841
Csub_6_202 sn_6 sn_202 6.187815128400868e-20
Rsub_6_35 sn_6 sn_35 26398079.80915741
Csub_6_35 sn_6 sn_35 3.991382546913481e-19
Rsub_6_177 sn_6 sn_177 67760359.85275172
Csub_6_177 sn_6 sn_177 1.554962742985215e-19
Rsub_6_10 sn_6 sn_10 39732792.91121176
Csub_6_10 sn_6 sn_10 2.651835607372274e-19
Rsub_6_154 sn_6 sn_154 270228347.7534376
Csub_6_154 sn_6 sn_154 3.899103698714735e-20
Rsub_6_159 sn_6 sn_159 175775807.7280198
Csub_6_159 sn_6 sn_159 5.99427397798293e-20
Rsub_6_170 sn_6 sn_170 83058479.17960346
Csub_6_170 sn_6 sn_170 1.268562054868135e-19
Rsub_6_78 sn_6 sn_78 228668881.7561356
Csub_6_78 sn_6 sn_78 4.607746983897293e-20
Rsub_6_96 sn_6 sn_96 440888437.5953963
Csub_6_96 sn_6 sn_96 2.389829853487639e-20
Rsub_85_97 sn_85 sn_97 15373043.10959342
Csub_85_97 sn_85 sn_97 6.853869742715285e-19
Rsub_85_182 sn_85 sn_182 15049308.58279547
Csub_85_182 sn_85 sn_182 7.001307365227014e-19
Rsub_85_177 sn_85 sn_177 198720.1611176763
Csub_85_177 sn_85 sn_177 5.30217137655731e-17
Rsub_85_98 sn_85 sn_98 218802.300979899
Csub_85_98 sn_85 sn_98 4.815526827205518e-17
Rsub_85_117 sn_85 sn_117 290024.9140091997
Csub_85_117 sn_85 sn_117 3.632958064387455e-17
Rsub_85_135 sn_85 sn_135 11995069.53144284
Csub_85_135 sn_85 sn_135 8.784012026450177e-19
Rsub_85_109 sn_85 sn_109 141382.6184757763
Csub_85_109 sn_85 sn_109 7.452460292376931e-17
Rsub_85_211 sn_85 sn_211 5395974.412725988
Csub_85_211 sn_85 sn_211 1.952656313080455e-18
Rsub_85_119 sn_85 sn_119 343467.1778199456
Csub_85_119 sn_85 sn_119 3.067682789693954e-17
Rsub_85_226 sn_85 sn_226 35564691.74056818
Csub_85_226 sn_85 sn_226 2.962624723163612e-19
Rsub_85_162 sn_85 sn_162 2165510.267359561
Csub_85_162 sn_85 sn_162 4.865589261360231e-18
Rsub_85_106 sn_85 sn_106 1467135.152142704
Csub_85_106 sn_85 sn_106 7.181672040808102e-18
Rsub_85_167 sn_85 sn_167 129540.4642652792
Csub_85_167 sn_85 sn_167 8.133739184887346e-17
Rsub_85_129 sn_85 sn_129 26990190.19459879
Csub_85_129 sn_85 sn_129 3.903819656794614e-19
Rsub_85_163 sn_85 sn_163 4388634.669234196
Csub_85_163 sn_85 sn_163 2.400856825949604e-18
Rsub_85_205 sn_85 sn_205 436525.0666898611
Csub_85_205 sn_85 sn_205 2.413717860952961e-17
Rsub_85_126 sn_85 sn_126 3776174.127474567
Csub_85_126 sn_85 sn_126 2.790253612927697e-18
Rsub_85_195 sn_85 sn_195 8524125.175223166
Csub_85_195 sn_85 sn_195 1.236077988725001e-18
Rsub_85_150 sn_85 sn_150 32639621.06605214
Csub_85_150 sn_85 sn_150 3.228126785206095e-19
Rsub_85_229 sn_85 sn_229 94451.53925419909
Csub_85_229 sn_85 sn_229 1.115543863596863e-16
Rsub_85_114 sn_85 sn_114 7655375.653668929
Csub_85_114 sn_85 sn_114 1.376350943298291e-18
Rsub_85_171 sn_85 sn_171 316719.5172915233
Csub_85_171 sn_85 sn_171 3.326755355127589e-17
Rsub_85_92 sn_85 sn_92 1159514.805340477
Csub_85_92 sn_85 sn_92 9.086976253947958e-18
Rsub_85_122 sn_85 sn_122 75931.8773968725
Csub_85_122 sn_85 sn_122 1.387623204304439e-16
Rsub_85_202 sn_85 sn_202 2222.732899468102
Csub_85_202 sn_85 sn_202 4.740328226010138e-15
Rsub_85_230 sn_85 0 41190.63740577991
Csub_85_230 sn_85 0 2.557980202741779e-16
Rsub_85_115 sn_85 sn_115 116312.3975432682
Csub_85_115 sn_85 sn_115 9.058779394785009e-17
Rsub_85_194 sn_85 sn_194 12347.68890285512
Csub_85_194 sn_85 sn_194 8.533162428309709e-16
Rsub_85_143 sn_85 sn_143 4112769676.230715
Rsub_85_217 sn_85 sn_217 557038.0336101943
Csub_85_217 sn_85 sn_217 1.891519585106688e-17
Rsub_85_166 sn_85 sn_166 4499688.89300123
Csub_85_166 sn_85 sn_166 2.341602664712741e-18
Rsub_85_100 sn_85 sn_100 1821211.175343315
Csub_85_100 sn_85 sn_100 5.785426558369199e-18
Rsub_85_219 sn_85 sn_219 7721918.470971342
Csub_85_219 sn_85 sn_219 1.364490384331216e-18
Rsub_85_140 sn_85 sn_140 17793828.83100066
Csub_85_140 sn_85 sn_140 5.921425682073097e-19
Rsub_85_175 sn_85 sn_175 504995.9084882929
Csub_85_175 sn_85 sn_175 2.086449281098336e-17
Rsub_85_225 sn_85 sn_225 3979.688453384092
Csub_85_225 sn_85 sn_225 2.647564910079934e-15
Rsub_85_146 sn_85 sn_146 24312745.4521058
Csub_85_146 sn_85 sn_146 4.333728382500466e-19
Rsub_85_139 sn_85 sn_139 601462.1170120251
Csub_85_139 sn_85 sn_139 1.751811660986014e-17
Rsub_85_218 sn_85 sn_218 3861738.498801377
Csub_85_218 sn_85 sn_218 2.728430085439592e-18
Rsub_85_107 sn_85 sn_107 31092030.02636501
Csub_85_107 sn_85 sn_107 3.388805264016345e-19
Rsub_85_102 sn_85 sn_102 20396011.95323865
Csub_85_102 sn_85 sn_102 5.165952798216971e-19
Rsub_85_204 sn_85 sn_204 1590727.241286698
Csub_85_204 sn_85 sn_204 6.623689611116051e-18
Rsub_85_110 sn_85 sn_110 34557224.0439944
Csub_85_110 sn_85 sn_110 3.048995917269317e-19
Rsub_85_172 sn_85 sn_172 1356863.875531722
Csub_85_172 sn_85 sn_172 7.765320967146398e-18
Rsub_85_120 sn_85 sn_120 51160050.66942368
Csub_85_120 sn_85 sn_120 2.059513891085185e-19
Rsub_85_199 sn_85 sn_199 52181972.9578455
Csub_85_199 sn_85 sn_199 2.019180744802761e-19
Rsub_85_215 sn_85 sn_215 3520973.115761178
Csub_85_215 sn_85 sn_215 2.992491892387592e-18
Rsub_85_192 sn_85 sn_192 10712394.23329314
Csub_85_192 sn_85 sn_192 9.835787661252774e-19
Rsub_85_113 sn_85 sn_113 852903.4723642644
Csub_85_113 sn_85 sn_113 1.235366468027463e-17
Rsub_85_160 sn_85 sn_160 6665584.249214854
Csub_85_160 sn_85 sn_160 1.580729176661611e-18
Rsub_85_200 sn_85 sn_200 26438756.57719955
Csub_85_200 sn_85 sn_200 3.985241692991165e-19
Rsub_159_193 sn_159 sn_193 14544376.04265218
Csub_159_193 sn_159 sn_193 7.244369556542804e-19
Rsub_159_202 sn_159 sn_202 67890.49260612013
Csub_159_202 sn_159 sn_202 1.551982184509907e-16
Rsub_159_227 sn_159 sn_227 4081162.700682013
Csub_159_227 sn_159 sn_227 2.581735714792557e-18
Rsub_159_196 sn_159 sn_196 12940834.58285401
Csub_159_196 sn_159 sn_196 8.142043262179041e-19
Rsub_159_187 sn_159 sn_187 2601374.163524288
Csub_159_187 sn_159 sn_187 4.050352944212913e-18
Rsub_159_220 sn_159 sn_220 1535458.380929846
Csub_159_220 sn_159 sn_220 6.86210947368648e-18
Rsub_159_216 sn_159 sn_216 1641498.482275894
Csub_159_216 sn_159 sn_216 6.418820130507491e-18
Rsub_159_208 sn_159 sn_208 8561833.025384631
Csub_159_208 sn_159 sn_208 1.230634079290125e-18
Rsub_159_163 sn_159 sn_163 5436339.230527926
Csub_159_163 sn_159 sn_163 1.938157840309534e-18
Rsub_159_230 sn_159 0 10823.61146358788
Csub_159_230 sn_159 0 9.734720742403017e-16
Rsub_159_179 sn_159 sn_179 25600134.51012197
Csub_159_179 sn_159 sn_179 4.115792242444668e-19
Rsub_159_213 sn_159 sn_213 5821832.340390299
Csub_159_213 sn_159 sn_213 1.809822558635144e-18
Rsub_159_176 sn_159 sn_176 4981597.034826862
Csub_159_176 sn_159 sn_176 2.115081454515159e-18
Rsub_159_198 sn_159 sn_198 4017223.988001983
Csub_159_198 sn_159 sn_198 2.622826990404002e-18
Rsub_159_183 sn_159 sn_183 5483.548708201127
Csub_159_183 sn_159 sn_183 1.921471671523911e-15
Rsub_159_228 sn_159 sn_228 4507409.682284676
Csub_159_228 sn_159 sn_228 2.337591708967835e-18
Rsub_159_185 sn_159 sn_185 5157.23285998445
Csub_159_185 sn_159 sn_185 2.043049788188499e-15
Rsub_159_222 sn_159 sn_222 128728.9959071778
Csub_159_222 sn_159 sn_222 8.185011797829538e-17
Rsub_159_165 sn_159 sn_165 656.5554733014377
Csub_159_165 sn_159 sn_165 1.604812377733769e-14
Rsub_159_189 sn_159 sn_189 1510.439819529355
Csub_159_189 sn_159 sn_189 6.975771802356953e-15
Rsub_159_226 sn_159 sn_226 3571263.531854505
Csub_159_226 sn_159 sn_226 2.95035171956592e-18
Rsub_159_169 sn_159 sn_169 3788.0485914086
Csub_159_169 sn_159 sn_169 2.781506954828151e-15
Rsub_159_177 sn_159 sn_177 6733.004820757432
Csub_159_177 sn_159 sn_177 1.564900632440762e-15
Rsub_159_181 sn_159 sn_181 171679.0921516599
Csub_159_181 sn_159 sn_181 6.137313152216673e-17
Rsub_159_192 sn_159 sn_192 3988037.578863024
Csub_159_192 sn_159 sn_192 2.642022120873273e-18
Rsub_159_215 sn_159 sn_215 569202.2722090277
Csub_159_215 sn_159 sn_215 1.851096528715314e-17
Rsub_159_219 sn_159 sn_219 469628.9859418028
Csub_159_219 sn_159 sn_219 2.243576060600249e-17
Rsub_159_195 sn_159 sn_195 782916.106676099
Csub_159_195 sn_159 sn_195 1.345799813336713e-17
Rsub_159_207 sn_159 sn_207 5680245.769216728
Csub_159_207 sn_159 sn_207 1.854934439515091e-18
Rsub_159_170 sn_159 sn_170 7323942.402666052
Csub_159_170 sn_159 sn_170 1.438635494784138e-18
Rsub_159_175 sn_159 sn_175 111722.0863243861
Csub_159_175 sn_159 sn_175 9.430976317106381e-17
Rsub_159_188 sn_159 sn_188 30373587.69977944
Csub_159_188 sn_159 sn_188 3.468962444073248e-19
Rsub_159_190 sn_159 sn_190 3048577.330564287
Csub_159_190 sn_159 sn_190 3.456196894398514e-18
Rsub_159_186 sn_159 sn_186 6295048.607648149
Csub_159_186 sn_159 sn_186 1.673773176179884e-18
Rsub_159_221 sn_159 sn_221 4166779.350045873
Csub_159_221 sn_159 sn_221 2.528687654678428e-18
Rsub_159_171 sn_159 sn_171 6621010.085267274
Csub_159_171 sn_159 sn_171 1.591371009338173e-18
Rsub_136_225 sn_136 sn_225 1215150.600321254
Csub_136_225 sn_136 sn_225 8.670928113309111e-18
Rsub_136_154 sn_136 sn_154 591996.4463103544
Csub_136_154 sn_136 sn_154 1.779822086416081e-17
Rsub_136_160 sn_136 sn_160 19960553.77425524
Csub_136_160 sn_136 sn_160 5.278652897806757e-19
Rsub_136_153 sn_136 sn_153 825679.2540644417
Csub_136_153 sn_136 sn_153 1.276098854411529e-17
Rsub_136_219 sn_136 sn_219 134682181.2358873
Csub_136_219 sn_136 sn_219 7.823220121283914e-20
Rsub_136_140 sn_136 sn_140 9927348.005996129
Csub_136_140 sn_136 sn_140 1.061359337445001e-18
Rsub_136_180 sn_136 sn_180 9695355.409068236
Csub_136_180 sn_136 sn_180 1.086755777139953e-18
Rsub_136_222 sn_136 sn_222 4628045.935663657
Csub_136_222 sn_136 sn_222 2.276659231282906e-18
Rsub_136_198 sn_136 sn_198 8082642.621340661
Csub_136_198 sn_136 sn_198 1.303593885793051e-18
Rsub_136_176 sn_136 sn_176 4464995.255551136
Csub_136_176 sn_136 sn_176 2.359797244830315e-18
Rsub_136_209 sn_136 sn_209 226132.0397380311
Csub_136_209 sn_136 sn_209 4.659438580413586e-17
Rsub_136_177 sn_136 sn_177 34645.4588541745
Csub_136_177 sn_136 sn_177 3.04123075597841e-16
Rsub_136_159 sn_136 sn_159 40937.52580829195
Csub_136_159 sn_136 sn_159 2.573795874125794e-16
Rsub_136_196 sn_136 sn_196 11748247.86639491
Csub_136_196 sn_136 sn_196 8.968557373026588e-19
Rsub_136_157 sn_136 sn_157 53689.52439528309
Csub_136_157 sn_136 sn_157 1.962484045240618e-16
Rsub_136_226 sn_136 sn_226 4087320.1485575
Csub_136_226 sn_136 sn_226 2.577846393057453e-18
Rsub_136_152 sn_136 sn_152 1730.103517392475
Csub_136_152 sn_136 sn_152 6.090088481011854e-15
Rsub_136_189 sn_136 sn_189 3685.81018627785
Csub_136_189 sn_136 sn_189 2.858661452903077e-15
Rsub_136_195 sn_136 sn_195 348394.2964839164
Csub_136_195 sn_136 sn_195 3.024298505620461e-17
Rsub_136_158 sn_136 sn_158 7910082.683362056
Csub_136_158 sn_136 sn_158 1.332032031016853e-18
Rsub_136_161 sn_136 sn_161 2129.641044752192
Csub_136_161 sn_136 sn_161 4.94753964673706e-15
Rsub_136_193 sn_136 sn_193 11324697.50351305
Csub_136_193 sn_136 sn_193 9.303986706012648e-19
Rsub_136_145 sn_136 sn_145 9675.458627278231
Csub_136_145 sn_136 sn_145 1.088990600665096e-15
Rsub_136_168 sn_136 sn_168 2263603.576724839
Csub_136_168 sn_136 sn_168 4.654738846752938e-18
Rsub_136_230 sn_136 0 24120.15087288174
Csub_136_230 sn_136 0 4.368332336625705e-16
Rsub_136_151 sn_136 sn_151 14855.35644481325
Csub_136_151 sn_136 sn_151 7.092716718964231e-16
Rsub_136_188 sn_136 sn_188 40817088.69775917
Csub_136_188 sn_136 sn_188 2.58139025550062e-19
Rsub_136_183 sn_136 sn_183 453542.7219580688
Csub_136_183 sn_136 sn_183 2.323151269353657e-17
Rsub_136_149 sn_136 sn_149 3322.73946821821
Csub_136_149 sn_136 sn_149 3.171023067866376e-15
Rsub_136_173 sn_136 sn_173 25930000.97846573
Csub_136_173 sn_136 sn_173 4.063433515093311e-19
Rsub_136_220 sn_136 sn_220 312618.3838208774
Csub_136_220 sn_136 sn_220 3.370397918846368e-17
Rsub_136_141 sn_136 sn_141 119887.9235880331
Csub_136_141 sn_136 sn_141 8.788611218621294e-17
Rsub_136_215 sn_136 sn_215 1434000.351153702
Csub_136_215 sn_136 sn_215 7.347615705779319e-18
Rsub_136_138 sn_136 sn_138 8005977.997987755
Csub_136_138 sn_136 sn_138 1.316076999571854e-18
Rsub_136_217 sn_136 sn_217 591996.4463103543
Csub_136_217 sn_136 sn_217 1.779822086416081e-17
Rsub_136_165 sn_136 sn_165 123063.8597047139
Csub_136_165 sn_136 sn_165 8.561801594320062e-17
Rsub_136_167 sn_136 sn_167 153570.8700315465
Csub_136_167 sn_136 sn_167 6.860990954902842e-17
Rsub_136_139 sn_136 sn_139 315407.9427063363
Csub_136_139 sn_136 sn_139 3.34058914681172e-17
Rsub_136_192 sn_136 sn_192 38168263.83034294
Csub_136_192 sn_136 sn_192 2.760535178928869e-19
Rsub_136_190 sn_136 sn_190 3799836.702658715
Csub_136_190 sn_136 sn_190 2.7728779752187e-18
Rsub_136_216 sn_136 sn_216 581995.2283520461
Csub_136_216 sn_136 sn_216 1.810407197334706e-17
Rsub_136_144 sn_136 sn_144 74577550.6878971
Csub_136_144 sn_136 sn_144 1.412822411710006e-19
Rsub_209_211 sn_209 sn_211 35258034.88125023
Csub_209_211 sn_209 sn_211 2.988392160174862e-19
Rsub_209_229 sn_209 sn_229 55797.06958188142
Csub_209_229 sn_209 sn_229 1.888357862014215e-16
Rsub_209_217 sn_209 sn_217 7588.468539116067
Csub_209_217 sn_209 sn_217 1.388486154738322e-15
Rsub_209_227 sn_209 sn_227 2285451.112381927
Csub_209_227 sn_209 sn_227 4.610242347843853e-18
Rsub_209_210 sn_209 sn_210 14940932.07707934
Csub_209_210 sn_209 sn_210 7.052092498562299e-19
Rsub_209_220 sn_209 sn_220 824.5975510017248
Csub_209_220 sn_209 sn_220 1.277772834691327e-14
Rsub_209_230 sn_209 0 10195.98779706276
Csub_209_230 sn_209 0 1.033395067936951e-15
Rsub_209_216 sn_209 sn_216 9858997.938566513
Csub_209_216 sn_209 sn_216 1.068717487100113e-18
Rsub_209_225 sn_209 sn_225 1029872.543912209
Csub_209_225 sn_209 sn_225 1.023086163866913e-17
Rsub_209_215 sn_209 sn_215 5273550.592303508
Csub_209_215 sn_209 sn_215 1.997986616001654e-18
Rsub_209_223 sn_209 sn_223 446845.525251165
Csub_209_223 sn_209 sn_223 2.357970015769456e-17
Rsub_209_218 sn_209 sn_218 4824435.115978696
Csub_209_218 sn_209 sn_218 2.183982839220451e-18
Rsub_209_228 sn_209 sn_228 28822073.59499561
Csub_209_228 sn_209 sn_228 3.655699326248149e-19
Rsub_42_72 sn_42 sn_72 79678996.48689246
Csub_42_72 sn_42 sn_72 1.322366491395671e-19
Rsub_42_66 sn_42 sn_66 69971777.31071228
Csub_42_66 sn_42 sn_66 1.505819046934074e-19
Rsub_42_195 sn_42 sn_195 80810739.30287921
Csub_42_195 sn_42 sn_195 1.303846938305958e-19
Rsub_42_80 sn_42 sn_80 37119749.42687864
Csub_42_80 sn_42 sn_80 2.838511483754917e-19
Rsub_42_217 sn_42 sn_217 77693339.37163776
Csub_42_217 sn_42 sn_217 1.356163036297083e-19
Rsub_42_89 sn_42 sn_89 76829676.60824148
Csub_42_89 sn_42 sn_89 1.371408024526262e-19
Rsub_42_168 sn_42 sn_168 1769481.45490159
Csub_42_168 sn_42 sn_168 5.954560005725511e-18
Rsub_42_128 sn_42 sn_128 36546798.01084626
Csub_42_128 sn_42 sn_128 2.883011392435258e-19
Rsub_42_162 sn_42 sn_162 20862586.70698882
Csub_42_162 sn_42 sn_162 5.050420472884291e-19
Rsub_42_203 sn_42 sn_203 11189311.75842709
Csub_42_203 sn_42 sn_203 9.416560848163499e-19
Rsub_42_158 sn_42 sn_158 1825257.061197007
Csub_42_158 sn_42 sn_158 5.772602515132942e-18
Rsub_42_140 sn_42 sn_140 43200994.23955395
Csub_42_140 sn_42 sn_140 2.438944678866444e-19
Rsub_42_199 sn_42 sn_199 78949965.70051029
Csub_42_199 sn_42 sn_199 1.33457733752529e-19
Rsub_42_142 sn_42 sn_142 95247779.99539796
Csub_42_142 sn_42 sn_142 1.106218276451072e-19
Rsub_42_175 sn_42 sn_175 39934758.02488374
Csub_42_175 sn_42 sn_175 2.638424275831248e-19
Rsub_42_182 sn_42 sn_182 34466377.09960289
Csub_42_182 sn_42 sn_182 3.057032502076176e-19
Rsub_42_170 sn_42 sn_170 16965942.80841649
Csub_42_170 sn_42 sn_170 6.210373111126514e-19
Rsub_42_156 sn_42 sn_156 30727682.06479037
Csub_42_156 sn_42 sn_156 3.428987412722334e-19
Rsub_42_228 sn_42 sn_228 78949965.70051029
Csub_42_228 sn_42 sn_228 1.33457733752529e-19
Rsub_42_174 sn_42 sn_174 76847533.1887428
Csub_42_174 sn_42 sn_174 1.371089359023624e-19
Rsub_42_214 sn_42 sn_214 5506332.791526661
Csub_42_214 sn_42 sn_214 1.913521013194828e-18
Rsub_42_56 sn_42 sn_56 1347946.048837659
Csub_42_56 sn_42 sn_56 7.816695268564844e-18
Rsub_42_135 sn_42 sn_135 12263621.8744526
Csub_42_135 sn_42 sn_135 8.591657187489981e-19
Rsub_42_196 sn_42 sn_196 4916400.609157004
Csub_42_196 sn_42 sn_196 2.143129565683756e-18
Rsub_42_208 sn_42 sn_208 1544524.446259449
Csub_42_208 sn_42 sn_208 6.821830193589619e-18
Rsub_42_137 sn_42 sn_137 25457405.36764926
Csub_42_137 sn_42 sn_137 4.138867787217445e-19
Rsub_42_230 sn_42 0 524244.2472308456
Csub_42_230 sn_42 0 2.009842465203127e-17
Rsub_42_151 sn_42 sn_151 78949965.70051029
Csub_42_151 sn_42 sn_151 1.33457733752529e-19
Rsub_42_205 sn_42 sn_205 45756359.73461984
Csub_42_205 sn_42 sn_205 2.302736398467897e-19
Rsub_42_126 sn_42 sn_126 9586091.10590189
Csub_42_126 sn_42 sn_126 1.099142850389037e-18
Rsub_42_131 sn_42 sn_131 12771215.54626089
Csub_42_131 sn_42 sn_131 8.250180622246902e-19
Rsub_42_219 sn_42 sn_219 24196713.45508945
Csub_42_219 sn_42 sn_219 4.354510178329114e-19
Rsub_42_52 sn_42 sn_52 11714.4621738925
Csub_42_52 sn_42 sn_52 8.994423598645603e-16
Rsub_42_222 sn_42 sn_222 2336013.271682915
Csub_42_222 sn_42 sn_222 4.510455325726506e-18
Rsub_42_166 sn_42 sn_166 1886181.685319942
Csub_42_166 sn_42 sn_166 5.586144529042419e-18
Rsub_42_146 sn_42 sn_146 14477400.53623573
Csub_42_146 sn_42 sn_146 7.277883537074252e-19
Rsub_42_152 sn_42 sn_152 321735.4714503313
Csub_42_152 sn_42 sn_152 3.274890224174922e-17
Rsub_42_186 sn_42 sn_186 316816.8150822802
Csub_42_186 sn_42 sn_186 3.325733673414266e-17
Rsub_42_107 sn_42 sn_107 13664447.87744634
Csub_42_107 sn_42 sn_107 7.710873938507857e-19
Rsub_42_84 sn_42 sn_84 1472460.31355865
Csub_42_84 sn_42 sn_84 7.155699481478973e-18
Rsub_42_59 sn_42 sn_59 1013644.602898787
Csub_42_59 sn_42 sn_59 1.039465259529634e-17
Rsub_42_138 sn_42 sn_138 4181479.371490232
Csub_42_138 sn_42 sn_138 2.519798034654639e-18
Rsub_42_93 sn_42 sn_93 31637.0017229183
Csub_42_93 sn_42 sn_93 3.330430485957594e-16
Rsub_42_45 sn_42 sn_45 2601103.155606985
Csub_42_45 sn_42 sn_45 4.050774948897112e-18
Rsub_42_212 sn_42 sn_212 2887232.687884126
Csub_42_212 sn_42 sn_212 3.649336455092415e-18
Rsub_42_150 sn_42 sn_150 3568742.480653953
Csub_42_150 sn_42 sn_150 2.952435923675627e-18
Rsub_42_184 sn_42 sn_184 16758044.61137624
Csub_42_184 sn_42 sn_184 6.287418220069235e-19
Rsub_42_148 sn_42 sn_148 113654173.2899243
Csub_42_148 sn_42 sn_148 9.270652539394334e-20
Rsub_42_209 sn_42 sn_209 17710179.79694064
Csub_42_209 sn_42 sn_209 5.949393864454235e-19
Rsub_42_116 sn_42 sn_116 11707147.07535165
Csub_42_116 sn_42 sn_116 9.000043677945776e-19
Rsub_42_144 sn_42 sn_144 18152576.63610581
Csub_42_144 sn_42 sn_144 5.804401057463514e-19
Rsub_42_70 sn_42 sn_70 200752950.9859437
Csub_42_70 sn_42 sn_70 5.248482500746771e-20
Rsub_42_90 sn_42 sn_90 168632478.8281927
Csub_42_90 sn_42 sn_90 6.248193453269967e-20
Rsub_42_86 sn_42 sn_86 15037546.77848439
Csub_42_86 sn_42 sn_86 7.006783524893518e-19
Rsub_42_160 sn_42 sn_160 260567.7298791518
Csub_42_160 sn_42 sn_160 4.043664005176964e-17
Rsub_42_81 sn_42 sn_81 53673193.607794
Csub_42_81 sn_42 sn_81 1.963081157276241e-19
Rsub_42_123 sn_42 sn_123 176196489.6956174
Csub_42_123 sn_42 sn_123 5.979962211751191e-20
Rsub_42_79 sn_42 sn_79 33194682.91406269
Csub_42_79 sn_42 sn_79 3.174147959029395e-19
Rsub_42_155 sn_42 sn_155 6107510.694705227
Csub_42_155 sn_42 sn_155 1.725168244300313e-18
Rsub_42_224 sn_42 sn_224 2692342.731286073
Csub_42_224 sn_42 sn_224 3.913500082954504e-18
Rsub_42_57 sn_42 sn_57 13486343.82473727
Csub_42_57 sn_42 sn_57 7.812705681508357e-19
Rsub_42_51 sn_42 sn_51 3753207.240876343
Csub_42_51 sn_42 sn_51 2.807327926759999e-18
Rsub_42_218 sn_42 sn_218 1094530.611368332
Csub_42_218 sn_42 sn_218 9.626485904362032e-18
Rsub_42_139 sn_42 sn_139 12974945.70935027
Csub_42_139 sn_42 sn_139 8.120637834065837e-19
Rsub_42_177 sn_42 sn_177 49740262.62251074
Csub_42_177 sn_42 sn_177 2.118300738014509e-19
Rsub_42_125 sn_42 sn_125 28645065.84361063
Csub_42_125 sn_42 sn_125 3.678289154493319e-19
Rsub_42_83 sn_42 sn_83 76847533.1887428
Csub_42_83 sn_42 sn_83 1.371089359023624e-19
Rsub_42_215 sn_42 sn_215 15603158.72172765
Csub_42_215 sn_42 sn_215 6.752788771902821e-19
Rsub_42_48 sn_42 sn_48 13772613.28305443
Csub_42_48 sn_42 sn_48 7.650315365489785e-19
Rsub_42_197 sn_42 sn_197 8036645.619714894
Csub_42_197 sn_42 sn_197 1.311054885434129e-18
Rsub_42_210 sn_42 sn_210 12471610.41248481
Csub_42_210 sn_42 sn_210 8.448374471096664e-19
Rsub_42_43 sn_42 sn_43 32779506.11357761
Csub_42_43 sn_42 sn_43 3.214350901359578e-19
Rsub_42_46 sn_42 sn_46 76847533.1887428
Csub_42_46 sn_42 sn_46 1.371089359023624e-19
Rsub_42_213 sn_42 sn_213 17039741.4787691
Csub_42_213 sn_42 sn_213 6.183476149188108e-19
Rsub_42_190 sn_42 sn_190 735120.6710053046
Csub_42_190 sn_42 sn_190 1.433299853726188e-17
Rsub_42_216 sn_42 sn_216 1571609.655886483
Csub_42_216 sn_42 sn_216 6.70426238650639e-18
Rsub_42_49 sn_42 sn_49 25501032.7045288
Csub_42_49 sn_42 sn_49 4.131786984594862e-19
Rsub_42_207 sn_42 sn_207 4314326.678852231
Csub_42_207 sn_42 sn_207 2.442208086345722e-18
Rsub_42_132 sn_42 sn_132 6442954.857749717
Csub_42_132 sn_42 sn_132 1.635349577151934e-18
Rsub_42_44 sn_42 sn_44 5696395.520569067
Csub_42_44 sn_42 sn_44 1.849675547314772e-18
Rsub_42_171 sn_42 sn_171 2259781.247113765
Csub_42_171 sn_42 sn_171 4.662612151369694e-18
Rsub_42_221 sn_42 sn_221 4593577.942025783
Csub_42_221 sn_42 sn_221 2.293742184242416e-18
Rsub_42_141 sn_42 sn_141 7909662.050690351
Csub_42_141 sn_42 sn_141 1.332102867948749e-18
Rsub_42_229 sn_42 sn_229 4028008168.352818
Rsub_42_62 sn_42 sn_62 74551773.54945646
Csub_42_62 sn_42 sn_62 1.413310911408468e-19
Rsub_42_192 sn_42 sn_192 35946175.88563373
Csub_42_192 sn_42 sn_192 2.931183427064079e-19
Rsub_42_74 sn_42 sn_74 38777590.7216336
Csub_42_74 sn_42 sn_74 2.717157849714426e-19
Rsub_42_164 sn_42 sn_164 13268979.70952626
Csub_42_164 sn_42 sn_164 7.940688532868503e-19
Rsub_42_181 sn_42 sn_181 66576298.89725977
Csub_42_181 sn_42 sn_181 1.582617789926991e-19
Rsub_42_120 sn_42 sn_120 1619457.806379264
Csub_42_120 sn_42 sn_120 6.506179698369023e-18
Rsub_42_157 sn_42 sn_157 157899931.4010206
Csub_42_157 sn_42 sn_157 6.672886687626452e-20
Rsub_51_81 sn_51 sn_81 6409139.504263298
Csub_51_81 sn_51 sn_81 1.643977868670394e-18
Rsub_51_171 sn_51 sn_171 12319854.69496049
Csub_51_171 sn_51 sn_171 8.552441374604857e-19
Rsub_51_217 sn_51 sn_217 3201578.473018218
Csub_51_217 sn_51 sn_217 3.291027719928715e-18
Rsub_51_92 sn_51 sn_92 4750108.963110526
Csub_51_92 sn_51 sn_92 2.218156169480872e-18
Rsub_51_174 sn_51 sn_174 55066951.65605285
Csub_51_174 sn_51 sn_174 1.913395091858485e-19
Rsub_51_163 sn_51 sn_163 17209815.01698532
Csub_51_163 sn_51 sn_163 6.122368829549278e-19
Rsub_51_80 sn_51 sn_80 14760787.43893921
Csub_51_80 sn_51 sn_80 7.138158140828298e-19
Rsub_51_123 sn_51 sn_123 5727316.152745926
Csub_51_123 sn_51 sn_123 1.839689519702583e-18
Rsub_51_141 sn_51 sn_141 5863680.823049401
Csub_51_141 sn_51 sn_141 1.796906042500198e-18
Rsub_51_82 sn_51 sn_82 39122851.2965601
Csub_51_82 sn_51 sn_82 2.693178833608282e-19
Rsub_51_111 sn_51 sn_111 1190392.57217982
Csub_51_111 sn_51 sn_111 8.851267849341359e-18
Rsub_51_71 sn_51 sn_71 4824585.856708581
Csub_51_71 sn_51 sn_71 2.183914602240736e-18
Rsub_51_160 sn_51 sn_160 5536405.614321061
Csub_51_160 sn_51 sn_160 1.9031270893475e-18
Rsub_51_112 sn_51 sn_112 4032874.238679808
Csub_51_112 sn_51 sn_112 2.612648666594473e-18
Rsub_51_195 sn_51 sn_195 345875.5260065173
Csub_51_195 sn_51 sn_195 3.046322364546679e-17
Rsub_51_116 sn_51 sn_116 12083149.97884024
Csub_51_116 sn_51 sn_116 8.719980734064605e-19
Rsub_51_129 sn_51 sn_129 1235720.466825005
Csub_51_129 sn_51 sn_129 8.526591397568971e-18
Rsub_51_78 sn_51 sn_78 1146893.992709363
Csub_51_78 sn_51 sn_78 9.186972439657791e-18
Rsub_51_177 sn_51 sn_177 2758827.185452608
Csub_51_177 sn_51 sn_177 3.819189385181227e-18
Rsub_51_214 sn_51 sn_214 836726.379886369
Csub_51_214 sn_51 sn_214 1.259250784427389e-17
Rsub_51_175 sn_51 sn_175 5754589.08680662
Csub_51_175 sn_51 sn_175 1.830970612026268e-18
Rsub_51_96 sn_51 sn_96 3058539.694898437
Csub_51_96 sn_51 sn_96 3.444939269483596e-18
Rsub_51_212 sn_51 sn_212 600795.0090070965
Csub_51_212 sn_51 sn_212 1.753756829578713e-17
Rsub_51_133 sn_51 sn_133 1604623.489953734
Csub_51_133 sn_51 sn_133 6.566327595349983e-18
Rsub_51_101 sn_51 sn_101 141060.848901576
Csub_51_101 sn_51 sn_101 7.469459870882912e-17
Rsub_51_213 sn_51 sn_213 6526735.477787791
Csub_51_213 sn_51 sn_213 1.614357367184321e-18
Rsub_51_76 sn_51 sn_76 673552.6347161887
Csub_51_76 sn_51 sn_76 1.564314792810469e-17
Rsub_51_155 sn_51 sn_155 1079990.890329767
Csub_51_155 sn_51 sn_155 9.756085534214796e-18
Rsub_51_188 sn_51 sn_188 763180.9009492927
Csub_51_188 sn_51 sn_188 1.380601046111617e-17
Rsub_51_114 sn_51 sn_114 292335.294705459
Csub_51_114 sn_51 sn_114 3.604246115011868e-17
Rsub_51_170 sn_51 sn_170 381610.9839498
Csub_51_170 sn_51 sn_170 2.761053519260349e-17
Rsub_51_72 sn_51 sn_72 167516.3866745343
Csub_51_72 sn_51 sn_72 6.289822572821618e-17
Rsub_51_97 sn_51 sn_97 205584.68122195
Csub_51_97 sn_51 sn_97 5.125130646701626e-17
Rsub_51_139 sn_51 sn_139 5700043.218685231
Csub_51_139 sn_51 sn_139 1.848491861902117e-18
Rsub_51_198 sn_51 sn_198 458289.8235426696
Csub_51_198 sn_51 sn_198 2.299087381164376e-17
Rsub_51_93 sn_51 sn_93 5700043.218685231
Csub_51_93 sn_51 sn_93 1.848491861902117e-18
Rsub_51_204 sn_51 sn_204 19565.17432550283
Csub_51_204 sn_51 sn_204 5.38532564388956e-16
Rsub_51_218 sn_51 sn_218 1913231.297493519
Csub_51_218 sn_51 sn_218 5.507166601358449e-18
Rsub_51_182 sn_51 sn_182 2364506.335648496
Csub_51_182 sn_51 sn_182 4.456102884300471e-18
Rsub_51_199 sn_51 sn_199 2066593.954814233
Csub_51_199 sn_51 sn_199 5.098477849354364e-18
Rsub_51_153 sn_51 sn_153 1136316.718586087
Csub_51_153 sn_51 sn_153 9.27248832116146e-18
Rsub_51_60 sn_51 sn_60 1022113.20414944
Csub_51_60 sn_51 sn_60 1.030852889822319e-17
Rsub_51_148 sn_51 sn_148 4604343.973118698
Csub_51_148 sn_51 sn_148 2.288378879541712e-18
Rsub_51_206 sn_51 sn_206 166009.725811675
Csub_51_206 sn_51 sn_206 6.346907357815178e-17
Rsub_51_126 sn_51 sn_126 9099215.559659161
Csub_51_126 sn_51 sn_126 1.15795514823749e-18
Rsub_51_219 sn_51 sn_219 552850.2436664228
Csub_51_219 sn_51 sn_219 1.905847672663318e-17
Rsub_51_52 sn_51 sn_52 131212.4462329303
Csub_51_52 sn_51 sn_52 8.030094556369657e-17
Rsub_51_210 sn_51 sn_210 12679205.10636279
Csub_51_210 sn_51 sn_210 8.310050522759107e-19
Rsub_51_131 sn_51 sn_131 822781.3483785471
Csub_51_131 sn_51 sn_131 1.280593382797777e-17
Rsub_51_110 sn_51 sn_110 811784.4222321449
Csub_51_110 sn_51 sn_110 1.29794108062065e-17
Rsub_51_178 sn_51 sn_178 689916.961081133
Csub_51_178 sn_51 sn_178 1.527210388583407e-17
Rsub_51_99 sn_51 sn_99 658370.7331654065
Csub_51_99 sn_51 sn_99 1.600387588854569e-17
Rsub_51_211 sn_51 sn_211 5227332.357150215
Csub_51_211 sn_51 sn_211 2.015652111314035e-18
Rsub_51_162 sn_51 sn_162 4292001.310797925
Csub_51_162 sn_51 sn_162 2.454911529435476e-18
Rsub_51_226 sn_51 sn_226 3210026.572450458
Csub_51_226 sn_51 sn_226 3.282366442900409e-18
Rsub_51_105 sn_51 sn_105 1381591.640028798
Csub_51_105 sn_51 sn_105 7.626337042695465e-18
Rsub_51_53 sn_51 sn_53 7798764.014121464
Csub_51_53 sn_51 sn_53 1.351045304506107e-18
Rsub_51_220 sn_51 sn_220 8034070.154541358
Csub_51_220 sn_51 sn_220 1.311475167574199e-18
Rsub_51_138 sn_51 sn_138 1827235.015295667
Csub_51_138 sn_51 sn_138 5.766353760753144e-18
Rsub_51_55 sn_51 sn_55 97126317.76019466
Csub_51_55 sn_51 sn_55 1.084822707707774e-19
Rsub_51_222 sn_51 sn_222 341170.3579353458
Csub_51_222 sn_51 sn_222 3.088334979039047e-17
Rsub_51_64 sn_51 sn_64 2676238.49896942
Csub_51_64 sn_51 sn_64 3.93704952166537e-18
Rsub_51_179 sn_51 sn_179 3290160.923999352
Csub_51_179 sn_51 sn_179 3.202421931819186e-18
Rsub_51_167 sn_51 sn_167 5279880.91266569
Csub_51_167 sn_51 sn_167 1.99559112724578e-18
Rsub_51_201 sn_51 sn_201 2177574.611798026
Csub_51_201 sn_51 sn_201 4.838632598462385e-18
Rsub_51_158 sn_51 sn_158 5768225.553836969
Csub_51_158 sn_51 sn_158 1.826642076300438e-18
Rsub_51_67 sn_51 sn_67 4256814.462736802
Csub_51_67 sn_51 sn_67 2.475203839505812e-18
Rsub_51_159 sn_51 sn_159 7581875.668873178
Csub_51_159 sn_51 sn_159 1.389693522077491e-18
Rsub_51_95 sn_51 sn_95 45016570.39919516
Csub_51_95 sn_51 sn_95 2.340578904344605e-19
Rsub_51_77 sn_51 sn_77 5290949.207774809
Csub_51_77 sn_51 sn_77 1.991416490399704e-18
Rsub_51_150 sn_51 sn_150 2792008.107930948
Csub_51_150 sn_51 sn_150 3.773801183563966e-18
Rsub_51_181 sn_51 sn_181 2818274.9517788
Csub_51_181 sn_51 sn_181 3.738628658491865e-18
Rsub_51_61 sn_51 sn_61 666382.9055856545
Csub_51_61 sn_51 sn_61 1.581145526680333e-17
Rsub_51_228 sn_51 sn_228 38282851.9132921
Csub_51_228 sn_51 sn_228 2.752272355804206e-19
Rsub_51_145 sn_51 sn_145 9030417.5243825
Csub_51_145 sn_51 sn_145 1.166777003807527e-18
Rsub_51_84 sn_51 sn_84 6122773.696626001
Csub_51_84 sn_51 sn_84 1.720867702171682e-18
Rsub_51_230 sn_51 0 77608.31912062196
Csub_51_230 sn_51 0 1.357648718799562e-16
Rsub_51_63 sn_51 sn_63 211892284.3894711
Csub_51_63 sn_51 sn_63 4.972565911302035e-20
Rsub_51_216 sn_51 sn_216 1159161.185914181
Csub_51_216 sn_51 sn_216 9.089748371724785e-18
Rsub_51_87 sn_51 sn_87 1662023.520328934
Csub_51_87 sn_51 sn_87 6.339551380202315e-18
Rsub_51_124 sn_51 sn_124 3411919.228984199
Csub_51_124 sn_51 sn_124 3.088139781482147e-18
Rsub_51_118 sn_51 sn_118 7069045.652072069
Csub_51_118 sn_51 sn_118 1.490510037821239e-18
Rsub_130_209 sn_130 sn_209 63710.07611416641
Csub_130_209 sn_130 sn_209 1.653817440642978e-16
Rsub_130_173 sn_130 sn_173 11504142.27888065
Csub_130_173 sn_130 sn_173 9.158860562401875e-19
Rsub_130_167 sn_130 sn_167 31257042.29998224
Csub_130_167 sn_130 sn_167 3.370915072868551e-19
Rsub_130_175 sn_130 sn_175 2647226.283666254
Csub_130_175 sn_130 sn_175 3.980197524949618e-18
Rsub_130_218 sn_130 sn_218 1944570.617230718
Csub_130_218 sn_130 sn_218 5.418411349460329e-18
Rsub_130_193 sn_130 sn_193 796647.8489427482
Csub_130_193 sn_130 sn_193 1.322602391535136e-17
Rsub_130_227 sn_130 sn_227 1597598.916235242
Csub_130_227 sn_130 sn_227 6.595199455354746e-18
Rsub_130_170 sn_130 sn_170 1965083.035858812
Csub_130_170 sn_130 sn_170 5.361851540092899e-18
Rsub_130_159 sn_130 sn_159 241491.0936884296
Csub_130_159 sn_130 sn_159 4.363094034359756e-17
Rsub_130_168 sn_130 sn_168 2650640.348733119
Csub_130_168 sn_130 sn_168 3.975070970026523e-18
Rsub_130_203 sn_130 sn_203 5238232.24008824
Csub_130_203 sn_130 sn_203 2.01145787725756e-18
Rsub_130_179 sn_130 sn_179 23444333.70926959
Csub_130_179 sn_130 sn_179 4.494255896922337e-19
Rsub_130_211 sn_130 sn_211 23025936.92493234
Csub_130_211 sn_130 sn_211 4.575919553927537e-19
Rsub_130_228 sn_130 sn_228 4133566.762724122
Csub_130_228 sn_130 sn_228 2.549005279713009e-18
Rsub_130_149 sn_130 sn_149 7073.312863320008
Csub_130_149 sn_130 sn_149 1.489610838065557e-15
Rsub_130_208 sn_130 sn_208 9480136.882996865
Csub_130_208 sn_130 sn_208 1.111427359358888e-18
Rsub_130_222 sn_130 sn_222 361452.5933409366
Csub_130_222 sn_130 sn_222 2.915038845022635e-17
Rsub_130_143 sn_130 sn_143 27228863.52815697
Csub_130_143 sn_130 sn_143 3.869600907630381e-19
Rsub_130_206 sn_130 sn_206 1904206.878206899
Csub_130_206 sn_130 sn_206 5.533266171242751e-18
Rsub_130_172 sn_130 sn_172 702140.5824496645
Csub_130_172 sn_130 sn_172 1.500623061192357e-17
Rsub_130_199 sn_130 sn_199 3640847.179791762
Csub_130_199 sn_130 sn_199 2.893964778503182e-18
Rsub_130_195 sn_130 sn_195 69313.33235280654
Csub_130_195 sn_130 sn_195 1.520123639215475e-16
Rsub_130_161 sn_130 sn_161 22927.69479427327
Csub_130_161 sn_130 sn_161 4.595526762185326e-16
Rsub_130_198 sn_130 sn_198 1049806.56331641
Csub_130_198 sn_130 sn_198 1.003659518849314e-17
Rsub_130_153 sn_130 sn_153 3981271.841068971
Csub_130_153 sn_130 sn_153 2.64651194965902e-18
Rsub_130_163 sn_130 sn_163 2341156.587005274
Csub_130_163 sn_130 sn_163 4.500546251674649e-18
Rsub_130_200 sn_130 sn_200 103610.1794566027
Csub_130_200 sn_130 sn_200 1.016935165781006e-16
Rsub_130_189 sn_130 sn_189 38465.24671055577
Csub_130_189 sn_130 sn_189 2.739221609967873e-16
Rsub_130_152 sn_130 sn_152 1273.384751606856
Csub_130_152 sn_130 sn_152 8.274391136641338e-15
Rsub_130_183 sn_130 sn_183 14917.02298039137
Csub_130_183 sn_130 sn_183 7.063395636032974e-16
Rsub_130_220 sn_130 sn_220 6057.72718817292
Csub_130_220 sn_130 sn_220 1.739345991480334e-15
Rsub_130_145 sn_130 sn_145 847.2852724322306
Csub_130_145 sn_130 sn_145 1.243557966254247e-14
Rsub_130_230 sn_130 0 8208.47103777598
Csub_130_230 sn_130 0 1.283610973802592e-15
Rsub_130_151 sn_130 sn_151 57014.56751420379
Csub_130_151 sn_130 sn_151 1.848033574858757e-16
Rsub_130_157 sn_130 sn_157 2353.186818235851
Csub_130_157 sn_130 sn_157 4.477538043549405e-15
Rsub_130_177 sn_130 sn_177 2463.589721231563
Csub_130_177 sn_130 sn_177 4.276882392967101e-15
Rsub_130_217 sn_130 sn_217 2953.877506411156
Csub_130_217 sn_130 sn_217 3.567000824970365e-15
Rsub_130_138 sn_130 sn_138 711302.6742276496
Csub_130_138 sn_130 sn_138 1.481293953192399e-17
Rsub_130_139 sn_130 sn_139 81557.43965531392
Csub_130_139 sn_130 sn_139 1.291909548259524e-16
Rsub_130_192 sn_130 sn_192 32276935.02355618
Csub_130_192 sn_130 sn_192 3.264400258122502e-19
Rsub_130_155 sn_130 sn_155 131537.1714149951
Csub_130_155 sn_130 sn_155 8.010270700582248e-17
Rsub_130_229 sn_130 sn_229 101089.8460190103
Csub_130_229 sn_130 sn_229 1.042289004995475e-16
Rsub_130_150 sn_130 sn_150 5282630.389244866
Csub_130_150 sn_130 sn_150 1.994552472132383e-18
Rsub_130_188 sn_130 sn_188 5335141.237019707
Csub_130_188 sn_130 sn_188 1.974921194048059e-18
Rsub_130_136 sn_130 sn_136 8351.524607219777
Csub_130_136 sn_130 sn_136 1.261623954639535e-15
Rsub_130_215 sn_130 sn_215 698235.9606389216
Csub_130_215 sn_130 sn_215 1.509014730863845e-17
Rsub_130_131 sn_130 sn_131 347080.8796381394
Csub_130_131 sn_130 sn_131 3.035742998351035e-17
Rsub_130_210 sn_130 sn_210 3845734.309550039
Csub_130_210 sn_130 sn_210 2.739784564956802e-18
Rsub_130_140 sn_130 sn_140 153460254.5926904
Csub_130_140 sn_130 sn_140 6.865936414738538e-20
Rsub_130_219 sn_130 sn_219 1086393.657583187
Csub_130_219 sn_130 sn_219 9.69858709012502e-18
Rsub_130_204 sn_130 sn_204 5805899.979914802
Csub_130_204 sn_130 sn_204 1.814789014395769e-18
Rsub_130_133 sn_130 sn_133 9143744.332274357
Csub_130_133 sn_130 sn_133 1.152316066519898e-18
Rsub_130_135 sn_130 sn_135 523798.5026628249
Csub_130_135 sn_130 sn_135 2.011552810606726e-17
Rsub_130_214 sn_130 sn_214 1953390.610916175
Csub_130_214 sn_130 sn_214 5.393946015378972e-18
Rsub_130_166 sn_130 sn_166 5219639.115881425
Csub_130_166 sn_130 sn_166 2.018622986821328e-18
Rsub_130_169 sn_130 sn_169 53879.88162534189
Csub_130_169 sn_130 sn_169 1.955550603376653e-16
Rsub_130_142 sn_130 sn_142 6219385.753282289
Csub_130_142 sn_130 sn_142 1.694135710535298e-18
Rsub_130_164 sn_130 sn_164 23541868.90620337
Csub_130_164 sn_130 sn_164 4.475635959154287e-19
Rsub_130_160 sn_130 sn_160 1323045.391418386
Csub_130_160 sn_130 sn_160 7.963811045767858e-18
Rsub_130_165 sn_130 sn_165 139992.1985026913
Csub_130_165 sn_130 sn_165 7.526479057350783e-17
Rsub_130_194 sn_130 sn_194 1658295.791265394
Csub_130_194 sn_130 sn_194 6.353802233430225e-18
Rsub_130_225 sn_130 sn_225 7300672.962877598
Csub_130_225 sn_130 sn_225 1.443220858653144e-18
Rsub_130_174 sn_130 sn_174 1205336481.707112
Rsub_130_144 sn_130 sn_144 23586403.02541251
Csub_130_144 sn_130 sn_144 4.467185391039813e-19
Rsub_130_223 sn_130 sn_223 520286.1728508808
Csub_130_223 sn_130 sn_223 2.025132331404445e-17
Rsub_130_156 sn_130 sn_156 332046.3840382533
Csub_130_156 sn_130 sn_156 3.173196278811501e-17
Rsub_130_213 sn_130 sn_213 3231853.956891204
Csub_130_213 sn_130 sn_213 3.260197905837705e-18
Rsub_130_216 sn_130 sn_216 872515.9292566555
Csub_130_216 sn_130 sn_216 1.207597838495237e-17
Rsub_130_147 sn_130 sn_147 1737654.747475346
Csub_130_147 sn_130 sn_147 6.06362312049534e-18
Rsub_130_176 sn_130 sn_176 4587445.167679333
Csub_130_176 sn_130 sn_176 2.296808597618645e-18
Rsub_130_207 sn_130 sn_207 3575936.411078893
Csub_130_207 sn_130 sn_207 2.94649632739164e-18
Rsub_130_205 sn_130 sn_205 642280.4271879412
Csub_130_205 sn_130 sn_205 1.640480241373892e-17
Rsub_130_197 sn_130 sn_197 28200155.53816773
Csub_130_197 sn_130 sn_197 3.736321059637175e-19
Rsub_130_178 sn_130 sn_178 16110428.23817345
Csub_130_178 sn_130 sn_178 6.540163517977717e-19
Rsub_130_181 sn_130 sn_181 43867.36963000693
Csub_130_181 sn_130 sn_181 2.401895438705003e-16
Rsub_130_196 sn_130 sn_196 4866900.331052527
Csub_130_196 sn_130 sn_196 2.164926911488931e-18
Rsub_139_225 sn_139 sn_225 2797425.634537801
Csub_139_225 sn_139 sn_225 3.766492796857091e-18
Rsub_139_196 sn_139 sn_196 4760386.47292679
Csub_139_196 sn_139 sn_196 2.213367246998317e-18
Rsub_139_173 sn_139 sn_173 5835119.041494253
Csub_139_173 sn_139 sn_173 1.805701550783071e-18
Rsub_139_203 sn_139 sn_203 1756640.78196221
Csub_139_203 sn_139 sn_203 5.998086581173697e-18
Rsub_139_178 sn_139 sn_178 28433116.16291238
Csub_139_178 sn_139 sn_178 3.70570831626735e-19
Rsub_139_175 sn_139 sn_175 274392.0418866571
Csub_139_175 sn_139 sn_175 3.839937714586597e-17
Rsub_139_193 sn_139 sn_193 23634241.33917939
Csub_139_193 sn_139 sn_193 4.45814331461669e-19
Rsub_139_216 sn_139 sn_216 905136.2389468787
Csub_139_216 sn_139 sn_216 1.16407708020719e-17
Rsub_139_212 sn_139 sn_212 643849.7547797959
Csub_139_212 sn_139 sn_212 1.636481713941726e-17
Rsub_139_163 sn_139 sn_163 548801.9799729908
Csub_139_163 sn_139 sn_163 1.919906247923623e-17
Rsub_139_209 sn_139 sn_209 2984289.757927423
Csub_139_209 sn_139 sn_209 3.530650290991699e-18
Rsub_139_227 sn_139 sn_227 481314.856151689
Csub_139_227 sn_139 sn_227 2.189104152419797e-17
Rsub_139_148 sn_139 sn_148 3351467.922816147
Csub_139_148 sn_139 sn_148 3.143841368881872e-18
Rsub_139_153 sn_139 sn_153 728917.9559790408
Csub_139_153 sn_139 sn_153 1.445496494605899e-17
Rsub_139_190 sn_139 sn_190 1221295.328065974
Csub_139_190 sn_139 sn_190 8.627301898317604e-18
Rsub_139_226 sn_139 sn_226 511303.1495824983
Csub_139_226 sn_139 sn_226 2.060711636694104e-17
Rsub_139_152 sn_139 sn_152 878587.3850584615
Csub_139_152 sn_139 sn_152 1.199252764314263e-17
Rsub_139_189 sn_139 sn_189 29579.99373323363
Csub_139_189 sn_139 sn_189 3.562030336197158e-16
Rsub_139_141 sn_139 sn_141 28364.70476721919
Csub_139_141 sn_139 sn_141 3.7146459265837e-16
Rsub_139_220 sn_139 sn_220 1357863.868014774
Csub_139_220 sn_139 sn_220 7.759602232906135e-18
Rsub_139_180 sn_139 sn_180 1119799.678432668
Csub_139_180 sn_139 sn_180 9.409257481639421e-18
Rsub_139_195 sn_139 sn_195 113167.7809442617
Csub_139_195 sn_139 sn_195 9.310497576531533e-17
Rsub_139_161 sn_139 sn_161 1015792.884616594
Csub_139_161 sn_139 sn_161 1.037266913540839e-17
Rsub_139_159 sn_139 sn_159 23488.86335656043
Csub_139_159 sn_139 sn_159 4.485735789887495e-16
Rsub_139_206 sn_139 sn_206 3330089.465688429
Csub_139_206 sn_139 sn_206 3.164024153342618e-18
Rsub_139_169 sn_139 sn_169 34011.71149823263
Csub_139_169 sn_139 sn_169 3.097898646699245e-16
Rsub_139_183 sn_139 sn_183 2431.768536840861
Csub_139_183 sn_139 sn_183 4.332848025050143e-15
Rsub_139_213 sn_139 sn_213 1623224.640275133
Csub_139_213 sn_139 sn_213 6.491081542751894e-18
Rsub_139_218 sn_139 sn_218 149419.2394474917
Csub_139_218 sn_139 sn_218 7.051624369921043e-17
Rsub_139_151 sn_139 sn_151 16155.55700206255
Csub_139_151 sn_139 sn_151 6.521894293638299e-16
Rsub_139_230 sn_139 0 3505.290652895154
Csub_139_230 sn_139 0 3.005880123957057e-15
Rsub_139_202 sn_139 sn_202 50784.29569734233
Csub_139_202 sn_139 sn_202 2.074752314184679e-16
Rsub_139_222 sn_139 sn_222 241582.7455841121
Csub_139_222 sn_139 sn_222 4.361438759524944e-17
Rsub_139_143 sn_139 sn_143 15672890.0145148
Csub_139_143 sn_139 sn_143 6.72274449222324e-19
Rsub_139_185 sn_139 sn_185 25493.09033824891
Csub_139_185 sn_139 sn_185 4.133074241855034e-16
Rsub_139_154 sn_139 sn_154 11322.45069712601
Csub_139_154 sn_139 sn_154 9.305832972100718e-16
Rsub_139_191 sn_139 sn_191 26454.50474404695
Csub_139_191 sn_139 sn_191 3.982869308714247e-16
Rsub_139_162 sn_139 sn_162 1617934.706539918
Csub_139_162 sn_139 sn_162 6.512304519854887e-18
Rsub_139_156 sn_139 sn_156 3793.488607625207
Csub_139_156 sn_139 sn_156 2.777518161264765e-15
Rsub_139_217 sn_139 sn_217 712731.5107651668
Csub_139_217 sn_139 sn_217 1.478324353993884e-17
Rsub_139_210 sn_139 sn_210 1558364.937095329
Csub_139_210 sn_139 sn_210 6.761242666219883e-18
Rsub_139_155 sn_139 sn_155 228254.9086783293
Csub_139_155 sn_139 sn_155 4.616103795199714e-17
Rsub_139_208 sn_139 sn_208 2132960.885700398
Csub_139_208 sn_139 sn_208 4.939839062623106e-18
Rsub_139_142 sn_139 sn_142 4445394.066705388
Csub_139_142 sn_139 sn_142 2.37020235869413e-18
Rsub_139_214 sn_139 sn_214 1437064.099593654
Csub_139_214 sn_139 sn_214 7.331950958352734e-18
Rsub_139_179 sn_139 sn_179 163460.5925444969
Csub_139_179 sn_139 sn_179 6.445886031742963e-17
Rsub_139_211 sn_139 sn_211 5556094.012483639
Csub_139_211 sn_139 sn_211 1.896383228677599e-18
Rsub_139_144 sn_139 sn_144 14573895.37816859
Csub_139_144 sn_139 sn_144 7.229696130530377e-19
Rsub_139_223 sn_139 sn_223 156833.2924644544
Csub_139_223 sn_139 sn_223 6.718269658604566e-17
Rsub_139_228 sn_139 sn_228 7295957.251030569
Csub_139_228 sn_139 sn_228 1.444153678496636e-18
Rsub_139_140 sn_139 sn_140 1204151.235897187
Csub_139_140 sn_139 sn_140 8.750133029909232e-18
Rsub_139_219 sn_139 sn_219 1653573.977196992
Csub_139_219 sn_139 sn_219 6.371945644724413e-18
Rsub_139_197 sn_139 sn_197 19088231.10190314
Csub_139_197 sn_139 sn_197 5.519884711150363e-19
Rsub_139_160 sn_139 sn_160 708566.6628014707
Csub_139_160 sn_139 sn_160 1.487013721556098e-17
Rsub_139_200 sn_139 sn_200 2096521.865515303
Csub_139_200 sn_139 sn_200 5.02569692953822e-18
Rsub_139_158 sn_139 sn_158 470773.9631950071
Csub_139_158 sn_139 sn_158 2.238119421626873e-17
Rsub_139_170 sn_139 sn_170 2120068.318844117
Csub_139_170 sn_139 sn_170 4.969879229163049e-18
Rsub_139_229 sn_139 sn_229 47226.0754398565
Csub_139_229 sn_139 sn_229 2.231073279770718e-16
Rsub_139_215 sn_139 sn_215 620223.8541888527
Csub_139_215 sn_139 sn_215 1.69881945543838e-17
Rsub_139_146 sn_139 sn_146 10993319.79279128
Csub_139_146 sn_139 sn_146 9.584441916389224e-19
Rsub_139_167 sn_139 sn_167 518940.8671761517
Csub_139_167 sn_139 sn_167 2.030382297614162e-17
Rsub_139_164 sn_139 sn_164 4199058.976585017
Csub_139_164 sn_139 sn_164 2.509248753347838e-18
Rsub_139_177 sn_139 sn_177 74878.96933093196
Csub_139_177 sn_139 sn_177 1.407135220526794e-16
Rsub_139_181 sn_139 sn_181 64336.26725922091
Csub_139_181 sn_139 sn_181 1.637720674682113e-16
Rsub_139_182 sn_139 sn_182 4427068.512164048
Csub_139_182 sn_139 sn_182 2.380013653115916e-18
Rsub_139_171 sn_139 sn_171 16359419.5623218
Csub_139_171 sn_139 sn_171 6.440621846081327e-19
Rsub_139_198 sn_139 sn_198 15352448.36179102
Csub_139_198 sn_139 sn_198 6.863063958223805e-19
Rsub_139_184 sn_139 sn_184 9564398.433419185
Csub_139_184 sn_139 sn_184 1.10163577726062e-18
Rsub_139_204 sn_139 sn_204 27717248.57223042
Csub_139_204 sn_139 sn_204 3.80141754502515e-19
Rsub_139_168 sn_139 sn_168 2296190.660247304
Csub_139_168 sn_139 sn_168 4.588679714033504e-18
Rsub_66_181 sn_66 sn_181 240924.0500299768
Csub_66_181 sn_66 sn_181 4.373363099665229e-17
Rsub_66_127 sn_66 sn_127 766337.5799965946
Csub_66_127 sn_66 sn_127 1.374914107993611e-17
Rsub_66_152 sn_66 sn_152 666319.0806149655
Csub_66_152 sn_66 sn_152 1.581296980495526e-17
Rsub_66_166 sn_66 sn_166 873725.3151202289
Csub_66_166 sn_66 sn_166 1.205926315730034e-17
Rsub_66_84 sn_66 sn_84 304975960.4245183
Csub_66_84 sn_66 sn_84 3.454857060721606e-20
Rsub_66_112 sn_66 sn_112 2642557.031167952
Csub_66_112 sn_66 sn_112 3.987230314409943e-18
Rsub_66_191 sn_66 sn_191 412054.9664253638
Csub_66_191 sn_66 sn_191 2.557057761889272e-17
Rsub_66_185 sn_66 sn_185 803258.2804343993
Csub_66_185 sn_66 sn_185 1.311718006384187e-17
Rsub_66_169 sn_66 sn_169 820689.0858367247
Csub_66_169 sn_66 sn_169 1.283858124113792e-17
Rsub_66_136 sn_66 sn_136 111538.7282854276
Csub_66_136 sn_66 sn_136 9.446479858786932e-17
Rsub_66_165 sn_66 sn_165 162579.3410511746
Csub_66_165 sn_66 sn_165 6.480825567446151e-17
Rsub_66_111 sn_66 sn_111 957783.3782851557
Csub_66_111 sn_66 sn_111 1.100090452717486e-17
Rsub_66_82 sn_66 sn_82 6212024.325405305
Csub_66_82 sn_66 sn_82 1.696143310182957e-18
Rsub_66_180 sn_66 sn_180 2164619.156806859
Csub_66_180 sn_66 sn_180 4.867592282502436e-18
Rsub_66_89 sn_66 sn_89 794013.8434545677
Csub_66_89 sn_66 sn_89 1.326989899368535e-17
Rsub_66_108 sn_66 sn_108 444001.4945673933
Csub_66_108 sn_66 sn_108 2.373073881766114e-17
Rsub_66_118 sn_66 sn_118 2493437.465194273
Csub_66_118 sn_66 sn_118 4.225685885171803e-18
Rsub_66_177 sn_66 sn_177 323581.8358974538
Csub_66_177 sn_66 sn_177 3.25620363485703e-17
Rsub_66_184 sn_66 sn_184 24445706.51915983
Csub_66_184 sn_66 sn_184 4.310157079719425e-19
Rsub_66_197 sn_66 sn_197 39148743.32256709
Csub_66_197 sn_66 sn_197 2.691397630676002e-19
Rsub_66_128 sn_66 sn_128 93905.05743747354
Csub_66_128 sn_66 sn_128 1.122035786969801e-16
Rsub_66_200 sn_66 sn_200 5137290.87563171
Csub_66_200 sn_66 sn_200 2.050980518196641e-18
Rsub_66_182 sn_66 sn_182 48972194.24222814
Csub_66_182 sn_66 sn_182 2.151523668740275e-19
Rsub_66_147 sn_66 sn_147 1245967.839302293
Csub_66_147 sn_66 sn_147 8.456465062637679e-18
Rsub_66_153 sn_66 sn_153 18003.29773240102
Csub_66_153 sn_66 sn_153 5.852529719189838e-16
Rsub_66_87 sn_66 sn_87 240573.3979901014
Csub_66_87 sn_66 sn_87 4.379737572922978e-17
Rsub_66_124 sn_66 sn_124 4711881.635619313
Csub_66_124 sn_66 sn_124 2.236151991293628e-18
Rsub_66_224 sn_66 sn_224 927251.9487677466
Csub_66_224 sn_66 sn_224 1.136312899232216e-17
Rsub_66_205 sn_66 sn_205 376385.3998598002
Csub_66_205 sn_66 sn_205 2.79938688008481e-17
Rsub_66_129 sn_66 sn_129 15091116.58379554
Csub_66_129 sn_66 sn_129 6.981911142044859e-19
Rsub_66_164 sn_66 sn_164 32433646.37765454
Csub_66_164 sn_66 sn_164 3.248627483800035e-19
Rsub_66_106 sn_66 sn_106 569702.7773987461
Csub_66_106 sn_66 sn_106 1.84947027120693e-17
Rsub_66_88 sn_66 sn_88 22135956.10090831
Csub_66_88 sn_66 sn_88 4.759895373029611e-19
Rsub_66_190 sn_66 sn_190 905362.0003452837
Csub_66_190 sn_66 sn_190 1.163786805522171e-17
Rsub_66_201 sn_66 sn_201 13863260.87069729
Csub_66_201 sn_66 sn_201 7.600292312540205e-19
Rsub_66_198 sn_66 sn_198 424597.2493224238
Csub_66_198 sn_66 sn_198 2.481524201827548e-17
Rsub_66_95 sn_66 sn_95 13651724.53660939
Csub_66_95 sn_66 sn_95 7.718060435496373e-19
Rsub_66_211 sn_66 sn_211 5660600.379974356
Csub_66_211 sn_66 sn_211 1.861372079807149e-18
Rsub_66_203 sn_66 sn_203 2386016.326201992
Csub_66_203 sn_66 sn_203 4.415931017119964e-18
Rsub_66_67 sn_66 sn_67 7200164.505119241
Csub_66_67 sn_66 sn_67 1.463367051508153e-18
Rsub_66_80 sn_66 sn_80 9849589.783638764
Csub_66_80 sn_66 sn_80 1.069738307247297e-18
Rsub_66_97 sn_66 sn_97 1867095.631324311
Csub_66_97 sn_66 sn_97 5.643247900889033e-18
Rsub_66_216 sn_66 sn_216 2467865.243127748
Csub_66_216 sn_66 sn_216 4.269472788909725e-18
Rsub_66_215 sn_66 sn_215 1380129.623184206
Csub_66_215 sn_66 sn_215 7.634415873141286e-18
Rsub_66_150 sn_66 sn_150 1079898.192022377
Csub_66_150 sn_66 sn_150 9.756922995211079e-18
Rsub_66_141 sn_66 sn_141 415912.5883825351
Csub_66_141 sn_66 sn_141 2.533340850106485e-17
Rsub_66_132 sn_66 sn_132 440222.8891301123
Csub_66_132 sn_66 sn_132 2.393442904127558e-17
Rsub_66_101 sn_66 sn_101 5677104.10641524
Csub_66_101 sn_66 sn_101 1.855960945004261e-18
Rsub_66_217 sn_66 sn_217 333557.2893255221
Csub_66_217 sn_66 sn_217 3.158822738827133e-17
Rsub_66_219 sn_66 sn_219 783698.7422090353
Csub_66_219 sn_66 sn_219 1.344455839310205e-17
Rsub_66_213 sn_66 sn_213 1848685.871444157
Csub_66_213 sn_66 sn_213 5.699445030106227e-18
Rsub_66_114 sn_66 sn_114 2456881.337421169
Csub_66_114 sn_66 sn_114 4.28856019285387e-18
Rsub_66_92 sn_66 sn_92 100940.5875605921
Csub_66_92 sn_66 sn_92 1.04383021308502e-16
Rsub_66_102 sn_66 sn_102 2905038.102943677
Csub_66_102 sn_66 sn_102 3.626969123590282e-18
Rsub_66_135 sn_66 sn_135 8549184.370879447
Csub_66_135 sn_66 sn_135 1.232454822020188e-18
Rsub_66_173 sn_66 sn_173 1473726.216885416
Csub_66_173 sn_66 sn_173 7.149552869119672e-18
Rsub_66_94 sn_66 sn_94 82076.16109753119
Csub_66_94 sn_66 sn_94 1.283744678276252e-16
Rsub_66_202 sn_66 sn_202 359.3022263626882
Csub_66_202 sn_66 sn_202 2.932484891311034e-14
Rsub_66_167 sn_66 sn_167 64550.33727651567
Csub_66_167 sn_66 sn_167 1.632289457620436e-16
Rsub_66_99 sn_66 sn_99 1965660.820705591
Csub_66_99 sn_66 sn_99 5.360275481528821e-18
Rsub_66_199 sn_66 sn_199 26483941.04322385
Csub_66_199 sn_66 sn_199 3.978442439904861e-19
Rsub_66_206 sn_66 sn_206 1877293.141172347
Csub_66_206 sn_66 sn_206 5.612593617451826e-18
Rsub_66_117 sn_66 sn_117 60525.57950983895
Csub_66_117 sn_66 sn_117 1.740831494313443e-16
Rsub_66_196 sn_66 sn_196 1326799.276163597
Csub_66_196 sn_66 sn_196 7.941279205921752e-18
Rsub_66_115 sn_66 sn_115 10314.2695690812
Csub_66_115 sn_66 sn_115 1.021544320871245e-15
Rsub_66_76 sn_66 sn_76 1537953.566251764
Csub_66_76 sn_66 sn_76 6.850976345085034e-18
Rsub_66_155 sn_66 sn_155 413030.1179147943
Csub_66_155 sn_66 sn_155 2.551020626637115e-17
Rsub_66_83 sn_66 sn_83 14395.21387100224
Csub_66_83 sn_66 sn_83 7.319435193286516e-16
Rsub_66_71 sn_66 sn_71 126134.6537567275
Csub_66_71 sn_66 sn_71 8.35336141846588e-17
Rsub_66_72 sn_66 sn_72 17783265.78549023
Csub_66_72 sn_66 sn_72 5.924942937549164e-19
Rsub_66_230 sn_66 0 6160.244637432025
Csub_66_230 sn_66 0 1.710400174403182e-15
Rsub_66_225 sn_66 sn_225 1657.398427662797
Csub_66_225 sn_66 sn_225 6.357242366332014e-15
Rsub_66_208 sn_66 sn_208 6498638.538274054
Csub_66_208 sn_66 sn_208 1.621337060089565e-18
Rsub_66_73 sn_66 sn_73 3039.586177849003
Csub_66_73 sn_66 sn_73 3.466420389398618e-15
Rsub_66_107 sn_66 sn_107 46770933.7050296
Csub_66_107 sn_66 sn_107 2.252784511141145e-19
Rsub_66_109 sn_66 sn_109 270433.7696209019
Csub_66_109 sn_66 sn_109 3.896141934123168e-17
Rsub_66_188 sn_66 sn_188 4463133.519845081
Csub_66_188 sn_66 sn_188 2.360781602293568e-18
Rsub_66_143 sn_66 sn_143 1945904.499649727
Csub_66_143 sn_66 sn_143 5.414697126260114e-18
Rsub_66_222 sn_66 sn_222 4223922.037572494
Csub_66_222 sn_66 sn_222 2.494478687936524e-18
Rsub_66_69 sn_66 sn_69 107490.6667024497
Csub_66_69 sn_66 sn_69 9.802231045227929e-17
Rsub_66_148 sn_66 sn_148 9872571.978629263
Csub_66_148 sn_66 sn_148 1.067248081354877e-18
Rsub_66_195 sn_66 sn_195 505654.5979428159
Csub_66_195 sn_66 sn_195 2.083731374162559e-17
Rsub_66_116 sn_66 sn_116 6561056.956592904
Csub_66_116 sn_66 sn_116 1.605912518659417e-18
Rsub_66_121 sn_66 sn_121 376812.1586390054
Csub_66_121 sn_66 sn_121 2.796216433218704e-17
Rsub_66_209 sn_66 sn_209 47681.83370573217
Csub_66_209 sn_66 sn_209 2.209747965494737e-16
Rsub_66_172 sn_66 sn_172 96779.66580999727
Csub_66_172 sn_66 sn_172 1.088708399026275e-16
Rsub_66_75 sn_66 sn_75 152496.4627515202
Csub_66_75 sn_66 sn_75 6.909329772060542e-17
Rsub_66_223 sn_66 sn_223 102461.1284712156
Csub_66_223 sn_66 sn_223 1.028339591749667e-16
Rsub_66_144 sn_66 sn_144 14734714.63962528
Csub_66_144 sn_66 sn_144 7.150788976866102e-19
Rsub_66_122 sn_66 sn_122 334335.5993560039
Csub_66_122 sn_66 sn_122 3.151469219109583e-17
Rsub_66_85 sn_66 sn_85 8107.464597388695
Csub_66_85 sn_66 sn_85 1.299602776634222e-15
Rsub_66_119 sn_66 sn_119 279273.5477127667
Csub_66_119 sn_66 sn_119 3.772818295367806e-17
Rsub_66_207 sn_66 sn_207 10158814.86175482
Csub_66_207 sn_66 sn_207 1.037176446821273e-18
Rsub_66_221 sn_66 sn_221 3023372.097816495
Csub_66_221 sn_66 sn_221 3.485010498654644e-18
Rsub_66_171 sn_66 sn_171 6535579.730167981
Csub_66_171 sn_66 sn_171 1.612172743237146e-18
Rsub_66_68 sn_66 sn_68 118219.1572961622
Csub_66_68 sn_66 sn_68 8.912670114737868e-17
Rsub_66_226 sn_66 sn_226 385786.3384116622
Csub_66_226 sn_66 sn_226 2.731170716311577e-17
Rsub_66_163 sn_66 sn_163 481173.4666307968
Csub_66_163 sn_66 sn_163 2.189747405651239e-17
Rsub_66_179 sn_66 sn_179 301834.306624086
Csub_66_179 sn_66 sn_179 3.490817071153038e-17
Rsub_66_100 sn_66 sn_100 135207.7031783024
Csub_66_100 sn_66 sn_100 7.792813023630191e-17
Rsub_66_70 sn_66 sn_70 25089096.75821632
Csub_66_70 sn_66 sn_70 4.199626476700264e-19
Rsub_66_90 sn_66 sn_90 76471825.72237107
Csub_66_90 sn_66 sn_90 1.377825545905289e-19
Rsub_66_113 sn_66 sn_113 692969.8771745155
Csub_66_113 sn_66 sn_113 1.520482181013551e-17
Rsub_66_192 sn_66 sn_192 3868842.037462633
Csub_66_192 sn_66 sn_192 2.723420444723125e-18
Rsub_66_204 sn_66 sn_204 3571472.183290923
Csub_66_204 sn_66 sn_204 2.950179355035936e-18
Rsub_66_175 sn_66 sn_175 13152.88260809275
Csub_66_175 sn_66 sn_175 8.010778941908201e-16
Rsub_66_212 sn_66 sn_212 1351411.87473224
Csub_66_212 sn_66 sn_212 7.796648600795842e-18
Rsub_66_110 sn_66 sn_110 16311240.23687554
Csub_66_110 sn_66 sn_110 6.459645832699901e-19
Rsub_66_79 sn_66 sn_79 35076.45791941237
Csub_66_79 sn_66 sn_79 3.003861885495227e-16
Rsub_66_158 sn_66 sn_158 1930484.656781635
Csub_66_158 sn_66 sn_158 5.457947290705573e-18
Rsub_66_91 sn_66 sn_91 27843.19412794308
Csub_66_91 sn_66 sn_91 3.784222260496945e-16
Rsub_66_214 sn_66 sn_214 1873928.94706829
Csub_66_214 sn_66 sn_214 5.622669695515423e-18
Rsub_66_86 sn_66 sn_86 4208097.647026447
Csub_66_86 sn_66 sn_86 2.503859079808986e-18
Rsub_66_140 sn_66 sn_140 4142146.607416902
Csub_66_140 sn_66 sn_140 2.543725391893044e-18
Rsub_66_98 sn_66 sn_98 1330815.042176766
Csub_66_98 sn_66 sn_98 7.917316207213778e-18
Rsub_66_104 sn_66 sn_104 754660.2964148253
Csub_66_104 sn_66 sn_104 1.396188927956832e-17
Rsub_66_126 sn_66 sn_126 663933.3549722207
Csub_66_126 sn_66 sn_126 1.586979088084956e-17
Rsub_66_161 sn_66 sn_161 709296.6306730018
Csub_66_161 sn_66 sn_161 1.485483371355179e-17
Rsub_66_131 sn_66 sn_131 6105111.9518197
Csub_66_131 sn_66 sn_131 1.72584607544985e-18
Rsub_66_210 sn_66 sn_210 1833957.540629159
Csub_66_210 sn_66 sn_210 5.745216706933873e-18
Rsub_66_105 sn_66 sn_105 11459368.9580514
Csub_66_105 sn_66 sn_105 9.19464548248708e-19
Rsub_145_172 sn_145 sn_172 11691370.24126818
Csub_145_172 sn_145 sn_172 9.012188721077654e-19
Rsub_145_163 sn_145 sn_163 17133616.67635806
Csub_145_163 sn_145 sn_163 6.149596843011458e-19
Rsub_145_214 sn_145 sn_214 14694258.41479548
Csub_145_214 sn_145 sn_214 7.170476525457683e-19
Rsub_145_222 sn_145 sn_222 3155198.021226726
Csub_145_222 sn_145 sn_222 3.339404827001466e-18
Rsub_145_212 sn_145 sn_212 635797.2553799411
Csub_145_212 sn_145 sn_212 1.657208082147758e-17
Rsub_145_189 sn_145 sn_189 135201.8873206384
Csub_145_189 sn_145 sn_189 7.793148240040599e-17
Rsub_145_195 sn_145 sn_195 1190096.067624959
Csub_145_195 sn_145 sn_195 8.853473084116107e-18
Rsub_145_190 sn_145 sn_190 2750307.127851003
Csub_145_190 sn_145 sn_190 3.831020686937919e-18
Rsub_145_180 sn_145 sn_180 9476251.332027145
Csub_145_180 sn_145 sn_180 1.111883078345501e-18
Rsub_145_217 sn_145 sn_217 32360.227479557
Csub_145_217 sn_145 sn_217 3.255997971239923e-16
Rsub_145_216 sn_145 sn_216 1179223.700014385
Csub_145_216 sn_145 sn_216 8.935101543584537e-18
Rsub_145_192 sn_145 sn_192 9761293.810711039
Csub_145_192 sn_145 sn_192 1.079414645901586e-18
Rsub_145_223 sn_145 sn_223 100686.9999129594
Csub_145_223 sn_145 sn_223 1.046459176590667e-16
Rsub_145_149 sn_145 sn_149 1448.408726259755
Csub_145_149 sn_145 sn_149 7.274523628035922e-15
Rsub_145_219 sn_145 sn_219 7012502.167519155
Csub_145_219 sn_145 sn_219 1.502528377250761e-18
Rsub_145_220 sn_145 sn_220 50852.76744893074
Csub_145_220 sn_145 sn_220 2.07195872138352e-16
Rsub_145_183 sn_145 sn_183 47896.97675232228
Csub_145_183 sn_145 sn_183 2.199822246968675e-16
Rsub_145_146 sn_145 sn_146 5068131.495739944
Csub_145_146 sn_145 sn_146 2.078968059744804e-18
Rsub_145_152 sn_145 sn_152 1646.85725317542
Csub_145_152 sn_145 sn_152 6.397933689707396e-15
Rsub_145_159 sn_145 sn_159 105033.1475145318
Csub_145_159 sn_145 sn_159 1.003157931716008e-16
Rsub_145_157 sn_145 sn_157 7102.598053873556
Csub_145_157 sn_145 sn_157 1.483468925358053e-15
Rsub_145_194 sn_145 sn_194 6524790.553761181
Csub_145_194 sn_145 sn_194 1.614838578405601e-18
Rsub_145_177 sn_145 sn_177 12744.01906931225
Csub_145_177 sn_145 sn_177 8.26778698691842e-16
Rsub_145_151 sn_145 sn_151 33661.11712103194
Csub_145_151 sn_145 sn_151 3.130164535046479e-16
Rsub_145_229 sn_145 sn_229 190615.0054557721
Csub_145_229 sn_145 sn_229 5.527625423316819e-17
Rsub_145_150 sn_145 sn_150 4327287.586133833
Csub_145_150 sn_145 sn_150 2.434893288810441e-18
Rsub_145_161 sn_145 sn_161 23009.20918977015
Csub_145_161 sn_145 sn_161 4.579246255414332e-16
Rsub_145_205 sn_145 sn_205 626830.2094077467
Csub_145_205 sn_145 sn_205 1.680915077814337e-17
Rsub_145_215 sn_145 sn_215 1821830.835867449
Csub_145_215 sn_145 sn_215 5.78345875741704e-18
Rsub_145_199 sn_145 sn_199 13529477.92806854
Csub_145_199 sn_145 sn_199 7.787797547140227e-19
Rsub_145_162 sn_145 sn_162 13119952.56176717
Csub_145_162 sn_145 sn_162 8.030885365343737e-19
Rsub_145_206 sn_145 sn_206 39055797.58818302
Csub_145_206 sn_145 sn_206 2.697802670254003e-19
Rsub_145_200 sn_145 sn_200 7287001.098232475
Csub_145_200 sn_145 sn_200 1.445928628278335e-18
Rsub_145_209 sn_145 sn_209 164928.7848376689
Csub_145_209 sn_145 sn_209 6.38850490082767e-17
Rsub_145_213 sn_145 sn_213 37843785.19879793
Csub_145_213 sn_145 sn_213 2.784204446484566e-19
Rsub_229_230 sn_229 0 12467.32846351244
Csub_229_230 sn_229 0 8.451276095810459e-16
Rsub_62_200 sn_62 sn_200 13095369.11140841
Csub_62_200 sn_62 sn_200 8.045961448349587e-19
Rsub_62_132 sn_62 sn_132 89024.52703709378
Csub_62_132 sn_62 sn_132 1.183548383002335e-16
Rsub_62_220 sn_62 sn_220 939364.5709566138
Csub_62_220 sn_62 sn_220 1.121660729816544e-17
Rsub_62_96 sn_62 sn_96 469682.2854783069
Csub_62_96 sn_62 sn_96 2.243321459633088e-17
Rsub_62_72 sn_62 sn_72 28708184.06269715
Csub_62_72 sn_62 sn_72 3.670202015989197e-19
Rsub_62_193 sn_62 sn_193 5176729.350314312
Csub_62_193 sn_62 sn_193 2.035355296600597e-18
Rsub_62_152 sn_62 sn_152 799134.0362920585
Csub_62_152 sn_62 sn_152 1.318487640836668e-17
Rsub_62_157 sn_62 sn_157 1004330.79005822
Csub_62_157 sn_62 sn_157 1.049104897164331e-17
Rsub_62_97 sn_62 sn_97 4017549.91404618
Csub_62_97 sn_62 sn_97 2.622614212058023e-18
Rsub_62_213 sn_62 sn_213 11451948.27807461
Csub_62_213 sn_62 sn_213 9.200603466226515e-19
Rsub_62_178 sn_62 sn_178 1924405.713297938
Csub_62_178 sn_62 sn_178 5.475188225342133e-18
Rsub_62_112 sn_62 sn_112 3332991.30742535
Csub_62_112 sn_62 sn_112 3.161269421482279e-18
Rsub_62_78 sn_62 sn_78 23709430.42851173
Csub_62_78 sn_62 sn_78 4.444005322691925e-19
Rsub_62_212 sn_62 sn_212 430950.342031798
Csub_62_212 sn_62 sn_212 2.444941440945082e-17
Rsub_62_110 sn_62 sn_110 34363896.91647555
Csub_62_110 sn_62 sn_110 3.066149199504306e-19
Rsub_62_136 sn_62 sn_136 1017322.364996981
Csub_62_136 sn_62 sn_136 1.035707447782421e-17
Rsub_62_123 sn_62 sn_123 36867894.2915886
Csub_62_123 sn_62 sn_123 2.857902167912502e-19
Rsub_62_106 sn_62 sn_106 1983861.551548571
Csub_62_106 sn_62 sn_106 5.3110981933217e-18
Rsub_62_90 sn_62 sn_90 180454419.9144788
Csub_62_90 sn_62 sn_90 5.838861418425473e-20
Rsub_62_70 sn_62 sn_70 214826690.3743796
Csub_62_70 sn_62 sn_70 4.904643591477399e-20
Rsub_62_160 sn_62 sn_160 258066.4852738245
Csub_62_160 sn_62 sn_160 4.082856203140883e-17
Rsub_62_81 sn_62 sn_81 205933.8090025513
Csub_62_81 sn_62 sn_81 5.116441808785009e-17
Rsub_62_175 sn_62 sn_175 74427.53189353996
Csub_62_175 sn_62 sn_175 1.415670147076922e-16
Rsub_62_65 sn_62 sn_65 6398.708666670969
Csub_62_65 sn_62 sn_65 1.64665779473779e-15
Rsub_62_223 sn_62 sn_223 9757.155591790694
Csub_62_223 sn_62 sn_223 1.079872448800038e-15
Rsub_62_163 sn_62 sn_163 13563910.11239333
Csub_62_163 sn_62 sn_163 7.768028109094312e-19
Rsub_62_115 sn_62 sn_115 5855.592554292266
Csub_62_115 sn_62 sn_115 1.799388090024561e-15
Rsub_62_172 sn_62 sn_172 446365.5987519184
Csub_62_172 sn_62 sn_172 2.360505274530796e-17
Rsub_62_209 sn_62 sn_209 143519.3595546213
Csub_62_209 sn_62 sn_209 7.341506772973004e-17
Rsub_62_225 sn_62 sn_225 1807.038687411308
Csub_62_225 sn_62 sn_225 5.830801285900608e-15
Rsub_62_71 sn_62 sn_71 39153.70680246881
Csub_62_71 sn_62 sn_71 2.691056444639267e-16
Rsub_62_150 sn_62 sn_150 3882485.415928606
Csub_62_150 sn_62 sn_150 2.713850117505181e-18
Rsub_62_122 sn_62 sn_122 78980.78594299391
Csub_62_122 sn_62 sn_122 1.334056552670283e-16
Rsub_62_85 sn_62 sn_85 1643.990050023098
Csub_62_85 sn_62 sn_85 6.409092014931575e-15
Rsub_62_164 sn_62 sn_164 7290266.329538288
Csub_62_164 sn_62 sn_164 1.445281012511007e-18
Rsub_62_216 sn_62 sn_216 5279818.692988666
Csub_62_216 sn_62 sn_216 1.995614644158505e-18
Rsub_62_68 sn_62 sn_68 2032.134123823858
Csub_62_68 sn_62 sn_68 5.184935078204161e-15
Rsub_62_226 sn_62 sn_226 864993.1258226711
Csub_62_226 sn_62 sn_226 1.218100258566684e-17
Rsub_62_91 sn_62 sn_91 234803.151490565
Csub_62_91 sn_62 sn_91 4.487368859976048e-17
Rsub_62_111 sn_62 sn_111 124832.5823201556
Csub_62_111 sn_62 sn_111 8.440491501815845e-17
Rsub_62_119 sn_62 sn_119 33388.67358216411
Csub_62_119 sn_62 sn_119 3.155705924136646e-16
Rsub_62_230 sn_62 0 12837.00978991009
Csub_62_230 sn_62 0 8.207895510457342e-16
Rsub_62_202 sn_62 sn_202 647.9388474858899
Csub_62_202 sn_62 sn_202 1.626154002513247e-14
Rsub_62_66 sn_62 sn_66 18005.12572641886
Csub_62_66 sn_62 sn_66 5.851935533429715e-16
Rsub_62_173 sn_62 sn_173 53754.55939753982
Csub_62_173 sn_62 sn_173 1.960109732145293e-16
Rsub_62_229 sn_62 sn_229 154221.1741471018
Csub_62_229 sn_62 sn_229 6.832060228111032e-17
Rsub_62_83 sn_62 sn_83 591.269456334343
Csub_62_83 sn_62 sn_83 1.7820104504556e-14
Rsub_62_162 sn_62 sn_162 14134099.13994518
Csub_62_162 sn_62 sn_162 7.45465515552544e-19
Rsub_62_75 sn_62 sn_75 20035.66801895704
Csub_62_75 sn_62 sn_75 5.258863089696213e-16
Rsub_62_186 sn_62 sn_186 516666.3667025955
Csub_62_186 sn_62 sn_186 2.039320571508196e-17
Rsub_62_167 sn_62 sn_167 3276.073035450653
Csub_62_167 sn_62 sn_167 3.216193103210416e-15
Rsub_62_69 sn_62 sn_69 196660.6397329356
Csub_62_69 sn_62 sn_69 5.357698173126308e-17
Rsub_62_206 sn_62 sn_206 15157125.63468098
Csub_62_206 sn_62 sn_206 6.951505025544883e-19
Rsub_62_98 sn_62 sn_98 701713.2423190259
Csub_62_98 sn_62 sn_98 1.501536933720813e-17
Rsub_62_177 sn_62 sn_177 554909.2801024388
Csub_62_177 sn_62 sn_177 1.89877586842392e-17
Rsub_62_73 sn_62 sn_73 117388.8633212361
Csub_62_73 sn_62 sn_73 8.97570962366062e-17
Rsub_62_133 sn_62 sn_133 21705583.6109547
Csub_62_133 sn_62 sn_133 4.854273301784103e-19
Rsub_62_217 sn_62 sn_217 260831.3153010882
Csub_62_217 sn_62 sn_217 4.039577644297546e-17
Rsub_62_138 sn_62 sn_138 3527397.231011334
Csub_62_138 sn_62 sn_138 2.98704194968399e-18
Rsub_62_142 sn_62 sn_142 13895060.87700452
Csub_62_142 sn_62 sn_142 7.582898409367345e-19
Rsub_62_102 sn_62 sn_102 8754736.997306464
Csub_62_102 sn_62 sn_102 1.203517993227178e-18
Rsub_62_117 sn_62 sn_117 265658.8767469674
Csub_62_117 sn_62 sn_117 3.966170312564297e-17
Rsub_62_77 sn_62 sn_77 362887.726271558
Csub_62_77 sn_62 sn_77 2.903510573500435e-17
Rsub_62_199 sn_62 sn_199 26090986.47892275
Csub_62_199 sn_62 sn_199 4.038361489605522e-19
Rsub_62_155 sn_62 sn_155 433714.1439511909
Csub_62_155 sn_62 sn_155 2.429361285348294e-17
Rsub_62_125 sn_62 sn_125 849704.8602804724
Csub_62_125 sn_62 sn_125 1.240016857000453e-17
Rsub_62_191 sn_62 sn_191 1699409.720560945
Csub_62_191 sn_62 sn_191 6.200084285002263e-18
Rsub_62_131 sn_62 sn_131 80917789.23618437
Csub_62_131 sn_62 sn_131 1.302122018123347e-19
Rsub_62_129 sn_62 sn_129 30449022.71459575
Csub_62_129 sn_62 sn_129 3.46036836748108e-19
Rsub_62_124 sn_62 sn_124 477725.589805351
Csub_62_124 sn_62 sn_124 2.205551414259195e-17
Rsub_62_82 sn_62 sn_82 41349565.53316113
Csub_62_82 sn_62 sn_82 2.548148539500385e-19
Rsub_62_101 sn_62 sn_101 13582469.98465765
Csub_62_101 sn_62 sn_101 7.757413426373622e-19
Rsub_62_92 sn_62 sn_92 567966.5594968827
Csub_62_92 sn_62 sn_92 1.855123919894765e-17
Rsub_62_215 sn_62 sn_215 2519016.057004146
Csub_62_215 sn_62 sn_215 4.182777427294763e-18
Rsub_62_219 sn_62 sn_219 307049.4194512443
Csub_62_219 sn_62 sn_219 3.431526925229398e-17
Rsub_150_167 sn_150 sn_167 10603035.87470573
Csub_150_167 sn_150 sn_167 9.937232719702014e-19
Rsub_150_225 sn_150 sn_225 21459311.15459233
Csub_150_225 sn_150 sn_225 4.909982164071085e-19
Rsub_150_152 sn_150 sn_152 9841178.296418155
Csub_150_152 sn_150 sn_152 1.070652637811156e-18
Rsub_150_162 sn_150 sn_162 2061027.02785991
Csub_150_162 sn_150 sn_162 5.112249067966213e-18
Rsub_150_188 sn_150 sn_188 89607123.60498689
Csub_150_188 sn_150 sn_188 1.175853333790486e-19
Rsub_150_185 sn_150 sn_185 23247587.08414169
Csub_150_185 sn_150 sn_185 4.532291228373309e-19
Rsub_150_182 sn_150 sn_182 15720461.28117056
Csub_150_182 sn_150 sn_182 6.702400975250164e-19
Rsub_150_220 sn_150 sn_220 5859887.250316725
Csub_150_220 sn_150 sn_220 1.798069323204215e-18
Rsub_150_179 sn_150 sn_179 10729655.57729616
Csub_150_179 sn_150 sn_179 9.81996432814217e-19
Rsub_150_217 sn_150 sn_217 8574365.760270659
Csub_150_217 sn_150 sn_217 1.228835321097546e-18
Rsub_150_156 sn_150 sn_156 16883377.05299767
Csub_150_156 sn_150 sn_156 6.240744057990003e-19
Rsub_150_171 sn_150 sn_171 103816667.4776223
Csub_150_171 sn_150 sn_171 1.014912514361062e-19
Rsub_150_191 sn_150 sn_191 1740198.921901688
Csub_150_191 sn_150 sn_191 6.054758090940395e-18
Rsub_150_208 sn_150 sn_208 4110911.59151209
Csub_150_208 sn_150 sn_208 2.563052809013204e-18
Rsub_150_166 sn_150 sn_166 2547368.68425743
Csub_150_166 sn_150 sn_166 4.136222435073796e-18
Rsub_150_201 sn_150 sn_201 20735769.06327437
Csub_150_201 sn_150 sn_201 5.081308279465471e-19
Rsub_150_164 sn_150 sn_164 2634840.168486207
Csub_150_164 sn_150 sn_164 3.998908027989994e-18
Rsub_150_198 sn_150 sn_198 1987820.105037488
Csub_150_198 sn_150 sn_198 5.300521649584231e-18
Rsub_150_221 sn_150 sn_221 3277397.163003291
Csub_150_221 sn_150 sn_221 3.21489370320158e-18
Rsub_150_170 sn_150 sn_170 1907087.0628474
Csub_150_170 sn_150 sn_170 5.524909537427398e-18
Rsub_150_189 sn_150 sn_189 9365606.818268253
Csub_150_189 sn_150 sn_189 1.12501877418961e-18
Rsub_150_200 sn_150 sn_200 7181704.70153274
Csub_150_200 sn_150 sn_200 1.467128479952855e-18
Rsub_150_174 sn_150 sn_174 63796349.51912043
Csub_150_174 sn_150 sn_174 1.651580941801711e-19
Rsub_150_226 sn_150 sn_226 3039792.8257871
Csub_150_226 sn_150 sn_226 3.466184738922714e-18
Rsub_150_165 sn_150 sn_165 2355945.799556224
Csub_150_165 sn_150 sn_165 4.47229452571222e-18
Rsub_150_218 sn_150 sn_218 1677649.58914046
Csub_150_218 sn_150 sn_218 6.280503133928189e-18
Rsub_150_169 sn_150 sn_169 47940229.6239156
Csub_150_169 sn_150 sn_169 2.197837512437308e-19
Rsub_150_160 sn_150 sn_160 1819515.383205617
Csub_150_160 sn_150 sn_160 5.79081858800603e-18
Rsub_150_183 sn_150 sn_183 8623953.054904917
Csub_150_183 sn_150 sn_183 1.221769580046278e-18
Rsub_150_197 sn_150 sn_197 101544027.450054
Csub_150_197 sn_150 sn_197 1.037627102924643e-19
Rsub_150_177 sn_150 sn_177 485900.4444874399
Csub_150_177 sn_150 sn_177 2.168444919482341e-17
Rsub_150_214 sn_150 sn_214 2419983.241800693
Csub_150_214 sn_150 sn_214 4.353948953129887e-18
Rsub_150_190 sn_150 sn_190 472999.9176738181
Csub_150_190 sn_150 sn_190 2.227586751821802e-17
Rsub_150_153 sn_150 sn_153 154303.3479242733
Csub_150_153 sn_150 sn_153 6.828421835280555e-17
Rsub_150_227 sn_150 sn_227 628815.5765014593
Csub_150_227 sn_150 sn_227 1.675607904125375e-17
Rsub_150_195 sn_150 sn_195 118174.4247337181
Csub_150_195 sn_150 sn_195 8.916043827564049e-17
Rsub_150_158 sn_150 sn_158 803224.413482882
Csub_150_158 sn_150 sn_158 1.311773313331262e-17
Rsub_150_178 sn_150 sn_178 3072275.177301934
Csub_150_178 sn_150 sn_178 3.42953768597093e-18
Rsub_150_215 sn_150 sn_215 554187.7563101752
Csub_150_215 sn_150 sn_215 1.901247976386689e-17
Rsub_150_159 sn_150 sn_159 1277224.048138407
Csub_150_159 sn_150 sn_159 8.249518569265311e-18
Rsub_150_196 sn_150 sn_196 5265976.923838368
Csub_150_196 sn_150 sn_196 2.00086017364276e-18
Rsub_150_210 sn_150 sn_210 40022.15950369243
Csub_150_210 sn_150 sn_210 2.632662413245819e-16
Rsub_150_184 sn_150 sn_184 5097289.63445615
Csub_150_184 sn_150 sn_184 2.067075692738064e-18
Rsub_150_181 sn_150 sn_181 104520.4438836418
Csub_150_181 sn_150 sn_181 1.008078717495672e-16
Rsub_150_151 sn_150 sn_151 5793010.081505264
Csub_150_151 sn_150 sn_151 1.81882706123173e-18
Rsub_150_230 sn_150 0 41297.52195237971
Csub_150_230 sn_150 0 2.551359743662017e-16
Rsub_150_168 sn_150 sn_168 34647.55071081312
Csub_150_168 sn_150 sn_168 3.041047140726654e-16
Rsub_150_219 sn_150 sn_219 30923.26684459286
Csub_150_219 sn_150 sn_219 3.407299608796791e-16
Rsub_150_222 sn_150 sn_222 40782.89396222675
Csub_150_222 sn_150 sn_222 2.583554642294127e-16
Rsub_150_228 sn_150 sn_228 684782.014158133
Csub_150_228 sn_150 sn_228 1.538662418752848e-17
Rsub_150_154 sn_150 sn_154 2088817.548607719
Csub_150_154 sn_150 sn_154 5.044233523053745e-18
Rsub_150_176 sn_150 sn_176 1940805.078124156
Csub_150_176 sn_150 sn_176 5.428924120712739e-18
Rsub_150_213 sn_150 sn_213 6902337.780733591
Csub_150_213 sn_150 sn_213 1.526509399705177e-18
Rsub_150_212 sn_150 sn_212 951621.1051569657
Csub_150_212 sn_150 sn_212 1.107214147009913e-17
Rsub_150_202 sn_150 sn_202 3602342.985746429
Csub_150_202 sn_150 sn_202 2.924897363721398e-18
Rsub_150_216 sn_150 sn_216 594969.355996146
Csub_150_216 sn_150 sn_216 1.770928770707689e-17
Rsub_150_155 sn_150 sn_155 675108.9671940146
Csub_150_155 sn_150 sn_155 1.560708569169694e-17
Rsub_150_192 sn_150 sn_192 1047806.987392295
Csub_150_192 sn_150 sn_192 1.005574846227398e-17
Rsub_150_157 sn_150 sn_157 599091.469257588
Csub_150_157 sn_150 sn_157 1.75874370491156e-17
Rsub_150_180 sn_150 sn_180 856195.9736172917
Csub_150_180 sn_150 sn_180 1.230615866799167e-17
Rsub_150_199 sn_150 sn_199 10500534.07481783
Csub_150_199 sn_150 sn_199 1.0034235808537e-18
Rsub_71_168 sn_71 sn_168 5223582.307357308
Csub_71_168 sn_71 sn_168 2.017099163420778e-18
Rsub_71_77 sn_71 sn_77 3799966.90428545
Csub_71_77 sn_71 sn_77 2.7727829656483e-18
Rsub_71_85 sn_71 sn_85 153473.1559286598
Csub_71_85 sn_71 sn_85 6.865359247012396e-17
Rsub_71_156 sn_71 sn_156 6923063.440188653
Csub_71_156 sn_71 sn_156 1.521939469897864e-18
Rsub_71_110 sn_71 sn_110 3645118.636078625
Csub_71_110 sn_71 sn_110 2.890573546205624e-18
Rsub_71_79 sn_71 sn_79 7837431.740088741
Csub_71_79 sn_71 sn_79 1.344379619708267e-18
Rsub_71_82 sn_71 sn_82 20230697.334008
Csub_71_82 sn_71 sn_82 5.208166247694325e-19
Rsub_71_198 sn_71 sn_198 1519705.782382464
Csub_71_198 sn_71 sn_198 6.933239067967361e-18
Rsub_71_213 sn_71 sn_213 6896062.947575726
Csub_71_213 sn_71 sn_213 1.527898393957388e-18
Rsub_71_189 sn_71 sn_189 4094154.699377135
Csub_71_189 sn_71 sn_189 2.573543081758237e-18
Rsub_71_144 sn_71 sn_144 11863003.51262557
Csub_71_144 sn_71 sn_144 8.881800878686597e-19
Rsub_71_173 sn_71 sn_173 6991246.825809347
Csub_71_173 sn_71 sn_173 1.507096482895272e-18
Rsub_71_177 sn_71 sn_177 1385223.352102129
Csub_71_177 sn_71 sn_177 7.606342678413911e-18
Rsub_71_214 sn_71 sn_214 8596718.580243936
Csub_71_214 sn_71 sn_214 1.225640156052546e-18
Rsub_71_118 sn_71 sn_118 4951663.336521111
Csub_71_118 sn_71 sn_118 2.127867503535209e-18
Rsub_71_97 sn_71 sn_97 15489054.68196824
Csub_71_97 sn_71 sn_97 6.80253489872185e-19
Rsub_71_228 sn_71 sn_228 8074230.593567953
Csub_71_228 sn_71 sn_228 1.304952017424857e-18
Rsub_71_146 sn_71 sn_146 20171566.5246511
Csub_71_146 sn_71 sn_146 5.223433435055064e-19
Rsub_71_105 sn_71 sn_105 2484800.575357664
Csub_71_105 sn_71 sn_105 4.240373898301022e-18
Rsub_71_90 sn_71 sn_90 253089375.8131143
Csub_71_90 sn_71 sn_90 4.163147294657809e-20
Rsub_71_202 sn_71 sn_202 127527.9016237849
Csub_71_202 sn_71 sn_202 8.262100581967761e-17
Rsub_71_179 sn_71 sn_179 235201.692957316
Csub_71_179 sn_71 sn_179 4.479765162295045e-17
Rsub_71_100 sn_71 sn_100 7063.877900466908
Csub_71_100 sn_71 sn_100 1.491600456674592e-15
Rsub_71_122 sn_71 sn_122 588934.4169704311
Csub_71_122 sn_71 sn_122 1.78907586288322e-17
Rsub_71_212 sn_71 sn_212 2914393.585484674
Csub_71_212 sn_71 sn_212 3.615326205323686e-18
Rsub_71_138 sn_71 sn_138 1145397.448880484
Csub_71_138 sn_71 sn_138 9.198975877350172e-18
Rsub_71_217 sn_71 sn_217 30608.08433600279
Csub_71_217 sn_71 sn_217 3.442385804536108e-16
Rsub_71_89 sn_71 sn_89 295390.3052024382
Csub_71_89 sn_71 sn_89 3.566969977233712e-17
Rsub_71_163 sn_71 sn_163 1795711.222549266
Csub_71_163 sn_71 sn_163 5.867582365093186e-18
Rsub_71_117 sn_71 sn_117 51194.93914207865
Csub_71_117 sn_71 sn_117 2.058110367704247e-16
Rsub_71_227 sn_71 sn_227 3997220.762826984
Csub_71_227 sn_71 sn_227 2.635952359753632e-18
Rsub_71_175 sn_71 sn_175 290514.2489489691
Csub_71_175 sn_71 sn_175 3.626838800626544e-17
Rsub_71_220 sn_71 sn_220 253225.5265109815
Csub_71_220 sn_71 sn_220 4.160908912859176e-17
Rsub_71_72 sn_71 sn_72 19183758.67176614
Csub_71_72 sn_71 sn_72 5.492397857223445e-19
Rsub_71_230 sn_71 0 982171.1804018844
Csub_71_230 sn_71 0 1.072774656034877e-17
Rsub_71_109 sn_71 sn_109 4957.721281604081
Csub_71_109 sn_71 sn_109 2.12526741697365e-15
Rsub_71_188 sn_71 sn_188 20278933.38264583
Csub_71_188 sn_71 sn_188 5.195777955090498e-19
Rsub_71_111 sn_71 sn_111 4206.251281779327
Csub_71_111 sn_71 sn_111 2.504958167352489e-15
Rsub_71_106 sn_71 sn_106 3189.496330876825
Csub_71_106 sn_71 sn_106 3.303494473478016e-15
Rsub_71_229 sn_71 sn_229 13744.9115614127
Csub_71_229 sn_71 sn_229 7.66573393735759e-16
Rsub_71_157 sn_71 sn_157 139601.6164810953
Csub_71_157 sn_71 sn_157 7.547536889486407e-17
Rsub_71_83 sn_71 sn_83 14688.60859662846
Csub_71_83 sn_71 sn_83 7.1732345735242e-16
Rsub_71_162 sn_71 sn_162 2997948.481755584
Csub_71_162 sn_71 sn_162 3.514564565185552e-18
Rsub_71_94 sn_71 sn_94 2126.143177680195
Csub_71_94 sn_71 sn_94 4.95567919077125e-15
Rsub_71_126 sn_71 sn_126 10562220.48744281
Csub_71_126 sn_71 sn_126 9.97563297864932e-19
Rsub_71_113 sn_71 sn_113 109783.0483793298
Csub_71_113 sn_71 sn_113 9.597550494156105e-17
Rsub_71_192 sn_71 sn_192 11363147.15400721
Csub_71_192 sn_71 sn_192 9.272504667436534e-19
Rsub_71_187 sn_71 sn_187 122173.9825838701
Csub_71_187 sn_71 sn_187 8.624163082346036e-17
Rsub_71_108 sn_71 sn_108 214043.385415545
Csub_71_108 sn_71 sn_108 4.922592436937219e-17
Rsub_71_193 sn_71 sn_193 436831.8463403984
Csub_71_193 sn_71 sn_193 2.412022747540141e-17
Rsub_71_119 sn_71 sn_119 81134.37788595095
Csub_71_119 sn_71 sn_119 1.298645996527013e-16
Rsub_71_121 sn_71 sn_121 18888.30529680952
Csub_71_121 sn_71 sn_121 5.578310672482485e-16
Rsub_71_200 sn_71 sn_200 11567482.86330274
Csub_71_200 sn_71 sn_200 9.108708979078295e-19
Rsub_71_87 sn_71 sn_87 46115.00721492094
Csub_71_87 sn_71 sn_87 2.284827464760934e-16
Rsub_71_172 sn_71 sn_172 722891.9375761081
Csub_71_172 sn_71 sn_172 1.457546135811024e-17
Rsub_71_98 sn_71 sn_98 705396.1064460813
Csub_71_98 sn_71 sn_98 1.493697428429935e-17
Rsub_71_209 sn_71 sn_209 81165.72302343216
Csub_71_209 sn_71 sn_209 1.298144476479088e-16
Rsub_71_199 sn_71 sn_199 16881562.95805946
Csub_71_199 sn_71 sn_199 6.241414689153386e-19
Rsub_71_195 sn_71 sn_195 648324.2580031552
Csub_71_195 sn_71 sn_195 1.625187299744493e-17
Rsub_71_143 sn_71 sn_143 7958556.79998698
Csub_71_143 sn_71 sn_143 1.323918867079926e-18
Rsub_71_222 sn_71 sn_222 1117558.715163416
Csub_71_222 sn_71 sn_222 9.428125215496438e-18
Rsub_71_206 sn_71 sn_206 1909997.523773608
Csub_71_206 sn_71 sn_206 5.516490660895165e-18
Rsub_71_226 sn_71 sn_226 2371197.731175067
Csub_71_226 sn_71 sn_226 4.443527995874286e-18
Rsub_71_210 sn_71 sn_210 3830520.63530763
Csub_71_210 sn_71 sn_210 2.750666164048432e-18
Rsub_71_92 sn_71 sn_92 24260914.86919622
Csub_71_92 sn_71 sn_92 4.342986882002558e-19
Rsub_71_102 sn_71 sn_102 2603321.017094153
Csub_71_102 sn_71 sn_102 4.047323950079313e-18
Rsub_71_80 sn_71 sn_80 60372416.9349251
Csub_71_80 sn_71 sn_80 1.74524791902686e-19
Rsub_71_129 sn_71 sn_129 15025797.83835308
Csub_71_129 sn_71 sn_129 7.012262254278317e-19
Rsub_71_208 sn_71 sn_208 9561163.586703006
Csub_71_208 sn_71 sn_208 1.102008495794738e-18
Rsub_71_153 sn_71 sn_153 4276570.372061443
Csub_71_153 sn_71 sn_153 2.463769466080616e-18
Rsub_71_99 sn_71 sn_99 15896762.45761328
Csub_71_99 sn_71 sn_99 6.628068784649839e-19
Rsub_71_211 sn_71 sn_211 5671409.756271633
Csub_71_211 sn_71 sn_211 1.857824413159075e-18
Rsub_71_167 sn_71 sn_167 499700.5246863047
Csub_71_167 sn_71 sn_167 2.108559623555419e-17
Rsub_71_155 sn_71 sn_155 1232428.499737391
Csub_71_155 sn_71 sn_155 8.549366964878809e-18
Rsub_71_76 sn_71 sn_76 14478185.80254605
Csub_71_76 sn_71 sn_76 7.277488799996694e-19
Rsub_71_91 sn_71 sn_91 15681668.85934827
Csub_71_91 sn_71 sn_91 6.718980994136294e-19
Rsub_71_194 sn_71 sn_194 55428.40189532077
Csub_71_194 sn_71 sn_194 1.900917786179126e-16
Rsub_71_115 sn_71 sn_115 122761.0670830831
Csub_71_115 sn_71 sn_115 8.58291944880134e-17
Rsub_71_215 sn_71 sn_215 2358887.795339667
Csub_71_215 sn_71 sn_215 4.466716697185169e-18
Rsub_71_140 sn_71 sn_140 3637315.824518204
Csub_71_140 sn_71 sn_140 2.896774437679097e-18
Rsub_71_186 sn_71 sn_186 22961254.30432929
Csub_71_186 sn_71 sn_186 4.588810072210809e-19
Rsub_71_158 sn_71 sn_158 3510798.675333755
Csub_71_158 sn_71 sn_158 3.001164258223479e-18
Rsub_71_152 sn_71 sn_152 306898.1895147793
Csub_71_152 sn_71 sn_152 3.433217875572575e-17
Rsub_71_101 sn_71 sn_101 14375606.91806832
Csub_71_101 sn_71 sn_101 7.329418202849561e-19
Rsub_71_81 sn_71 sn_81 1190997.228543188
Csub_71_81 sn_71 sn_81 8.846774156744337e-18
Rsub_71_225 sn_71 sn_225 4683930.840193881
Csub_71_225 sn_71 sn_225 2.249495960062866e-18
Rsub_156_169 sn_156 sn_169 959245.109443843
Csub_156_169 sn_156 sn_169 1.098414096511673e-17
Rsub_156_207 sn_156 sn_207 5330122.900169144
Csub_156_207 sn_156 sn_207 1.976780592037688e-18
Rsub_156_220 sn_156 sn_220 267537.3969504107
Csub_156_220 sn_156 sn_220 3.938321753269876e-17
Rsub_156_214 sn_156 sn_214 8793215.004935225
Csub_156_214 sn_156 sn_214 1.198251549213383e-18
Rsub_156_204 sn_156 sn_204 18804477.27401569
Csub_156_204 sn_156 sn_204 5.603178088225548e-19
Rsub_156_174 sn_156 sn_174 27578567.38809992
Csub_156_174 sn_156 sn_174 3.820533298178667e-19
Rsub_156_209 sn_156 sn_209 688418.8936063402
Csub_156_209 sn_156 sn_209 1.530533749158706e-17
Rsub_156_198 sn_156 sn_198 7709592.732278176
Csub_156_198 sn_156 sn_198 1.366671868167086e-18
Rsub_156_211 sn_156 sn_211 12499176.17201557
Csub_156_211 sn_156 sn_211 8.429742374397568e-19
Rsub_156_182 sn_156 sn_182 33454380.65746642
Csub_156_182 sn_156 sn_182 3.149507865684683e-19
Rsub_156_203 sn_156 sn_203 4444172.311761919
Csub_156_203 sn_156 sn_203 2.370853955042248e-18
Rsub_156_222 sn_156 sn_222 755625.186677053
Csub_156_222 sn_156 sn_222 1.394406074334999e-17
Rsub_156_185 sn_156 sn_185 13018.81310857712
Csub_156_185 sn_156 sn_185 8.093275027727608e-16
Rsub_156_226 sn_156 sn_226 1263651.953823687
Csub_156_226 sn_156 sn_226 8.338121482222725e-18
Rsub_156_186 sn_156 sn_186 22432181.6544489
Csub_156_186 sn_156 sn_186 4.697039130895383e-19
Rsub_156_178 sn_156 sn_178 14723035.10160089
Csub_156_178 sn_156 sn_178 7.156461578417573e-19
Rsub_156_168 sn_156 sn_168 6028929.005935602
Csub_156_168 sn_156 sn_168 1.74765426692811e-18
Rsub_156_230 sn_156 0 17381.84538576588
Csub_156_230 sn_156 0 6.061774954492694e-16
Rsub_156_179 sn_156 sn_179 300541.699152667
Csub_156_179 sn_156 sn_179 3.505830815469555e-17
Rsub_156_162 sn_156 sn_162 1756144.822813578
Csub_156_162 sn_156 sn_162 5.999780522285829e-18
Rsub_156_196 sn_156 sn_196 6548462.491334469
Csub_156_196 sn_156 sn_196 1.609001122961741e-18
Rsub_156_159 sn_156 sn_159 61559.50057480951
Csub_156_159 sn_156 sn_159 1.711593402130619e-16
Rsub_156_183 sn_156 sn_183 1673948.819202662
Csub_156_183 sn_156 sn_183 6.294388084845243e-18
Rsub_156_208 sn_156 sn_208 19374410.6549207
Csub_156_208 sn_156 sn_208 5.438350456122882e-19
Rsub_156_197 sn_156 sn_197 42252914.77602509
Csub_156_197 sn_156 sn_197 2.493670213778613e-19
Rsub_156_180 sn_156 sn_180 4874104.056522748
Csub_156_180 sn_156 sn_180 2.161727238492087e-18
Rsub_156_158 sn_156 sn_158 1847584.802473788
Csub_156_158 sn_156 sn_158 5.702841616862392e-18
Rsub_156_195 sn_156 sn_195 106950.1107768158
Csub_156_195 sn_156 sn_195 9.851774276529365e-17
Rsub_156_181 sn_156 sn_181 25533.4586892145
Csub_156_181 sn_156 sn_181 4.126539859122447e-16
Rsub_156_164 sn_156 sn_164 27888589.71128018
Csub_156_164 sn_156 sn_164 3.778062502016113e-19
Rsub_156_219 sn_156 sn_219 11722654.10503692
Csub_156_219 sn_156 sn_219 8.988138187667544e-19
Rsub_156_190 sn_156 sn_190 3975988.072980643
Csub_156_190 sn_156 sn_190 2.65002895100015e-18
Rsub_156_192 sn_156 sn_192 10737423.19178214
Csub_156_192 sn_156 sn_192 9.812860417287145e-19
Rsub_156_175 sn_156 sn_175 156890.312468643
Csub_156_175 sn_156 sn_175 6.715827979714096e-17
Rsub_156_210 sn_156 sn_210 10702029.90260824
Csub_156_210 sn_156 sn_210 9.84531308370023e-19
Rsub_156_177 sn_156 sn_177 92321.49752587454
Csub_156_177 sn_156 sn_177 1.1412816932781e-16
Rsub_156_228 sn_156 sn_228 47520043.47051088
Csub_156_228 sn_156 sn_228 2.217271435950714e-19
Rsub_77_137 sn_77 sn_137 226207.9019263703
Csub_77_137 sn_77 sn_137 4.657875968302637e-17
Rsub_77_125 sn_77 sn_125 232151.7148695675
Csub_77_125 sn_77 sn_125 4.538619716055009e-17
Rsub_77_225 sn_77 sn_225 532842.9780072002
Csub_77_225 sn_77 sn_225 1.977408718349972e-17
Rsub_77_106 sn_77 sn_106 1763432.490265396
Csub_77_106 sn_77 sn_106 5.974985467486913e-18
Rsub_77_141 sn_77 sn_141 68244.0574520517
Csub_77_141 sn_77 sn_141 1.543941538006139e-16
Rsub_77_177 sn_77 sn_177 33840.88437802941
Csub_77_177 sn_77 sn_177 3.113536686727556e-16
Rsub_77_149 sn_77 sn_149 1113127.211753027
Csub_77_149 sn_77 sn_149 9.465659801485262e-18
Rsub_77_156 sn_77 sn_156 58415.39399847548
Csub_77_156 sn_77 sn_156 1.803716928196184e-16
Rsub_77_196 sn_77 sn_196 6413250.154232346
Csub_77_196 sn_77 sn_196 1.64292414124476e-18
Rsub_77_224 sn_77 sn_224 1841819.96928571
Csub_77_224 sn_77 sn_224 5.720691315078008e-18
Rsub_77_100 sn_77 sn_100 604259.7084690063
Csub_77_100 sn_77 sn_100 1.74370115275863e-17
Rsub_77_162 sn_77 sn_162 3493139.231827789
Csub_77_162 sn_77 sn_162 3.016336539416087e-18
Rsub_77_168 sn_77 sn_168 2058381.49493457
Csub_77_168 sn_77 sn_168 5.118819581384221e-18
Rsub_77_154 sn_77 sn_154 62959.70264557077
Csub_77_154 sn_77 sn_154 1.673528155230454e-16
Rsub_77_213 sn_77 sn_213 5268248.875888906
Csub_77_213 sn_77 sn_213 1.99999729520223e-18
Rsub_77_129 sn_77 sn_129 31090054.77174512
Csub_77_129 sn_77 sn_129 3.389020566089718e-19
Rsub_77_140 sn_77 sn_140 9851950.426203754
Csub_77_140 sn_77 sn_140 1.069481985435651e-18
Rsub_77_105 sn_77 sn_105 10504163.21884284
Csub_77_105 sn_77 sn_105 1.003076902244739e-18
Rsub_77_110 sn_77 sn_110 14135416.93261404
Csub_77_110 sn_77 sn_110 7.453960185581528e-19
Rsub_77_201 sn_77 sn_201 12436342.75153996
Csub_77_201 sn_77 sn_201 8.472332833481365e-19
Rsub_77_204 sn_77 sn_204 3655933.836883597
Csub_77_204 sn_77 sn_204 2.882022479709738e-18
Rsub_77_112 sn_77 sn_112 5677900.994700552
Csub_77_112 sn_77 sn_112 1.855700462558996e-18
Rsub_77_173 sn_77 sn_173 13237803.15850411
Csub_77_173 sn_77 sn_173 7.95938976888416e-19
Rsub_77_97 sn_77 sn_97 11712211.94794336
Csub_77_97 sn_77 sn_97 8.996151665510275e-19
Rsub_77_109 sn_77 sn_109 403409.9390900942
Csub_77_109 sn_77 sn_109 2.611855207632074e-17
Rsub_77_146 sn_77 sn_146 5003234.11623086
Csub_77_146 sn_77 sn_146 2.105934533035116e-18
Rsub_77_214 sn_77 sn_214 2480662.85318775
Csub_77_214 sn_77 sn_214 4.247446801845805e-18
Rsub_77_226 sn_77 sn_226 2217490.934509232
Csub_77_226 sn_77 sn_226 4.751533969432846e-18
Rsub_77_145 sn_77 sn_145 34972.10543373734
Csub_77_145 sn_77 sn_145 3.012825042002056e-16
Rsub_77_119 sn_77 sn_119 494879.8279075779
Csub_77_119 sn_77 sn_119 2.129099411220649e-17
Rsub_77_211 sn_77 sn_211 6611907.396952208
Csub_77_211 sn_77 sn_211 1.593561867954601e-18
Rsub_77_103 sn_77 sn_103 9037208.668268319
Csub_77_103 sn_77 sn_103 1.165900212000855e-18
Rsub_77_191 sn_77 sn_191 194558.3901656309
Csub_77_191 sn_77 sn_191 5.41558937307207e-17
Rsub_77_185 sn_77 sn_185 379271.3367449169
Csub_77_185 sn_77 sn_185 2.778085892980736e-17
Rsub_77_80 sn_77 sn_80 1624266.993454587
Csub_77_80 sn_77 sn_80 6.486915971751902e-18
Rsub_77_166 sn_77 sn_166 1551241.419031129
Csub_77_166 sn_77 sn_166 6.792291240399482e-18
Rsub_77_82 sn_77 sn_82 21921061.33973309
Csub_77_82 sn_77 sn_82 4.806557191248794e-19
Rsub_77_182 sn_77 sn_182 5497676.2449654
Csub_77_182 sn_77 sn_182 1.916534010506527e-18
Rsub_77_131 sn_77 sn_131 1617950.90732436
Csub_77_131 sn_77 sn_131 6.512239311175647e-18
Rsub_77_181 sn_77 sn_181 25457.45950156622
Csub_77_181 sn_77 sn_181 4.13885898613794e-16
Rsub_77_153 sn_77 sn_153 52203.77953414881
Csub_77_153 sn_77 sn_153 2.018337292099247e-16
Rsub_77_127 sn_77 sn_127 451006.794264506
Csub_77_127 sn_77 sn_127 2.336213918775373e-17
Rsub_77_78 sn_77 sn_78 7900183.359785631
Csub_77_78 sn_77 sn_78 1.333701133553931e-18
Rsub_77_148 sn_77 sn_148 1739986.688344666
Csub_77_148 sn_77 sn_148 6.055496615467713e-18
Rsub_77_92 sn_77 sn_92 39510.95262633127
Csub_77_92 sn_77 sn_92 2.666724743864611e-16
Rsub_77_87 sn_77 sn_87 171724.754605204
Csub_77_87 sn_77 sn_87 6.135681210582262e-17
Rsub_77_184 sn_77 sn_184 2179084.974921173
Csub_77_184 sn_77 sn_184 4.835278854883185e-18
Rsub_77_199 sn_77 sn_199 11107771.6883953
Csub_77_199 sn_77 sn_199 9.485686056401266e-19
Rsub_77_218 sn_77 sn_218 2698798.102399115
Csub_77_218 sn_77 sn_218 3.904139213994379e-18
Rsub_77_117 sn_77 sn_117 228591.8056574788
Csub_77_117 sn_77 sn_117 4.609300614221417e-17
Rsub_77_99 sn_77 sn_99 3312980.217178018
Csub_77_99 sn_77 sn_99 3.180364146938653e-18
Rsub_77_178 sn_77 sn_178 5125017.05173371
Csub_77_178 sn_77 sn_178 2.055892379648899e-18
Rsub_77_175 sn_77 sn_175 27964.01959397105
Csub_77_175 sn_77 sn_175 3.767871591858572e-16
Rsub_77_96 sn_77 sn_96 28754.63706387731
Csub_77_96 sn_77 sn_96 3.664272819310365e-16
Rsub_77_98 sn_77 sn_98 145942.5858251911
Csub_77_98 sn_77 sn_98 7.219608617083513e-17
Rsub_77_135 sn_77 sn_135 1048796.735939914
Csub_77_135 sn_77 sn_135 1.004625886138688e-17
Rsub_77_209 sn_77 sn_209 46845.61626007475
Csub_77_209 sn_77 sn_209 2.249193060826475e-16
Rsub_77_217 sn_77 sn_217 164565.9850033901
Csub_77_217 sn_77 sn_217 6.402588908037677e-17
Rsub_77_138 sn_77 sn_138 103707836.7416274
Csub_77_138 sn_77 sn_138 1.015977560932071e-19
Rsub_77_143 sn_77 sn_143 2004410.464440076
Csub_77_143 sn_77 sn_143 5.256649618007918e-18
Rsub_77_222 sn_77 sn_222 42157.88039115214
Csub_77_222 sn_77 sn_222 2.499291568852532e-16
Rsub_77_152 sn_77 sn_152 63008.88183173953
Csub_77_152 sn_77 sn_152 1.672221946481591e-16
Rsub_77_189 sn_77 sn_189 84394.94788463332
Csub_77_189 sn_77 sn_189 1.248473251815171e-16
Rsub_77_157 sn_77 sn_157 4855.551308604121
Csub_77_157 sn_77 sn_157 2.169987058639288e-15
Rsub_77_163 sn_77 sn_163 17309.18395387695
Csub_77_163 sn_77 sn_163 6.087221402410491e-16
Rsub_77_89 sn_77 sn_89 1962.995107512212
Csub_77_89 sn_77 sn_89 5.367554642346174e-15
Rsub_77_79 sn_77 sn_79 463.9682276458188
Csub_77_79 sn_77 sn_79 2.270949361272487e-14
Rsub_77_158 sn_77 sn_158 3034590.181035958
Csub_77_158 sn_77 sn_158 3.472127329771108e-18
Rsub_77_167 sn_77 sn_167 116427.5353058042
Csub_77_167 sn_77 sn_167 9.049820967656203e-17
Rsub_77_151 sn_77 sn_151 58110.8943529325
Csub_77_151 sn_77 sn_151 1.813168360176561e-16
Rsub_77_230 sn_77 0 4369.228673601366
Csub_77_230 sn_77 0 2.411520268071763e-15
Rsub_77_128 sn_77 sn_128 8124.841949117785
Csub_77_128 sn_77 sn_128 1.296823195849869e-15
Rsub_77_207 sn_77 sn_207 6996898.012848139
Csub_77_207 sn_77 sn_207 1.505879245757513e-18
Rsub_77_179 sn_77 sn_179 2069.158627912961
Csub_77_179 sn_77 sn_179 5.092158406848455e-15
Rsub_77_111 sn_77 sn_111 22196.04927713748
Csub_77_111 sn_77 sn_111 4.747008519702135e-16
Rsub_77_190 sn_77 sn_190 785279.7427588354
Csub_77_190 sn_77 sn_190 1.341749051772729e-17
Rsub_77_155 sn_77 sn_155 506329.8897245276
Csub_77_155 sn_77 sn_155 2.080952303242941e-17
Rsub_77_81 sn_77 sn_81 1753.421121415394
Csub_77_81 sn_77 sn_81 6.009100365874889e-15
Rsub_77_160 sn_77 sn_160 4612985.40929032
Csub_77_160 sn_77 sn_160 2.284092093811971e-18
Rsub_77_187 sn_77 sn_187 268945.3489260424
Csub_77_187 sn_77 sn_187 3.91770430100557e-17
Rsub_77_220 sn_77 sn_220 4136.379741727299
Csub_77_220 sn_77 sn_220 2.547271807745123e-15
Rsub_77_101 sn_77 sn_101 1435143.127309695
Csub_77_101 sn_77 sn_101 7.341764944365924e-18
Rsub_77_180 sn_77 sn_180 3454480.254318157
Csub_77_180 sn_77 sn_180 3.05009226469285e-18
Rsub_77_215 sn_77 sn_215 643078.0558324428
Csub_77_215 sn_77 sn_215 1.638445505435709e-17
Rsub_77_192 sn_77 sn_192 3663382.215612988
Csub_77_192 sn_77 sn_192 2.87616275946433e-18
Rsub_77_113 sn_77 sn_113 513623.1799135532
Csub_77_113 sn_77 sn_113 2.051403424589087e-17
Rsub_77_221 sn_77 sn_221 9072870.524919551
Csub_77_221 sn_77 sn_221 1.161317520545509e-18
Rsub_77_229 sn_77 sn_229 496357.2905988245
Csub_77_229 sn_77 sn_229 2.122761909977868e-17
Rsub_77_150 sn_77 sn_150 7612703.234146295
Csub_77_150 sn_77 sn_150 1.384065972120032e-18
Rsub_77_91 sn_77 sn_91 9478.238691022994
Csub_77_91 sn_77 sn_91 1.111649943170274e-15
Rsub_77_208 sn_77 sn_208 8024513.230103132
Csub_77_208 sn_77 sn_208 1.313037090237881e-18
Rsub_77_216 sn_77 sn_216 22107086.18471825
Csub_77_216 sn_77 sn_216 4.766111379035313e-19
Rsub_77_126 sn_77 sn_126 3090055.820986455
Csub_77_126 sn_77 sn_126 3.409803612824826e-18
Rsub_77_228 sn_77 sn_228 51618343.0475329
Csub_77_228 sn_77 sn_228 2.04122854011944e-19
Rsub_77_133 sn_77 sn_133 11575125.02104855
Csub_77_133 sn_77 sn_133 9.102695204648027e-19
Rsub_77_90 sn_77 sn_90 70256664.66784975
Csub_77_90 sn_77 sn_90 1.49971302395908e-19
Rsub_77_83 sn_77 sn_83 209695.5778715542
Csub_77_83 sn_77 sn_83 5.024656985701417e-17
Rsub_77_195 sn_77 sn_195 596443.535377781
Csub_77_195 sn_77 sn_195 1.766551714833543e-17
Rsub_77_193 sn_77 sn_193 700030.3122095431
Csub_77_193 sn_77 sn_193 1.505146751284689e-17
Rsub_77_114 sn_77 sn_114 8263946.963142767
Csub_77_114 sn_77 sn_114 1.274994085661822e-18
Rsub_77_206 sn_77 sn_206 6352860.915151373
Csub_77_206 sn_77 sn_206 1.658541504836163e-18
Rsub_77_121 sn_77 sn_121 4343338.329027113
Csub_77_121 sn_77 sn_121 2.425895176485164e-18
Rsub_77_200 sn_77 sn_200 2603803.715784709
Csub_77_200 sn_77 sn_200 4.046573648526581e-18
Rsub_77_188 sn_77 sn_188 34205096.87837913
Csub_77_188 sn_77 sn_188 3.080384054953535e-19
Rsub_77_210 sn_77 sn_210 2065724.093206569
Csub_77_210 sn_77 sn_210 5.10062478182868e-18
Rsub_77_102 sn_77 sn_102 4215604.832278802
Csub_77_102 sn_77 sn_102 2.499400186078249e-18
Rsub_77_164 sn_77 sn_164 30476209.21152618
Csub_77_164 sn_77 sn_164 3.457281523794329e-19
Rsub_77_172 sn_77 sn_172 1334848.832535786
Csub_77_172 sn_77 sn_172 7.893390806069066e-18
Rsub_77_122 sn_77 sn_122 250741.7000552045
Csub_77_122 sn_77 sn_122 4.202126530972008e-17
Rsub_77_123 sn_77 sn_123 1787614271.523883
Rsub_77_202 sn_77 sn_202 79516.37870851725
Csub_77_202 sn_77 sn_202 1.325070843687881e-16
Rsub_77_115 sn_77 sn_115 40731.07404768992
Csub_77_115 sn_77 sn_115 2.586841557355785e-16
Rsub_77_198 sn_77 sn_198 2050131.749000894
Csub_77_198 sn_77 sn_198 5.13941775076886e-18
Rsub_151_207 sn_151 sn_207 5564069.004602402
Csub_151_207 sn_151 sn_207 1.893665138501085e-18
Rsub_151_166 sn_151 sn_166 5157260.885249215
Csub_151_166 sn_151 sn_166 2.043038685975035e-18
Rsub_151_175 sn_151 sn_175 499257.3186191077
Csub_151_175 sn_151 sn_175 2.110431456743145e-17
Rsub_151_226 sn_151 sn_226 298402.8305720793
Csub_151_226 sn_151 sn_226 3.530959636686459e-17
Rsub_151_173 sn_151 sn_173 16582158.35304294
Csub_151_173 sn_151 sn_173 6.354108601487625e-19
Rsub_151_167 sn_151 sn_167 23739133.41134904
Csub_151_167 sn_151 sn_167 4.43844487482125e-19
Rsub_151_179 sn_151 sn_179 83273.66344478009
Csub_151_179 sn_151 sn_179 1.265284012539798e-16
Rsub_151_200 sn_151 sn_200 12010740.83642348
Csub_151_200 sn_151 sn_200 8.77255087402878e-19
Rsub_151_219 sn_151 sn_219 1500186.842995636
Csub_151_219 sn_151 sn_219 7.023447480175411e-18
Rsub_151_217 sn_151 sn_217 373908.1020972172
Csub_151_217 sn_151 sn_217 2.817933990499752e-17
Rsub_151_228 sn_151 sn_228 18043490.86196677
Csub_151_228 sn_151 sn_228 5.839492802603669e-19
Rsub_151_210 sn_151 sn_210 2267591.138824459
Csub_151_210 sn_151 sn_210 4.646553482164431e-18
Rsub_151_204 sn_151 sn_204 5151430.018999999
Csub_151_204 sn_151 sn_204 2.045351186635231e-18
Rsub_151_197 sn_151 sn_197 31078896.27842849
Csub_151_197 sn_151 sn_197 3.390237352007657e-19
Rsub_151_211 sn_151 sn_211 70956707.59746881
Csub_151_211 sn_151 sn_211 1.484917192325573e-19
Rsub_151_206 sn_151 sn_206 5405733.020254779
Csub_151_206 sn_151 sn_206 1.949131313505639e-18
Rsub_151_153 sn_151 sn_153 1681596.368244404
Csub_151_153 sn_151 sn_153 6.265762522566664e-18
Rsub_151_214 sn_151 sn_214 2804209.29813756
Csub_151_214 sn_151 sn_214 3.757381272941324e-18
Rsub_151_177 sn_151 sn_177 45873.53662925118
Csub_151_177 sn_151 sn_177 2.296854412465646e-16
Rsub_151_156 sn_151 sn_156 249143.9015067916
Csub_151_156 sn_151 sn_156 4.229075421275274e-17
Rsub_151_193 sn_151 sn_193 5897323195.507854
Rsub_151_199 sn_151 sn_199 14448784.27215027
Csub_151_199 sn_151 sn_199 7.292297610490907e-19
Rsub_151_165 sn_151 sn_165 65380.50365021118
Csub_151_165 sn_151 sn_165 1.611563526429942e-16
Rsub_151_154 sn_151 sn_154 7180.858369281553
Csub_151_154 sn_151 sn_154 1.467301394956238e-15
Rsub_151_191 sn_151 sn_191 128445.515625914
Csub_151_191 sn_151 sn_191 8.203076184392889e-17
Rsub_151_229 sn_151 sn_229 79163.07695709952
Csub_151_229 sn_151 sn_229 1.330984583626024e-16
Rsub_151_155 sn_151 sn_155 3248059.578865421
Csub_151_155 sn_151 sn_155 3.243931721816044e-18
Rsub_151_161 sn_151 sn_161 2595.7078084544
Csub_151_161 sn_151 sn_161 4.059194747541286e-15
Rsub_151_183 sn_151 sn_183 527.8187835744726
Csub_151_183 sn_151 sn_183 1.996231250217217e-14
Rsub_151_220 sn_151 sn_220 2956676.389650531
Csub_151_220 sn_151 sn_220 3.563624189347072e-18
Rsub_151_185 sn_151 sn_185 35966.49679378478
Csub_151_185 sn_151 sn_185 2.929527321674199e-16
Rsub_151_222 sn_151 sn_222 657013.5466281942
Csub_151_222 sn_151 sn_222 1.603693494038811e-17
Rsub_151_230 sn_151 0 8300.731957451049
Csub_151_230 sn_151 0 1.269343903193026e-15
Rsub_151_188 sn_151 sn_188 39282588.20636439
Csub_151_188 sn_151 sn_188 2.68222741507723e-19
Rsub_151_189 sn_151 sn_189 1261.480891197629
Csub_151_189 sn_151 sn_189 8.35247174630354e-15
Rsub_151_152 sn_151 sn_152 3330.451729744465
Csub_151_152 sn_151 sn_152 3.163679992154827e-15
Rsub_151_157 sn_151 sn_157 396.9027001078284
Csub_151_157 sn_151 sn_157 2.654676700200706e-14
Rsub_151_186 sn_151 sn_186 32317209.47502403
Csub_151_186 sn_151 sn_186 3.260332087265455e-19
Rsub_151_159 sn_151 sn_159 4102.074575664312
Csub_151_159 sn_151 sn_159 2.568574341563175e-15
Rsub_151_172 sn_151 sn_172 14305528.10189322
Csub_151_172 sn_151 sn_172 7.365322990652533e-19
Rsub_151_163 sn_151 sn_163 1438373.161279662
Csub_151_163 sn_151 sn_163 7.325278158594198e-18
Rsub_151_205 sn_151 sn_205 34413057.71691238
Csub_151_205 sn_151 sn_205 3.061769049674368e-19
Rsub_151_195 sn_151 sn_195 679427.512386644
Csub_151_195 sn_151 sn_195 1.550788466781129e-17
Rsub_151_158 sn_151 sn_158 6276879.278144308
Csub_151_158 sn_151 sn_158 1.678618153278391e-18
Rsub_151_164 sn_151 sn_164 8153455.54408564
Csub_151_164 sn_151 sn_164 1.29227214709878e-18
Rsub_151_184 sn_151 sn_184 2609027.340160327
Csub_151_184 sn_151 sn_184 4.038471862691377e-18
Rsub_151_169 sn_151 sn_169 18731064.17829653
Csub_151_169 sn_151 sn_169 5.625138754496662e-19
Rsub_151_180 sn_151 sn_180 9202371.235725783
Csub_151_180 sn_151 sn_180 1.144974836629594e-18
Rsub_151_181 sn_151 sn_181 137123.0193362466
Csub_151_181 sn_151 sn_181 7.68396404428124e-17
Rsub_157_166 sn_157 sn_166 3477103.710735374
Csub_157_166 sn_157 sn_166 3.030247119089133e-18
Rsub_157_202 sn_157 sn_202 104963.5090422291
Csub_157_202 sn_157 sn_202 1.003823480976703e-16
Rsub_157_227 sn_157 sn_227 682687.8420319353
Csub_157_227 sn_157 sn_227 1.54338232696066e-17
Rsub_157_174 sn_157 sn_174 38948240.70273295
Csub_157_174 sn_157 sn_174 2.705252743672879e-19
Rsub_157_191 sn_157 sn_191 504078.5166560945
Csub_157_191 sn_157 sn_191 2.090246490194795e-17
Rsub_157_170 sn_157 sn_170 1001676.51710383
Csub_157_170 sn_157 sn_170 1.051884847285267e-17
Rsub_157_226 sn_157 sn_226 192397.1060429245
Csub_157_226 sn_157 sn_226 5.476425149492254e-17
Rsub_157_194 sn_157 sn_194 6210633.97154305
Csub_157_194 sn_157 sn_194 1.696523020114834e-18
Rsub_157_187 sn_157 sn_187 309805.8439750107
Csub_157_187 sn_157 sn_187 3.400995722688783e-17
Rsub_157_184 sn_157 sn_184 25768471.07586774
Csub_157_184 sn_157 sn_184 4.088905186189899e-19
Rsub_157_203 sn_157 sn_203 1105269.248321308
Csub_157_203 sn_157 sn_203 9.532956352701298e-18
Rsub_157_171 sn_157 sn_171 12617343.17055658
Csub_157_171 sn_157 sn_171 8.350794109189006e-19
Rsub_157_160 sn_157 sn_160 3901391.946171245
Csub_157_160 sn_157 sn_160 2.700698532115009e-18
Rsub_157_158 sn_157 sn_158 1335858.099701923
Csub_157_158 sn_157 sn_158 7.887427193487889e-18
Rsub_157_204 sn_157 sn_204 3149561.166709728
Csub_157_204 sn_157 sn_204 3.345381449834554e-18
Rsub_157_176 sn_157 sn_176 949329.256342797
Csub_157_176 sn_157 sn_176 1.109887157888805e-17
Rsub_157_186 sn_157 sn_186 68098872.03546792
Csub_157_186 sn_157 sn_186 1.547233190109564e-19
Rsub_157_192 sn_157 sn_192 2031137.03006114
Csub_157_192 sn_157 sn_192 5.187480384773862e-18
Rsub_157_219 sn_157 sn_219 160436.6024714691
Csub_157_219 sn_157 sn_219 6.567381345602686e-17
Rsub_157_207 sn_157 sn_207 1456319.588054022
Csub_157_207 sn_157 sn_207 7.235007747378558e-18
Rsub_157_221 sn_157 sn_221 6535715.046418844
Csub_157_221 sn_157 sn_221 1.61213936461372e-18
Rsub_157_228 sn_157 sn_228 13308997.25568285
Csub_157_228 sn_157 sn_228 7.916812438841696e-19
Rsub_157_229 sn_157 sn_229 479601.6155229407
Csub_157_229 sn_157 sn_229 2.196924105591553e-17
Rsub_157_213 sn_157 sn_213 2987851.871119804
Csub_157_213 sn_157 sn_213 3.526441054215006e-18
Rsub_157_168 sn_157 sn_168 8390737.398623211
Csub_157_168 sn_157 sn_168 1.255727953535868e-18
Rsub_157_205 sn_157 sn_205 21737280.81085339
Csub_157_205 sn_157 sn_205 4.847194823452413e-19
Rsub_157_224 sn_157 sn_224 603386.239142408
Csub_157_224 sn_157 sn_224 1.746225355952017e-17
Rsub_157_215 sn_157 sn_215 740438.1615285996
Csub_157_215 sn_157 sn_215 1.423006545270159e-17
Rsub_157_161 sn_157 sn_161 12263.64043056417
Csub_157_161 sn_157 sn_161 8.591644187455427e-16
Rsub_157_209 sn_157 sn_209 78257.30109913579
Csub_157_209 sn_157 sn_209 1.34638983893432e-16
Rsub_157_172 sn_157 sn_172 574811.6709919765
Csub_157_172 sn_157 sn_172 1.833032284129992e-17
Rsub_157_206 sn_157 sn_206 7008870.432399889
Csub_157_206 sn_157 sn_206 1.503306931388405e-18
Rsub_157_189 sn_157 sn_189 6736.182905986967
Csub_157_189 sn_157 sn_189 1.564162322977515e-15
Rsub_157_162 sn_157 sn_162 4070601.054164022
Csub_157_162 sn_157 sn_162 2.588434327518218e-18
Rsub_157_230 sn_157 0 7594.322615023835
Csub_157_230 sn_157 0 1.387415841590097e-15
Rsub_157_193 sn_157 sn_193 2014676.21508788
Csub_157_193 sn_157 sn_193 5.229864443389184e-18
Rsub_157_220 sn_157 sn_220 10724.78991798738
Csub_157_220 sn_157 sn_220 9.824419483087914e-16
Rsub_157_183 sn_157 sn_183 3938.72164975229
Csub_157_183 sn_157 sn_183 2.675102340093683e-15
Rsub_157_177 sn_157 sn_177 17594.38746099493
Csub_157_177 sn_157 sn_177 5.988548067154013e-16
Rsub_157_159 sn_157 sn_159 10234.25082851626
Csub_157_159 sn_157 sn_159 1.029531489776625e-15
Rsub_157_188 sn_157 sn_188 5469057.984359584
Csub_157_188 sn_157 sn_188 1.926562770473863e-18
Rsub_157_163 sn_157 sn_163 89796.87942519457
Csub_157_163 sn_157 sn_163 1.173368559094243e-16
Rsub_157_200 sn_157 sn_200 2646554.309368873
Csub_157_200 sn_157 sn_200 3.981208118394006e-18
Rsub_157_222 sn_157 sn_222 451279.4054501058
Csub_157_222 sn_157 sn_222 2.334802646648792e-17
Rsub_157_210 sn_157 sn_210 1656427.170724411
Csub_157_210 sn_157 sn_210 6.360969977099595e-18
Rsub_157_164 sn_157 sn_164 9160333.612659205
Csub_157_164 sn_157 sn_164 1.150229232663428e-18
Rsub_157_190 sn_157 sn_190 804245.8033467398
Csub_157_190 sn_157 sn_190 1.310107364985197e-17
Rsub_157_218 sn_157 sn_218 4033263.852187531
Csub_157_218 sn_157 sn_218 2.612396284591028e-18
Rsub_157_216 sn_157 sn_216 198463.8020746005
Csub_157_216 sn_157 sn_216 5.309020280821511e-17
Rsub_157_179 sn_157 sn_179 51861.92059317048
Csub_157_179 sn_157 sn_179 2.031641594009443e-16
Rsub_157_182 sn_157 sn_182 15384884.93198302
Csub_157_182 sn_157 sn_182 6.848594285113e-19
Rsub_157_195 sn_157 sn_195 458467.4773310476
Csub_157_195 sn_157 sn_195 2.298196496634346e-17
Rsub_157_211 sn_157 sn_211 3986240.356402305
Csub_157_211 sn_157 sn_211 2.643213293776263e-18
Rsub_157_212 sn_157 sn_212 1864364.773638926
Csub_157_212 sn_157 sn_212 5.651513937191895e-18
Rsub_181_202 sn_181 sn_202 212580.1056950263
Csub_181_202 sn_181 sn_202 4.956476744510586e-17
Rsub_181_200 sn_181 sn_200 12400917.71913675
Csub_181_200 sn_181 sn_200 8.496535289457163e-19
Rsub_181_183 sn_181 sn_183 354480.3494640217
Csub_181_183 sn_181 sn_183 2.972374496403336e-17
Rsub_181_193 sn_181 sn_193 10668455.97343614
Csub_181_193 sn_181 sn_193 9.876296559188378e-19
Rsub_181_195 sn_181 sn_195 58288.04477213448
Csub_181_195 sn_181 sn_195 1.807657735547708e-16
Rsub_181_226 sn_181 sn_226 541917.5622815397
Csub_181_226 sn_181 sn_226 1.944296371918656e-17
Rsub_181_206 sn_181 sn_206 845937.7625632305
Csub_181_206 sn_181 sn_206 1.245538852681546e-17
Rsub_181_207 sn_181 sn_207 43585.81537497399
Csub_181_207 sn_181 sn_207 2.417411125978342e-16
Rsub_181_184 sn_181 sn_184 2697262.543913157
Csub_181_184 sn_181 sn_184 3.906361850464804e-18
Rsub_181_221 sn_181 sn_221 105895.3902431315
Csub_181_221 sn_181 sn_221 9.949898175962776e-17
Rsub_181_217 sn_181 sn_217 368298.7477086219
Csub_181_217 sn_181 sn_217 2.860852383501966e-17
Rsub_181_191 sn_181 sn_191 24657.33580764483
Csub_181_191 sn_181 sn_191 4.273163809921119e-16
Rsub_181_228 sn_181 sn_228 22347.22613897308
Csub_181_228 sn_181 sn_228 4.714895458033873e-16
Rsub_181_218 sn_181 sn_218 2328104.620149915
Csub_181_218 sn_181 sn_218 4.525777497727537e-18
Rsub_181_230 sn_181 0 56279.58837223145
Csub_181_230 sn_181 0 1.872167833307881e-16
Rsub_181_227 sn_181 sn_227 924476.3624712876
Csub_181_227 sn_181 sn_227 1.139724489446559e-17
Rsub_181_190 sn_181 sn_190 178184.4357966156
Csub_181_190 sn_181 sn_190 5.91324570809126e-17
Rsub_181_210 sn_181 sn_210 22369.64017377867
Csub_181_210 sn_181 sn_210 4.71017120542721e-16
Rsub_181_219 sn_181 sn_219 164159.8578757645
Csub_181_219 sn_181 sn_219 6.418428742917144e-17
Rsub_181_185 sn_181 sn_185 9652.178970147377
Csub_181_185 sn_181 sn_185 1.091617088205434e-15
Rsub_181_222 sn_181 sn_222 44852.62563353563
Csub_181_222 sn_181 sn_222 2.349134159573488e-16
Rsub_181_203 sn_181 sn_203 84972.68778279584
Csub_181_203 sn_181 sn_203 1.239984726523302e-16
Rsub_181_215 sn_181 sn_215 77042.73167889044
Csub_181_215 sn_181 sn_215 1.367615513186298e-16
Rsub_181_188 sn_181 sn_188 2899841.216284414
Csub_181_188 sn_181 sn_188 3.633469116536825e-18
Rsub_181_186 sn_181 sn_186 5336076.327507574
Csub_181_186 sn_181 sn_186 1.974575110163666e-18
Rsub_181_192 sn_181 sn_192 2395640.941285806
Csub_181_192 sn_181 sn_192 4.398189779047098e-18
Rsub_181_204 sn_181 sn_204 2997923.335998808
Csub_181_204 sn_181 sn_204 3.514594044386927e-18
Rsub_181_211 sn_181 sn_211 2265885.268638244
Csub_181_211 sn_181 sn_211 4.650051636798998e-18
Rsub_181_197 sn_181 sn_197 8166594.936148821
Csub_181_197 sn_181 sn_197 1.290192985523385e-18
Rsub_181_208 sn_181 sn_208 26867.68051018818
Csub_181_208 sn_181 sn_208 3.921620066248215e-16
Rsub_181_201 sn_181 sn_201 96576626.5415788
Csub_181_201 sn_181 sn_201 1.090997260884213e-19
Rsub_181_213 sn_181 sn_213 2284105.809266115
Csub_181_213 sn_181 sn_213 4.612957709527206e-18
Rsub_181_199 sn_181 sn_199 57980685.17450421
Csub_181_199 sn_181 sn_199 1.817240253459991e-19
Rsub_181_214 sn_181 sn_214 5216039.627280183
Csub_181_214 sn_181 sn_214 2.020015999710507e-18
Rsub_125_127 sn_125 sn_127 293011.4276457567
Csub_125_127 sn_125 sn_127 3.595929205521752e-17
Rsub_125_165 sn_125 sn_165 67148.46765605525
Csub_125_165 sn_125 sn_165 1.569132382320247e-16
Rsub_125_227 sn_125 sn_227 1282363.361615393
Csub_125_227 sn_125 sn_227 8.216457064834726e-18
Rsub_125_187 sn_125 sn_187 960237.2952926198
Csub_125_187 sn_125 sn_187 1.0972791365096e-17
Rsub_125_182 sn_125 sn_182 15126749.27876182
Csub_125_182 sn_125 sn_182 6.96546449475657e-19
Rsub_125_209 sn_125 sn_209 213430.6146060295
Csub_125_209 sn_125 sn_209 4.936725465406751e-17
Rsub_125_170 sn_125 sn_170 9232725.435713295
Csub_125_170 sn_125 sn_170 1.141210531559144e-18
Rsub_125_126 sn_125 sn_126 1231403.937255188
Csub_125_126 sn_125 sn_126 8.556480277069706e-18
Rsub_125_188 sn_125 sn_188 37215119.89964666
Csub_125_188 sn_125 sn_188 2.831237284910652e-19
Rsub_125_197 sn_125 sn_197 9282018.325832289
Csub_125_197 sn_125 sn_197 1.135150043057605e-18
Rsub_125_203 sn_125 sn_203 1261845.826223906
Csub_125_203 sn_125 sn_203 8.35005615048916e-18
Rsub_125_160 sn_125 sn_160 3084502.245615381
Csub_125_160 sn_125 sn_160 3.415942885827886e-18
Rsub_125_218 sn_125 sn_218 1475966.853123165
Csub_125_218 sn_125 sn_218 7.138699273587796e-18
Rsub_125_139 sn_125 sn_139 596.9508902090926
Csub_125_139 sn_125 sn_139 1.765050303977168e-14
Rsub_125_192 sn_125 sn_192 8341672.684946723
Csub_125_192 sn_125 sn_192 1.263113994060688e-18
Rsub_125_168 sn_125 sn_168 1498402.366015881
Csub_125_168 sn_125 sn_168 7.031811842533042e-18
Rsub_125_167 sn_125 sn_167 450265.1275631676
Csub_125_167 sn_125 sn_167 2.340062078370002e-17
Rsub_125_157 sn_125 sn_157 142729.7237010107
Csub_125_157 sn_125 sn_157 7.382122818581052e-17
Rsub_125_189 sn_125 sn_189 29441.57983282446
Csub_125_189 sn_125 sn_189 3.578776533752058e-16
Rsub_125_190 sn_125 sn_190 10669740.14521388
Csub_125_190 sn_125 sn_190 9.875107883443955e-19
Rsub_125_158 sn_125 sn_158 351308.2148976475
Csub_125_158 sn_125 sn_158 2.99921352687405e-17
Rsub_125_147 sn_125 sn_147 1762838.14961267
Csub_125_147 sn_125 sn_147 5.976999933059692e-18
Rsub_125_226 sn_125 sn_226 1429278.330846266
Csub_125_226 sn_125 sn_226 7.371890607192946e-18
Rsub_125_184 sn_125 sn_184 289784545.7544649
Csub_125_184 sn_125 sn_184 3.635971502482257e-20
Rsub_125_198 sn_125 sn_198 886102.4032287819
Csub_125_198 sn_125 sn_198 1.18908192369608e-17
Rsub_125_161 sn_125 sn_161 280159.2453230146
Csub_125_161 sn_125 sn_161 3.760890878358049e-17
Rsub_125_135 sn_125 sn_135 620100.1345572937
Csub_125_135 sn_125 sn_135 1.69915839636969e-17
Rsub_125_134 sn_125 sn_134 11492.70215777783
Csub_125_134 sn_125 sn_134 9.167977519629098e-16
Rsub_125_148 sn_125 sn_148 3548918.017786494
Csub_125_148 sn_125 sn_148 2.968928402804228e-18
Rsub_125_185 sn_125 sn_185 5415.007060946799
Csub_125_185 sn_125 sn_185 1.945793123377336e-15
Rsub_125_151 sn_125 sn_151 43805.74304045692
Csub_125_151 sn_125 sn_151 2.405274461957877e-16
Rsub_125_230 sn_125 0 74906.4319499275
Csub_125_230 sn_125 0 1.406619328667703e-16
Rsub_125_206 sn_125 sn_206 12296978.66183797
Csub_125_206 sn_125 sn_206 8.568351456060157e-19
Rsub_125_169 sn_125 sn_169 95173.54866489759
Csub_125_169 sn_125 sn_169 1.107081079778642e-16
Rsub_125_132 sn_125 sn_132 1728.151835442644
Csub_125_132 sn_125 sn_132 6.096966300146429e-15
Rsub_125_211 sn_125 sn_211 13752550.22780302
Csub_125_211 sn_125 sn_211 7.661476110029964e-19
Rsub_125_183 sn_125 sn_183 13039.34371934409
Csub_125_183 sn_125 sn_183 8.080532064354547e-16
Rsub_125_162 sn_125 sn_162 1540154.467226086
Csub_125_162 sn_125 sn_162 6.841186209852614e-18
Rsub_125_159 sn_125 sn_159 33726.22663037638
Csub_125_159 sn_125 sn_159 3.124121656924422e-16
Rsub_125_137 sn_125 sn_137 547.8371608469672
Csub_125_137 sn_125 sn_137 1.923287475778457e-14
Rsub_125_216 sn_125 sn_216 2829601.768274962
Csub_125_216 sn_125 sn_216 3.723663032856196e-18
Rsub_125_141 sn_125 sn_141 3798.06388851669
Csub_125_141 sn_125 sn_141 2.774172265528939e-15
Rsub_125_154 sn_125 sn_154 395.1346593046208
Csub_125_154 sn_125 sn_154 2.666555123454033e-14
Rsub_125_191 sn_125 sn_191 1445.589030052658
Csub_125_191 sn_125 sn_191 7.28871296280257e-15
Rsub_125_177 sn_125 sn_177 96485.14227794658
Csub_125_177 sn_125 sn_177 1.092031711149614e-16
Rsub_125_156 sn_125 sn_156 605.6639346789498
Csub_125_156 sn_125 sn_156 1.739658397823403e-14
Rsub_125_128 sn_125 sn_128 41444.88262496716
Csub_125_128 sn_125 sn_128 2.542288175255352e-16
Rsub_125_207 sn_125 sn_207 2334221.945826027
Csub_125_207 sn_125 sn_207 4.513916734041067e-18
Rsub_125_217 sn_125 sn_217 18014492.70506537
Csub_125_217 sn_125 sn_217 5.848892708073494e-19
Rsub_125_138 sn_125 sn_138 1214109.632961653
Csub_125_138 sn_125 sn_138 8.67836249394357e-18
Rsub_125_155 sn_125 sn_155 109248.7630008985
Csub_125_155 sn_125 sn_155 9.644487692865999e-17
Rsub_125_131 sn_125 sn_131 336202.4757995888
Csub_125_131 sn_125 sn_131 3.133969634569505e-17
Rsub_125_210 sn_125 sn_210 1114958.143191374
Csub_125_210 sn_125 sn_210 9.450115743422565e-18
Rsub_125_179 sn_125 sn_179 134924.2740305419
Csub_125_179 sn_125 sn_179 7.809183023541729e-17
Rsub_125_186 sn_125 sn_186 8844285.681364741
Csub_125_186 sn_125 sn_186 1.191332333874152e-18
Rsub_125_199 sn_125 sn_199 14107381.30755988
Csub_125_199 sn_125 sn_199 7.468773454492008e-19
Rsub_125_166 sn_125 sn_166 1744558.433775277
Csub_125_166 sn_125 sn_166 6.039627735156302e-18
Rsub_125_195 sn_125 sn_195 139158.7893226556
Csub_125_195 sn_125 sn_195 7.57155444763173e-17
Rsub_125_181 sn_125 sn_181 50368.97828280261
Csub_125_181 sn_125 sn_181 2.091859684560537e-16
Rsub_125_153 sn_125 sn_153 2209180.202893772
Csub_125_153 sn_125 sn_153 4.76940880079788e-18
Rsub_125_221 sn_125 sn_221 1064626.326312256
Csub_125_221 sn_125 sn_221 9.896884232355196e-18
Rsub_125_222 sn_125 sn_222 542383.4610982857
Csub_125_222 sn_125 sn_222 1.942626252079002e-17
Rsub_125_133 sn_125 sn_133 50079991.01864033
Csub_125_133 sn_125 sn_133 2.103930789106612e-19
Rsub_125_144 sn_125 sn_144 18110313.25986168
Csub_125_144 sn_125 sn_144 5.81794657609941e-19
Rsub_125_146 sn_125 sn_146 7962132.656975674
Csub_125_146 sn_125 sn_146 1.323324284605949e-18
Rsub_125_150 sn_125 sn_150 2809546.251268739
Csub_125_150 sn_125 sn_150 3.750243832957695e-18
Rsub_125_224 sn_125 sn_224 1356851.562062296
Csub_125_224 sn_125 sn_224 7.765391437671681e-18
Rsub_125_228 sn_125 sn_228 8261441.538737888
Csub_125_228 sn_125 sn_228 1.275380749573116e-18
Rsub_125_180 sn_125 sn_180 1160675.308124038
Csub_125_180 sn_125 sn_180 9.077890628396136e-18
Rsub_125_219 sn_125 sn_219 362331.8808933508
Csub_125_219 sn_125 sn_219 2.907964785282398e-17
Rsub_125_140 sn_125 sn_140 33184952.41235262
Csub_125_140 sn_125 sn_140 3.175078683646973e-19
Rsub_125_196 sn_125 sn_196 1575949.392492442
Csub_125_196 sn_125 sn_196 6.685800668742309e-18
Rsub_125_174 sn_125 sn_174 19950944.10783167
Csub_125_174 sn_125 sn_174 5.281195438813316e-19
Rsub_125_164 sn_125 sn_164 3846453.41951903
Csub_125_164 sn_125 sn_164 2.739272351190336e-18
Rsub_125_215 sn_125 sn_215 768544.1486472358
Csub_125_215 sn_125 sn_215 1.370966589333345e-17
Rsub_125_176 sn_125 sn_176 1439371.806692057
Csub_125_176 sn_125 sn_176 7.320195833517674e-18
Rsub_125_202 sn_125 sn_202 514321.1015123933
Csub_125_202 sn_125 sn_202 2.048619718546802e-17
Rsub_125_178 sn_125 sn_178 7768668.23671869
Csub_125_178 sn_125 sn_178 1.356279246477434e-18
Rsub_125_173 sn_125 sn_173 7532342.01765475
Csub_125_173 sn_125 sn_173 1.398832325660992e-18
Rsub_125_163 sn_125 sn_163 9954048.676808901
Csub_125_163 sn_125 sn_163 1.058512354553586e-18
Rsub_69_190 sn_69 sn_190 1942375.119484534
Csub_69_190 sn_69 sn_190 5.42453586670023e-18
Rsub_69_183 sn_69 sn_183 254560.2333301327
Csub_69_183 sn_69 sn_183 4.139092490760528e-17
Rsub_69_97 sn_69 sn_97 15496819.62416341
Csub_69_97 sn_69 sn_97 6.799126374163246e-19
Rsub_69_213 sn_69 sn_213 60805134.112974
Csub_69_213 sn_69 sn_213 1.732827935656478e-19
Rsub_69_73 sn_69 sn_73 1191598.113252547
Csub_69_73 sn_69 sn_73 8.842313012287308e-18
Rsub_69_186 sn_69 sn_186 23117745.51868953
Csub_69_186 sn_69 sn_186 4.557746988655008e-19
Rsub_69_79 sn_69 sn_79 141286.2041415533
Csub_69_79 sn_69 sn_79 7.45754588443299e-17
Rsub_69_214 sn_69 sn_214 8203725.730861356
Csub_69_214 sn_69 sn_214 1.284353456941291e-18
Rsub_69_126 sn_69 sn_126 11187944.44996905
Csub_69_126 sn_69 sn_126 9.417711671118596e-19
Rsub_69_161 sn_69 sn_161 2574494.194974528
Csub_69_161 sn_69 sn_161 4.092642167458549e-18
Rsub_69_152 sn_69 sn_152 2625231.822904715
Csub_69_152 sn_69 sn_152 4.013544026969701e-18
Rsub_69_205 sn_69 sn_205 1488425.424161548
Csub_69_205 sn_69 sn_205 7.078946201261885e-18
Rsub_69_72 sn_69 sn_72 89872948.40532531
Csub_69_72 sn_69 sn_72 1.172375413201163e-19
Rsub_69_85 sn_69 sn_85 44749.21287534842
Csub_69_85 sn_69 sn_85 2.354562868307874e-16
Rsub_69_221 sn_69 sn_221 13374460.7914791
Csub_69_221 sn_69 sn_221 7.878062275933263e-19
Rsub_69_219 sn_69 sn_219 8162629.282152642
Csub_69_219 sn_69 sn_219 1.290819800584075e-18
Rsub_69_197 sn_69 sn_197 38080356.56522608
Csub_69_197 sn_69 sn_197 2.766907784642864e-19
Rsub_69_101 sn_69 sn_101 12541477.75955615
Csub_69_101 sn_69 sn_101 8.401309402475781e-19
Rsub_69_164 sn_69 sn_164 11578103.89334822
Csub_69_164 sn_69 sn_164 9.100353217838509e-19
Rsub_69_125 sn_69 sn_125 64038.03231312624
Csub_69_125 sn_69 sn_125 1.645347791248464e-16
Rsub_69_121 sn_69 sn_121 462661.8491140662
Csub_69_121 sn_69 sn_121 2.277361645963659e-17
Rsub_69_173 sn_69 sn_173 916325.2793544523
Csub_69_173 sn_69 sn_173 1.149862798683554e-17
Rsub_69_94 sn_69 sn_94 305275.0942283144
Csub_69_94 sn_69 sn_94 3.451471705827988e-17
Rsub_69_184 sn_69 sn_184 10555594.90552744
Csub_69_184 sn_69 sn_184 9.981894527529257e-19
Rsub_69_105 sn_69 sn_105 20503998.48028293
Csub_69_105 sn_69 sn_105 5.138745748719256e-19
Rsub_69_131 sn_69 sn_131 1134071.213414344
Csub_69_131 sn_69 sn_131 9.290848209177138e-18
Rsub_69_92 sn_69 sn_92 42375.54936627096
Csub_69_92 sn_69 sn_92 2.486453546869311e-16
Rsub_69_175 sn_69 sn_175 38158.64844363484
Csub_69_175 sn_69 sn_175 2.761230790915911e-16
Rsub_69_96 sn_69 sn_96 201517.6679066324
Csub_69_96 sn_69 sn_96 5.228565619919634e-17
Rsub_69_109 sn_69 sn_109 124105.0098878183
Csub_69_109 sn_69 sn_109 8.489974346526541e-17
Rsub_69_188 sn_69 sn_188 21994500.09646647
Csub_69_188 sn_69 sn_188 4.790508288898433e-19
Rsub_69_77 sn_69 sn_77 814774.2479300039
Csub_69_77 sn_69 sn_77 1.293178267354269e-17
Rsub_69_187 sn_69 sn_187 1970689.428901824
Csub_69_187 sn_69 sn_187 5.346597666635634e-18
Rsub_69_108 sn_69 sn_108 1615.091331009922
Csub_69_108 sn_69 sn_108 6.523769461161993e-15
Rsub_69_76 sn_69 sn_76 11271959.48646462
Csub_69_76 sn_69 sn_76 9.347517186237422e-19
Rsub_69_155 sn_69 sn_155 3647820.757802704
Csub_69_155 sn_69 sn_155 2.888432355041683e-18
Rsub_69_113 sn_69 sn_113 1802.069267390132
Csub_69_113 sn_69 sn_113 5.846880412920858e-15
Rsub_69_202 sn_69 sn_202 40509.70958177039
Csub_69_202 sn_69 sn_202 2.600977299272341e-16
Rsub_69_91 sn_69 sn_91 4618.60597045771
Csub_69_91 sn_69 sn_91 2.28131249334219e-15
Rsub_69_71 sn_69 sn_71 105699.2618330429
Csub_69_71 sn_69 sn_71 9.968360534885179e-17
Rsub_69_229 sn_69 sn_229 619166.9512719308
Csub_69_229 sn_69 sn_229 1.701719298904005e-17
Rsub_69_209 sn_69 sn_209 510647.9893550441
Csub_69_209 sn_69 sn_209 2.063355525111875e-17
Rsub_69_98 sn_69 sn_98 1707.123172455994
Csub_69_98 sn_69 sn_98 6.172069873008305e-15
Rsub_69_83 sn_69 sn_83 43594.23424821072
Csub_69_83 sn_69 sn_83 2.416944278052655e-16
Rsub_69_162 sn_69 sn_162 14834320.56522687
Csub_69_162 sn_69 sn_162 7.102774580002386e-19
Rsub_69_117 sn_69 sn_117 478068.9043091069
Csub_69_117 sn_69 sn_117 2.203967546782208e-17
Rsub_69_223 sn_69 sn_223 135512.4800698242
Csub_69_223 sn_69 sn_223 7.775286450960803e-17
Rsub_69_144 sn_69 sn_144 9877211854.602467
Rsub_69_75 sn_69 sn_75 6858.718526484897
Csub_69_75 sn_69 sn_75 1.536217510828508e-15
Rsub_69_106 sn_69 sn_106 172390.9389298841
Csub_69_106 sn_69 sn_106 6.111970598707316e-17
Rsub_69_148 sn_69 sn_148 10207672.33299527
Csub_69_148 sn_69 sn_148 1.032212159492217e-18
Rsub_69_222 sn_69 sn_222 5338783.276609648
Csub_69_222 sn_69 sn_222 1.973573931796893e-18
Rsub_69_111 sn_69 sn_111 11732.08986060536
Csub_69_111 sn_69 sn_111 8.980909307224088e-16
Rsub_69_179 sn_69 sn_179 147671.5801537269
Csub_69_179 sn_69 sn_179 7.135078727580123e-17
Rsub_69_100 sn_69 sn_100 6225015.482821698
Csub_69_100 sn_69 sn_100 1.692603581678801e-18
Rsub_69_119 sn_69 sn_119 3847.067276029898
Csub_69_119 sn_69 sn_119 2.738835259752321e-15
Rsub_69_198 sn_69 sn_198 4605734.508537305
Csub_69_198 sn_69 sn_198 2.287687986074602e-18
Rsub_69_230 sn_69 0 14409.70683085017
Csub_69_230 sn_69 0 7.312073469581024e-16
Rsub_69_163 sn_69 sn_163 59650.70924838302
Csub_69_163 sn_69 sn_163 1.766363490894388e-16
Rsub_69_89 sn_69 sn_89 1442101.237554468
Csub_69_89 sn_69 sn_89 7.306341072210638e-18
Rsub_69_167 sn_69 sn_167 23116.44540964402
Csub_69_167 sn_69 sn_167 4.55800332426293e-16
Rsub_69_122 sn_69 sn_122 42121.37498643265
Csub_69_122 sn_69 sn_122 2.501457634187824e-16
Rsub_69_201 sn_69 sn_201 12275413.70028123
Csub_69_201 sn_69 sn_201 8.583403997201833e-19
Rsub_69_133 sn_69 sn_133 51489275.58486748
Csub_69_133 sn_69 sn_133 2.04634525977418e-19
Rsub_69_220 sn_69 sn_220 875106.9425324319
Csub_69_220 sn_69 sn_220 1.204022387451179e-17
Rsub_69_172 sn_69 sn_172 1118112.640508625
Csub_69_172 sn_69 sn_172 9.423454418185449e-18
Rsub_69_157 sn_69 sn_157 1609563.584861609
Csub_69_157 sn_69 sn_157 6.546174131502817e-18
Rsub_69_102 sn_69 sn_102 8187304.0112318
Csub_69_102 sn_69 sn_102 1.286929554316716e-18
Rsub_69_228 sn_69 sn_228 7853133.488129416
Csub_69_228 sn_69 sn_228 1.34169163406641e-18
Rsub_69_124 sn_69 sn_124 871114.3803107013
Csub_69_124 sn_69 sn_124 1.209540760706067e-17
Rsub_69_203 sn_69 sn_203 3333384.752297455
Csub_69_203 sn_69 sn_203 3.160896291665096e-18
Rsub_69_216 sn_69 sn_216 5229773.018173607
Csub_69_216 sn_69 sn_216 2.014711435011697e-18
Rsub_69_160 sn_69 sn_160 875471.0826791791
Csub_69_160 sn_69 sn_160 1.203521590911433e-17
Rsub_69_158 sn_69 sn_158 2482612.343946924
Csub_69_158 sn_69 sn_158 4.244111461026097e-18
Rsub_69_115 sn_69 sn_115 2018859.164234285
Csub_69_115 sn_69 sn_115 5.219028493365108e-18
Rsub_69_194 sn_69 sn_194 353207.1745515172
Csub_69_194 sn_69 sn_194 2.983088753961082e-17
Rsub_69_225 sn_69 sn_225 135548.8248822807
Csub_69_225 sn_69 sn_225 7.773201657322047e-17
Rsub_69_207 sn_69 sn_207 9850959.818187708
Csub_69_207 sn_69 sn_207 1.069589532055203e-18
Rsub_69_128 sn_69 sn_128 102796.2710962629
Csub_69_128 sn_69 sn_128 1.02498693676964e-16
Rsub_69_116 sn_69 sn_116 18223766.86764491
Csub_69_116 sn_69 sn_116 5.781726455761914e-19
Rsub_69_132 sn_69 sn_132 436193.9615574356
Csub_69_132 sn_69 sn_132 2.415550060484415e-17
Rsub_69_217 sn_69 sn_217 686426.9345755704
Csub_69_217 sn_69 sn_217 1.534975242302357e-17
Rsub_69_226 sn_69 sn_226 3092409.285601997
Csub_69_226 sn_69 sn_226 3.407208596639197e-18
Rsub_69_153 sn_69 sn_153 26008661.44077639
Csub_69_153 sn_69 sn_153 4.051144087604177e-19
Rsub_69_206 sn_69 sn_206 4206758.578722052
Csub_69_206 sn_69 sn_206 2.504656092109479e-18
Rsub_106_168 sn_106 sn_168 10447164.61471462
Csub_106_168 sn_106 sn_168 1.008549581710389e-18
Rsub_106_229 sn_106 sn_229 212585.8180004125
Csub_106_229 sn_106 sn_229 4.956343561078734e-17
Rsub_106_113 sn_106 sn_113 962083.4286699545
Csub_106_113 sn_106 sn_113 1.095173577284904e-17
Rsub_106_230 sn_106 0 71514.49491903976
Csub_106_230 sn_106 0 1.473335372662306e-16
Rsub_106_193 sn_106 sn_193 7432944.249181516
Csub_106_193 sn_106 sn_193 1.417538346717754e-18
Rsub_106_156 sn_106 sn_156 1108842.429555691
Csub_106_156 sn_106 sn_156 9.502236946733655e-18
Rsub_106_117 sn_106 sn_117 113870.3974479697
Csub_106_117 sn_106 sn_117 9.253048850597355e-17
Rsub_106_111 sn_106 sn_111 20418.2271810798
Csub_106_111 sn_106 sn_111 5.160332191814114e-16
Rsub_106_205 sn_106 sn_205 6383.147682465881
Csub_106_205 sn_106 sn_205 1.650672054975805e-15
Rsub_106_223 sn_106 sn_223 121333.1315910423
Csub_106_223 sn_106 sn_223 8.683929413231992e-17
Rsub_106_121 sn_106 sn_121 84496.61505740967
Csub_106_121 sn_106 sn_121 1.246971076305386e-16
Rsub_106_157 sn_106 sn_157 788636.1403893301
Csub_106_157 sn_106 sn_157 1.336038632090637e-17
Rsub_106_194 sn_106 sn_194 2732800.276221787
Csub_106_194 sn_106 sn_194 3.85556295273694e-18
Rsub_106_217 sn_106 sn_217 68209.80812763421
Csub_106_217 sn_106 sn_217 1.544716777756379e-16
Rsub_106_109 sn_106 sn_109 5910.600053249907
Csub_106_109 sn_106 sn_109 1.782641932681028e-15
Rsub_106_227 sn_106 sn_227 679038.0873797754
Csub_106_227 sn_106 sn_227 1.551677836347508e-17
Rsub_106_107 sn_106 sn_107 14420026.97873628
Csub_106_107 sn_106 sn_107 7.3068403531887e-19
Rsub_106_202 sn_106 sn_202 1019584.207685075
Csub_106_202 sn_106 sn_202 1.033409837344643e-17
Rsub_106_225 sn_106 sn_225 1017349.622127283
Csub_106_225 sn_106 sn_225 1.035679698803855e-17
Rsub_106_167 sn_106 sn_167 286233.0249642865
Csub_106_167 sn_106 sn_167 3.6810858927074e-17
Rsub_106_130 sn_106 sn_130 572709.339322819
Csub_106_130 sn_106 sn_130 1.839761075782091e-17
Rsub_106_210 sn_106 sn_210 9877424.110457189
Csub_106_210 sn_106 sn_210 1.066723812241196e-18
Rsub_106_133 sn_106 sn_133 10833074.55923687
Csub_106_133 sn_106 sn_133 9.72621709987773e-19
Rsub_106_177 sn_106 sn_177 629620.187740766
Csub_106_177 sn_106 sn_177 1.673466592619517e-17
Rsub_106_122 sn_106 sn_122 1876884.196328833
Csub_106_122 sn_106 sn_122 5.613816517204023e-18
Rsub_106_145 sn_106 sn_145 4408581.225663491
Csub_106_145 sn_106 sn_145 2.389994186994766e-18
Rsub_106_132 sn_106 sn_132 1290817.169466767
Csub_106_132 sn_106 sn_132 8.16264592032239e-18
Rsub_106_213 sn_106 sn_213 34209253.20389634
Csub_106_213 sn_106 sn_213 3.080009797182571e-19
Rsub_185_209 sn_185 sn_209 42189.93305177879
Csub_185_209 sn_185 sn_209 2.497392799675412e-16
Rsub_185_227 sn_185 sn_227 792733.3220599268
Csub_185_227 sn_185 sn_227 1.329133418392307e-17
Rsub_185_212 sn_185 sn_212 6648567.060300864
Csub_185_212 sn_185 sn_212 1.584775096147289e-18
Rsub_185_203 sn_185 sn_203 6765068.555106037
Csub_185_203 sn_185 sn_203 1.557483625835164e-18
Rsub_185_204 sn_185 sn_204 11119345.52207515
Csub_185_204 sn_185 sn_204 9.475812655800651e-19
Rsub_185_197 sn_185 sn_197 12730011.87543752
Csub_185_197 sn_185 sn_197 8.276884267924433e-19
Rsub_185_219 sn_185 sn_219 2159654.981046069
Csub_185_219 sn_185 sn_219 4.878780913943234e-18
Rsub_185_186 sn_185 sn_186 46594680.70609043
Csub_185_186 sn_185 sn_186 2.261306085278693e-19
Rsub_185_215 sn_185 sn_215 18528506.43174521
Csub_185_215 sn_185 sn_215 5.686634020418216e-19
Rsub_185_198 sn_185 sn_198 2186817.591834659
Csub_185_198 sn_185 sn_198 4.818181242720972e-18
Rsub_185_230 sn_185 0 13249.39898498495
Csub_185_230 sn_185 0 7.952423739499884e-16
Rsub_185_206 sn_185 sn_206 4280385.827659977
Csub_185_206 sn_185 sn_206 2.461573308215101e-18
Rsub_185_199 sn_185 sn_199 16637494.63128044
Csub_185_199 sn_185 sn_199 6.332974847318766e-19
Rsub_185_202 sn_185 sn_202 253660.5096108629
Csub_185_202 sn_185 sn_202 4.153773686883257e-17
Rsub_185_228 sn_185 sn_228 7710485.825849214
Csub_185_228 sn_185 sn_228 1.366513568691962e-18
Rsub_185_191 sn_185 sn_191 531.9689330843173
Csub_185_191 sn_185 sn_191 1.980657675090204e-14
Rsub_185_222 sn_185 sn_222 983248.5857965732
Csub_185_222 sn_185 sn_222 1.071599151469303e-17
Rsub_185_207 sn_185 sn_207 11314642.13739968
Csub_185_207 sn_185 sn_207 9.312255194888098e-19
Rsub_185_210 sn_185 sn_210 1813845.158389867
Csub_185_210 sn_185 sn_210 5.808921149357167e-18
Rsub_185_195 sn_185 sn_195 1002794.955625724
Csub_185_195 sn_185 sn_195 1.050711657764118e-17
Rsub_185_189 sn_185 sn_189 4944.930784966033
Csub_185_189 sn_185 sn_189 2.130764607315404e-15
Rsub_185_226 sn_185 sn_226 5080670.248652596
Csub_185_226 sn_185 sn_226 2.073837306214529e-18
Rsub_185_211 sn_185 sn_211 37948946.39955875
Csub_185_211 sn_185 sn_211 2.77648907331786e-19
Rsub_220_228 sn_220 sn_228 36392180.70190362
Csub_220_228 sn_220 sn_228 2.895260272676886e-19
Rsub_220_229 sn_220 sn_229 575597.1866337083
Csub_220_229 sn_220 sn_229 1.83053075082785e-17
Rsub_220_222 sn_220 sn_222 1591662.624080577
Csub_220_222 sn_220 sn_222 6.61979702408128e-18
Rsub_220_221 sn_220 sn_221 2106240.182843975
Csub_220_221 sn_220 sn_221 5.002508065344661e-18
Rsub_220_226 sn_220 sn_226 1296890.692116154
Csub_220_226 sn_220 sn_226 8.124419094285795e-18
Rsub_53_141 sn_53 sn_141 120937.6537282093
Csub_53_141 sn_53 sn_141 8.712326705055231e-17
Rsub_53_190 sn_53 sn_190 160194.1134333592
Csub_53_190 sn_53 sn_190 6.577322522286803e-17
Rsub_53_154 sn_53 sn_154 508475.7964628322
Csub_53_154 sn_53 sn_154 2.072170116164061e-17
Rsub_53_166 sn_53 sn_166 71166.10076320727
Csub_53_166 sn_53 sn_166 1.480548096528191e-16
Rsub_53_119 sn_53 sn_119 404417.7618496969
Csub_53_119 sn_53 sn_119 2.605346375994712e-17
Rsub_53_189 sn_53 sn_189 1009385.554344206
Csub_53_189 sn_53 sn_189 1.043851227797243e-17
Rsub_53_159 sn_53 sn_159 504692.7771721029
Csub_53_159 sn_53 sn_159 2.087702455594486e-17
Rsub_53_75 sn_53 sn_75 329772.0578231254
Csub_53_75 sn_53 sn_75 3.195080739036199e-17
Rsub_53_139 sn_53 sn_139 583200.5751283704
Csub_53_139 sn_53 sn_139 1.806665485525417e-17
Rsub_53_132 sn_53 sn_132 258149.2142579142
Csub_53_132 sn_53 sn_132 4.081547771709701e-17
Rsub_53_152 sn_53 sn_152 264466.2406105856
Csub_53_152 sn_53 sn_152 3.984056141874263e-17
Rsub_53_181 sn_53 sn_181 137697.0075397222
Csub_53_181 sn_53 sn_181 7.651933539071637e-17
Rsub_53_126 sn_53 sn_126 753283.4656372983
Csub_53_126 sn_53 sn_126 1.398740843636578e-17
Rsub_53_224 sn_53 sn_224 289060.2250108593
Csub_53_224 sn_53 sn_224 3.645082439769834e-17
Rsub_53_112 sn_53 sn_112 2082114.423445951
Csub_53_112 sn_53 sn_112 5.060472846056106e-18
Rsub_53_105 sn_53 sn_105 4733299.350607769
Csub_53_105 sn_53 sn_105 2.226033623011206e-18
Rsub_53_80 sn_53 sn_80 4811453.428546447
Csub_53_80 sn_53 sn_80 2.189875400168448e-18
Rsub_53_110 sn_53 sn_110 5898120.753157706
Csub_53_110 sn_53 sn_110 1.786413663468831e-18
Rsub_53_196 sn_53 sn_196 12890086.21194086
Csub_53_196 sn_53 sn_196 8.174098550612817e-19
Rsub_53_148 sn_53 sn_148 4521082.630525662
Csub_53_148 sn_53 sn_148 2.330522214101833e-18
Rsub_53_86 sn_53 sn_86 9380710.240416737
Csub_53_86 sn_53 sn_86 1.123207436557802e-18
Rsub_53_88 sn_53 sn_88 22135956.10090831
Csub_53_88 sn_53 sn_88 4.759895373029611e-19
Rsub_53_158 sn_53 sn_158 1006630.910889196
Csub_53_158 sn_53 sn_158 1.046707724574315e-17
Rsub_53_209 sn_53 sn_209 399137.2060138225
Csub_53_209 sn_53 sn_209 2.639814916644256e-17
Rsub_53_186 sn_53 sn_186 22663914.31381221
Csub_53_186 sn_53 sn_186 4.649013121183876e-19
Rsub_53_201 sn_53 sn_201 27404120.32579696
Csub_53_201 sn_53 sn_201 3.844853758108575e-19
Rsub_53_210 sn_53 sn_210 1889622.73923967
Csub_53_210 sn_53 sn_210 5.575972009349116e-18
Rsub_53_162 sn_53 sn_162 13615416.60269948
Csub_53_162 sn_53 sn_162 7.738642018593076e-19
Rsub_53_211 sn_53 sn_211 8374591.083078528
Csub_53_211 sn_53 sn_211 1.258149012615044e-18
Rsub_53_160 sn_53 sn_160 2071765.217730804
Csub_53_160 sn_53 sn_160 5.085751711658993e-18
Rsub_53_140 sn_53 sn_140 4686129.090875727
Csub_53_140 sn_53 sn_140 2.248440727496259e-18
Rsub_53_130 sn_53 sn_130 284527.738424542
Csub_53_130 sn_53 sn_130 3.703148086921698e-17
Rsub_53_192 sn_53 sn_192 3804380.090247361
Csub_53_192 sn_53 sn_192 2.76956646083828e-18
Rsub_53_153 sn_53 sn_153 3276673.866515453
Csub_53_153 sn_53 sn_153 3.215603362270204e-18
Rsub_53_164 sn_53 sn_164 17987972.08640969
Csub_53_164 sn_53 sn_164 5.85751603994902e-19
Rsub_53_95 sn_53 sn_95 26658662.67666215
Csub_53_95 sn_53 sn_95 3.952367614994422e-19
Rsub_53_82 sn_53 sn_82 4802282.296751685
Csub_53_82 sn_53 sn_82 2.19405750248314e-18
Rsub_53_142 sn_53 sn_142 10444171.0585763
Csub_53_142 sn_53 sn_142 1.008838656810193e-18
Rsub_53_213 sn_53 sn_213 1197126.702208457
Csub_53_213 sn_53 sn_213 8.801477306280381e-18
Rsub_53_175 sn_53 sn_175 102306.2727133694
Csub_53_175 sn_53 sn_175 1.029896136647454e-16
Rsub_53_169 sn_53 sn_169 36369484.75129065
Csub_53_169 sn_53 sn_169 2.897067025909982e-19
Rsub_53_176 sn_53 sn_176 2362528.470851813
Csub_53_176 sn_53 sn_176 4.459833450570462e-18
Rsub_53_107 sn_53 sn_107 2076332.464435467
Csub_53_107 sn_53 sn_107 5.07456473503378e-18
Rsub_53_61 sn_53 sn_61 5037235.173844222
Csub_53_61 sn_53 sn_61 2.091719591918311e-18
Rsub_53_228 sn_53 sn_228 632647.2038545358
Csub_53_228 sn_53 sn_228 1.665459586011645e-17
Rsub_53_180 sn_53 sn_180 3531687.592822308
Csub_53_180 sn_53 sn_180 2.983413233844359e-18
Rsub_53_109 sn_53 sn_109 371466.6781963966
Csub_53_109 sn_53 sn_109 2.836454551829088e-17
Rsub_53_114 sn_53 sn_114 1993552.359386134
Csub_53_114 sn_53 sn_114 5.285280545866603e-18
Rsub_53_123 sn_53 sn_123 45264910.73994292
Csub_53_123 sn_53 sn_123 2.327737607341029e-19
Rsub_53_115 sn_53 sn_115 422478.5486145711
Csub_53_115 sn_53 sn_115 2.493968874107849e-17
Rsub_53_79 sn_53 sn_79 153135.6641285308
Csub_53_79 sn_53 sn_79 6.880489637858918e-17
Rsub_53_219 sn_53 sn_219 6172897.370300315
Csub_53_219 sn_53 sn_219 1.706894326953211e-18
Rsub_53_178 sn_53 sn_178 1273972.075882282
Csub_53_178 sn_53 sn_178 8.270576491979246e-18
Rsub_53_99 sn_53 sn_99 2168638.639708145
Csub_53_99 sn_53 sn_99 4.858570399560897e-18
Rsub_53_71 sn_53 sn_71 67916.03853782354
Csub_53_71 sn_53 sn_71 1.551398422091722e-16
Rsub_53_150 sn_53 sn_150 876201.8787606478
Csub_53_150 sn_53 sn_150 1.202517793859724e-17
Rsub_53_129 sn_53 sn_129 408724.8209707596
Csub_53_129 sn_53 sn_129 2.577891765223572e-17
Rsub_53_206 sn_53 sn_206 216387.6995824589
Csub_53_206 sn_53 sn_206 4.869261756819436e-17
Rsub_53_127 sn_53 sn_127 504692.8053995515
Csub_53_127 sn_53 sn_127 2.087702338829371e-17
Rsub_53_72 sn_53 sn_72 2988316.138855307
Csub_53_72 sn_53 sn_72 3.525893182863197e-18
Rsub_53_230 sn_53 0 7485.982009642803
Csub_53_230 sn_53 0 1.407495167455359e-15
Rsub_53_151 sn_53 sn_151 332284.7929357255
Csub_53_151 sn_53 sn_151 3.170919562445367e-17
Rsub_53_184 sn_53 sn_184 25641282.1761843
Csub_53_184 sn_53 sn_184 4.109187453978538e-19
Rsub_53_73 sn_53 sn_73 145863.9290511073
Csub_53_73 sn_53 sn_73 7.223501773723827e-17
Rsub_53_199 sn_53 sn_199 46544543.95065141
Csub_53_199 sn_53 sn_199 2.263741914283498e-19
Rsub_53_111 sn_53 sn_111 136724.7418726752
Csub_53_111 sn_53 sn_111 7.706347335467705e-17
Rsub_53_124 sn_53 sn_124 175676.6086391624
Csub_53_124 sn_53 sn_124 5.997658757103974e-17
Rsub_53_205 sn_53 sn_205 97595.23042823485
Csub_53_205 sn_53 sn_205 1.079610494897888e-16
Rsub_53_131 sn_53 sn_131 1502382.233853334
Csub_53_131 sn_53 sn_131 7.013184304773002e-18
Rsub_53_94 sn_53 sn_94 39769.01300420942
Csub_53_94 sn_53 sn_94 2.649420417125953e-16
Rsub_53_173 sn_53 sn_173 2976629.863364724
Csub_53_173 sn_53 sn_173 3.539735871063179e-18
Rsub_53_229 sn_53 sn_229 1448.619202072672
Csub_53_229 sn_53 sn_229 7.273466682724133e-15
Rsub_53_62 sn_53 sn_62 12998.3470223311
Csub_53_62 sn_53 sn_62 8.106018006849928e-16
Rsub_53_85 sn_53 sn_85 23624.31936904862
Csub_53_85 sn_53 sn_85 4.460015688762813e-16
Rsub_53_58 sn_53 sn_58 450639238.4039708
Csub_53_58 sn_53 sn_58 2.338119410006787e-20
Rsub_53_225 sn_53 sn_225 1471.62745455364
Csub_53_225 sn_53 sn_225 7.159749208012585e-15
Rsub_53_194 sn_53 sn_194 9672.961374585106
Csub_53_194 sn_53 sn_194 1.089271743595889e-15
Rsub_53_157 sn_53 sn_157 145831.618760239
Csub_53_157 sn_53 sn_157 7.225102204723503e-17
Rsub_53_78 sn_53 sn_78 9563698.793118734
Csub_53_78 sn_53 sn_78 1.101716368337657e-18
Rsub_53_121 sn_53 sn_121 53381.43888661801
Csub_53_121 sn_53 sn_121 1.973810320963707e-16
Rsub_53_172 sn_53 sn_172 3251.756955566284
Csub_53_172 sn_53 sn_172 3.240243242716491e-15
Rsub_53_56 sn_53 sn_56 33077057.52347138
Csub_53_56 sn_53 sn_56 3.185435552951874e-19
Rsub_53_223 sn_53 sn_223 19122.35075430693
Csub_53_223 sn_53 sn_223 5.510035684214645e-16
Rsub_53_65 sn_53 sn_65 41325.2371528115
Csub_53_65 sn_53 sn_65 2.549648647694008e-16
Rsub_53_68 sn_53 sn_68 930.3585226652808
Csub_53_68 sn_53 sn_68 1.132518620031039e-14
Rsub_53_59 sn_53 sn_59 83660662.85209531
Csub_53_59 sn_53 sn_59 1.259431032820954e-19
Rsub_53_226 sn_53 sn_226 410198.1066645817
Csub_53_226 sn_53 sn_226 2.568632894945482e-17
Rsub_53_179 sn_53 sn_179 136276.3644900051
Csub_53_179 sn_53 sn_179 7.73170280969946e-17
Rsub_53_177 sn_53 sn_177 57474.73935318973
Csub_53_177 sn_53 sn_177 1.83323728316225e-16
Rsub_53_66 sn_53 sn_66 4791.100591346056
Csub_53_66 sn_53 sn_66 2.199178101428629e-15
Rsub_53_117 sn_53 sn_117 8851.643499907585
Csub_53_117 sn_53 sn_117 1.190342053692064e-15
Rsub_53_128 sn_53 sn_128 39098.78274720941
Csub_53_128 sn_53 sn_128 2.694836708946398e-16
Rsub_53_202 sn_53 sn_202 10105.95685654047
Csub_53_202 sn_53 sn_202 1.042601274852158e-15
Rsub_53_217 sn_53 sn_217 80817.38163548667
Csub_53_217 sn_53 sn_217 1.30373977590032e-16
Rsub_53_138 sn_53 sn_138 399657.5848651882
Csub_53_138 sn_53 sn_138 2.636377714633928e-17
Rsub_53_143 sn_53 sn_143 6046251.429926958
Csub_53_143 sn_53 sn_143 1.742647262414175e-18
Rsub_53_222 sn_53 sn_222 187759.0460692825
Csub_53_222 sn_53 sn_222 5.611704854072424e-17
Rsub_53_227 sn_53 sn_227 1516441.971413556
Csub_53_227 sn_53 sn_227 6.948161354574212e-18
Rsub_53_60 sn_53 sn_60 14587795.5189478
Csub_53_60 sn_53 sn_60 7.222807235366283e-19
Rsub_53_165 sn_53 sn_165 263357.3611839216
Csub_53_165 sn_53 sn_165 4.000831210816853e-17
Rsub_53_185 sn_53 sn_185 549597.7708235363
Csub_53_185 sn_53 sn_185 1.917126317023042e-17
Rsub_53_106 sn_53 sn_106 163932.0597431462
Csub_53_106 sn_53 sn_106 6.427347718767695e-17
Rsub_53_155 sn_53 sn_155 222735.8613487825
Csub_53_155 sn_53 sn_155 4.73048364929925e-17
Rsub_53_101 sn_53 sn_101 747438.1571789109
Csub_53_101 sn_53 sn_101 1.409679637175378e-17
Rsub_53_183 sn_53 sn_183 331878.2060538297
Csub_53_183 sn_53 sn_183 3.174804283629583e-17
Rsub_53_87 sn_53 sn_87 153000.3552185206
Csub_53_87 sn_53 sn_87 6.88657453584432e-17
Rsub_53_167 sn_53 sn_167 84778.89885388908
Csub_53_167 sn_53 sn_167 1.242819102945527e-16
Rsub_53_77 sn_53 sn_77 187582.9008966052
Csub_53_77 sn_53 sn_77 5.616974389386196e-17
Rsub_53_156 sn_53 sn_156 605631.3326065236
Csub_53_156 sn_53 sn_156 1.739752046328738e-17
Rsub_53_170 sn_53 sn_170 181568.1645885427
Csub_53_170 sn_53 sn_170 5.803045663928507e-17
Rsub_53_54 sn_53 sn_54 46837340.77015179
Csub_53_54 sn_53 sn_54 2.249590461152873e-19
Rsub_53_221 sn_53 sn_221 118142.7441408389
Csub_53_221 sn_53 sn_221 8.918434711207801e-17
Rsub_53_83 sn_53 sn_83 29489.18916662635
Csub_53_83 sn_53 sn_83 3.57299871579867e-16
Rsub_53_188 sn_53 sn_188 20630336.7868977
Csub_53_188 sn_53 sn_188 5.107276537008212e-19
Rsub_53_70 sn_53 sn_70 252122062.5986377
Csub_53_70 sn_53 sn_70 4.179119984038608e-20
Rsub_53_90 sn_53 sn_90 33647049.15898419
Csub_53_90 sn_53 sn_90 3.131473269006304e-19
Rsub_53_215 sn_53 sn_215 175911.87102305
Csub_53_215 sn_53 sn_215 5.989637561668244e-17
Rsub_53_174 sn_53 sn_174 20192609.20346408
Csub_53_174 sn_53 sn_174 5.217990105222482e-19
Rsub_53_198 sn_53 sn_198 142521.4141981085
Csub_53_198 sn_53 sn_198 7.392912539854546e-17
Rsub_53_216 sn_53 sn_216 198033.71104443
Csub_53_216 sn_53 sn_216 5.320550449042527e-17
Rsub_53_163 sn_53 sn_163 299490.0984937019
Csub_53_163 sn_53 sn_163 3.518140851809021e-17
Rsub_53_197 sn_53 sn_197 17406904.02686691
Csub_53_197 sn_53 sn_197 6.053048540950954e-19
Rsub_53_182 sn_53 sn_182 1325225.102323839
Csub_53_182 sn_53 sn_182 7.950712285598744e-18
Rsub_53_193 sn_53 sn_193 1341846.404707083
Csub_53_193 sn_53 sn_193 7.852227695561071e-18
Rsub_53_133 sn_53 sn_133 13186749.65026461
Csub_53_133 sn_53 sn_133 7.990205154170477e-19
Rsub_53_102 sn_53 sn_102 418441.4719928153
Csub_53_102 sn_53 sn_102 2.518030407466618e-17
Rsub_53_195 sn_53 sn_195 72073.96150533599
Csub_53_195 sn_53 sn_195 1.461898760962367e-16
Rsub_141_149 sn_141 sn_149 616984.2421788395
Csub_141_149 sn_141 sn_149 1.707739482133466e-17
Rsub_141_175 sn_141 sn_175 39475759.71012463
Csub_141_175 sn_141 sn_175 2.66910214764724e-19
Rsub_141_214 sn_141 sn_214 1581252.868172078
Csub_141_214 sn_141 sn_214 6.663376689656306e-18
Rsub_141_213 sn_141 sn_213 888570.0727328785
Csub_141_213 sn_141 sn_213 1.185779695440798e-17
Rsub_141_176 sn_141 sn_176 217259.2161042855
Csub_141_176 sn_141 sn_176 4.849729135160112e-17
Rsub_141_160 sn_141 sn_160 409352.7198813274
Csub_141_160 sn_141 sn_160 2.573937582553393e-17
Rsub_141_158 sn_141 sn_158 154697.1667047039
Csub_141_158 sn_141 sn_158 6.811038448003855e-17
Rsub_141_184 sn_141 sn_184 1759887.634037797
Csub_141_184 sn_141 sn_184 5.98702059065875e-18
Rsub_141_163 sn_141 sn_163 2478558.937329351
Csub_141_163 sn_141 sn_163 4.251052231819459e-18
Rsub_141_190 sn_141 sn_190 31708.87626172903
Csub_141_190 sn_141 sn_190 3.322881396130392e-16
Rsub_141_227 sn_141 sn_227 107922783.3763198
Csub_141_227 sn_141 sn_227 9.762983470774621e-20
Rsub_141_148 sn_141 sn_148 2172440.615538127
Csub_141_148 sn_141 sn_148 4.850067443440817e-18
Rsub_141_216 sn_141 sn_216 33535.63200203624
Csub_141_216 sn_141 sn_216 3.141877123887285e-16
Rsub_141_168 sn_141 sn_168 110164.2168715984
Csub_141_168 sn_141 sn_168 9.564342943145298e-17
Rsub_141_165 sn_141 sn_165 18420.21313243307
Csub_141_165 sn_141 sn_165 5.720066009267868e-16
Rsub_141_166 sn_141 sn_166 243672.9056735488
Csub_141_166 sn_141 sn_166 4.324027520870884e-17
Rsub_141_206 sn_141 sn_206 1191722.83495608
Csub_141_206 sn_141 sn_206 8.841387605548664e-18
Rsub_141_169 sn_141 sn_169 3160.428403010128
Csub_141_169 sn_141 sn_169 3.333878246441085e-15
Rsub_141_178 sn_141 sn_178 4060944.162826918
Csub_141_178 sn_141 sn_178 2.594589602752703e-18
Rsub_141_181 sn_141 sn_181 987.7337895521899
Csub_141_181 sn_141 sn_181 1.066733123203868e-14
Rsub_141_156 sn_141 sn_156 21923.93351242003
Csub_141_156 sn_141 sn_156 4.805927502134152e-16
Rsub_141_230 sn_141 0 4516.554364745119
Csub_141_230 sn_141 0 2.332858779355046e-15
Rsub_141_151 sn_141 sn_151 224129.3271647175
Csub_141_151 sn_141 sn_151 4.701073097179519e-17
Rsub_141_199 sn_141 sn_199 4569956.277013538
Csub_141_199 sn_141 sn_199 2.305598317259084e-18
Rsub_141_185 sn_141 sn_185 3348.409209144864
Csub_141_185 sn_141 sn_185 3.14671321338316e-15
Rsub_141_154 sn_141 sn_154 6172.639398830159
Csub_141_154 sn_141 sn_154 1.706965662732037e-15
Rsub_141_191 sn_141 sn_191 1405.924665962105
Csub_141_191 sn_141 sn_191 7.494344296904168e-15
Rsub_141_228 sn_141 sn_228 71666.68251587985
Csub_141_228 sn_141 sn_228 1.470206675172293e-16
Rsub_141_183 sn_141 sn_183 90512.97389452509
Csub_141_183 sn_141 sn_183 1.164085439785481e-16
Rsub_141_217 sn_141 sn_217 399497.2670544087
Csub_141_217 sn_141 sn_217 2.637435690090717e-17
Rsub_141_180 sn_141 sn_180 28934.38031324769
Csub_141_180 sn_141 sn_180 3.641509991975133e-16
Rsub_141_224 sn_141 sn_224 963804.2557729319
Csub_141_224 sn_141 sn_224 1.093218196445934e-17
Rsub_141_150 sn_141 sn_150 278327.2690029778
Csub_141_150 sn_141 sn_150 3.785645416625445e-17
Rsub_141_229 sn_141 sn_229 174646.8903112553
Csub_141_229 sn_141 sn_229 6.03302096215507e-17
Rsub_141_155 sn_141 sn_155 19468.67661538337
Csub_141_155 sn_141 sn_155 5.412018346385443e-16
Rsub_141_222 sn_141 sn_222 55775.85796238465
Csub_141_222 sn_141 sn_222 1.889076006564673e-16
Rsub_141_143 sn_141 sn_143 11075103.89820728
Csub_141_143 sn_141 sn_143 9.513665604469445e-19
Rsub_141_177 sn_141 sn_177 42253.54372519439
Csub_141_177 sn_141 sn_177 2.493633095192308e-16
Rsub_141_226 sn_141 sn_226 346149.0541220324
Csub_141_226 sn_141 sn_226 3.043915150643583e-17
Rsub_141_189 sn_141 sn_189 293849.9596950851
Csub_141_189 sn_141 sn_189 3.5856678398606e-17
Rsub_141_221 sn_141 sn_221 649508.4524001443
Csub_141_221 sn_141 sn_221 1.622224231770084e-17
Rsub_141_142 sn_141 sn_142 3625519.172651927
Csub_141_142 sn_141 sn_142 2.906199912472942e-18
Rsub_141_171 sn_141 sn_171 1665484.953119686
Csub_141_171 sn_141 sn_171 6.326375679644355e-18
Rsub_141_188 sn_141 sn_188 7108295.001830187
Csub_141_188 sn_141 sn_188 1.482279998159495e-18
Rsub_141_172 sn_141 sn_172 3286644.754687
Csub_141_172 sn_141 sn_172 3.205847996563727e-18
Rsub_141_203 sn_141 sn_203 1064936.928538038
Csub_141_203 sn_141 sn_203 9.893997681810745e-18
Rsub_141_215 sn_141 sn_215 877580.7323518489
Csub_141_215 sn_141 sn_215 1.200628399622339e-17
Rsub_141_153 sn_141 sn_153 417747.5740408397
Csub_141_153 sn_141 sn_153 2.522212971893868e-17
Rsub_141_195 sn_141 sn_195 235016.0854491135
Csub_141_195 sn_141 sn_195 4.483303124590337e-17
Rsub_141_210 sn_141 sn_210 183156.4191181435
Csub_141_210 sn_141 sn_210 5.752724121251537e-17
Rsub_141_146 sn_141 sn_146 995645.0760333558
Csub_141_146 sn_141 sn_146 1.058256978903295e-17
Rsub_141_207 sn_141 sn_207 650880.8093426739
Csub_141_207 sn_141 sn_207 1.61880383489426e-17
Rsub_141_211 sn_141 sn_211 3296682.987148393
Csub_141_211 sn_141 sn_211 3.196086352040778e-18
Rsub_141_144 sn_141 sn_144 2785975.372169378
Csub_141_144 sn_141 sn_144 3.781972951909289e-18
Rsub_141_200 sn_141 sn_200 2214109.688270816
Csub_141_200 sn_141 sn_200 4.758790207209122e-18
Rsub_141_198 sn_141 sn_198 407336.9756069781
Csub_141_198 sn_141 sn_198 2.586674948064671e-17
Rsub_141_157 sn_141 sn_157 44452.46920698558
Csub_141_157 sn_141 sn_157 2.370280816835754e-16
Rsub_141_164 sn_141 sn_164 3388553.506518803
Csub_141_164 sn_141 sn_164 3.109434005383186e-18
Rsub_141_212 sn_141 sn_212 819938.9294177617
Csub_141_212 sn_141 sn_212 1.28503271697466e-17
Rsub_141_192 sn_141 sn_192 1490653.531974555
Csub_141_192 sn_141 sn_192 7.068365167506851e-18
Rsub_141_219 sn_141 sn_219 723897.3199708643
Csub_141_219 sn_141 sn_219 1.455521827688778e-17
Rsub_141_196 sn_141 sn_196 4727615.208349454
Csub_141_196 sn_141 sn_196 2.228710044679925e-18
Rsub_141_204 sn_141 sn_204 1320002.330088567
Csub_141_204 sn_141 sn_204 7.982170381110652e-18
Rsub_141_186 sn_141 sn_186 8734210.449134218
Csub_141_186 sn_141 sn_186 1.20634641947223e-18
Rsub_141_208 sn_141 sn_208 1286135.523045813
Csub_141_208 sn_141 sn_208 8.192358669386262e-18
Rsub_141_174 sn_141 sn_174 15569349.82943184
Csub_141_174 sn_141 sn_174 6.767452474034684e-19
Rsub_141_218 sn_141 sn_218 215644.6190986218
Csub_141_218 sn_141 sn_218 4.886040535707176e-17
Rsub_141_194 sn_141 sn_194 7225601.391017011
Csub_141_194 sn_141 sn_194 1.458215438694021e-18
Rsub_141_201 sn_141 sn_201 17007786.93070799
Csub_141_201 sn_141 sn_201 6.195093779782784e-19
Rsub_141_197 sn_141 sn_197 2715208.815175329
Csub_141_197 sn_141 sn_197 3.880542609961154e-18
Rsub_141_167 sn_141 sn_167 367839.4850257239
Csub_141_167 sn_141 sn_167 2.864424275032126e-17
Rsub_81_97 sn_81 sn_97 15373043.10959342
Csub_81_97 sn_81 sn_97 6.853869742715285e-19
Rsub_81_125 sn_81 sn_125 21599.7774963868
Csub_81_125 sn_81 sn_125 4.878051870669751e-16
Rsub_81_226 sn_81 sn_226 10262448.36295002
Csub_81_226 sn_81 sn_226 1.026702705786011e-18
Rsub_81_211 sn_81 sn_211 32889777.56914433
Csub_81_211 sn_81 sn_211 3.20357396156879e-19
Rsub_81_203 sn_81 sn_203 6125515.0860179
Csub_81_203 sn_81 sn_203 1.720097551678646e-18
Rsub_81_167 sn_81 sn_167 372913.9681428596
Csub_81_167 sn_81 sn_167 2.825446189291998e-17
Rsub_81_86 sn_81 sn_86 21141332.04733917
Csub_81_86 sn_81 sn_86 4.983831424924862e-19
Rsub_81_155 sn_81 sn_155 5871492.315641339
Csub_81_155 sn_81 sn_155 1.794515420579088e-18
Rsub_81_94 sn_81 sn_94 1148935.154829171
Csub_81_94 sn_81 sn_94 9.170651152890011e-18
Rsub_81_133 sn_81 sn_133 33885547.0928623
Csub_81_133 sn_81 sn_133 3.109432901689647e-19
Rsub_81_212 sn_81 sn_212 3739818.971419237
Csub_81_212 sn_81 sn_212 2.817377948706291e-18
Rsub_81_98 sn_81 sn_98 26691250.85305881
Csub_81_98 sn_81 sn_98 3.947542046731213e-19
Rsub_81_109 sn_81 sn_109 489279.0220066792
Csub_81_109 sn_81 sn_109 2.153471338095948e-17
Rsub_81_106 sn_81 sn_106 2727809.633379285
Csub_81_106 sn_81 sn_106 3.862616867870327e-18
Rsub_81_92 sn_81 sn_92 361496.0901093143
Csub_81_92 sn_81 sn_92 2.914688094978795e-17
Rsub_81_116 sn_81 sn_116 6248813.730094365
Csub_81_116 sn_81 sn_116 1.686157398401262e-18
Rsub_81_139 sn_81 sn_139 365002.7432021999
Csub_81_139 sn_81 sn_139 2.886686113587131e-17
Rsub_81_218 sn_81 sn_218 5459780.492871942
Csub_81_218 sn_81 sn_218 1.929836467965331e-18
Rsub_81_126 sn_81 sn_126 10186786.10992707
Csub_81_126 sn_81 sn_126 1.034328529972976e-18
Rsub_81_172 sn_81 sn_172 7480185.520360998
Csub_81_172 sn_81 sn_172 1.408585853058027e-18
Rsub_81_118 sn_81 sn_118 8554725.392709104
Csub_81_118 sn_81 sn_118 1.23165654285173e-18
Rsub_81_144 sn_81 sn_144 44395989.42953909
Csub_81_144 sn_81 sn_144 2.373296245362987e-19
Rsub_81_122 sn_81 sn_122 2968007.55668489
Csub_81_122 sn_81 sn_122 3.550019095638255e-18
Rsub_81_84 sn_81 sn_84 250673317.1458324
Csub_81_84 sn_81 sn_84 4.203272858155967e-20
Rsub_81_163 sn_81 sn_163 350273.5607303925
Csub_81_163 sn_81 sn_163 3.008072741847619e-17
Rsub_81_89 sn_81 sn_89 3350.951284912604
Csub_81_89 sn_81 sn_89 3.144326075305748e-15
Rsub_81_182 sn_81 sn_182 5303259.349900915
Csub_81_182 sn_81 sn_182 1.986793933136018e-18
Rsub_81_143 sn_81 sn_143 18747933.24775172
Csub_81_143 sn_81 sn_143 5.620077350922696e-19
Rsub_81_222 sn_81 sn_222 477868.4969392559
Csub_81_222 sn_81 sn_222 2.204891841524624e-17
Rsub_81_128 sn_81 sn_128 111226.8956934362
Csub_81_128 sn_81 sn_128 9.472963743653045e-17
Rsub_81_170 sn_81 sn_170 4451944.31968641
Csub_81_170 sn_81 sn_170 2.366715022835725e-18
Rsub_81_91 sn_81 sn_91 19864.08502129102
Csub_81_91 sn_81 sn_91 5.304288363111934e-16
Rsub_81_179 sn_81 sn_179 32087.52448887337
Csub_81_179 sn_81 sn_179 3.283669796927969e-16
Rsub_81_220 sn_81 sn_220 11835.69808102539
Csub_81_220 sn_81 sn_220 8.902291550611409e-16
Rsub_81_146 sn_81 sn_146 7698978.685941841
Csub_81_146 sn_81 sn_146 1.368556003599462e-18
Rsub_81_209 sn_81 sn_209 4042.188989505682
Csub_81_209 sn_81 sn_209 2.606628123916221e-15
Rsub_81_175 sn_81 sn_175 74895.87695933855
Csub_81_175 sn_81 sn_175 1.406817561926717e-16
Rsub_81_157 sn_81 sn_157 182501.4222139326
Csub_81_157 sn_81 sn_157 5.773370626054016e-17
Rsub_81_162 sn_81 sn_162 22836831.03137551
Csub_81_162 sn_81 sn_162 4.613811560699439e-19
Rsub_81_83 sn_81 sn_83 352433.1984176878
Csub_81_83 sn_81 sn_83 2.989639894747555e-17
Rsub_81_108 sn_81 sn_108 387116.7651315942
Csub_81_108 sn_81 sn_108 2.721784342935468e-17
Rsub_81_187 sn_81 sn_187 8628.819780738877
Csub_81_187 sn_81 sn_187 1.221080491882492e-15
Rsub_81_229 sn_81 sn_229 135047.0627808279
Csub_81_229 sn_81 sn_229 7.802082685300596e-17
Rsub_81_104 sn_81 sn_104 4107.549042008225
Csub_81_104 sn_81 sn_104 2.565150992592556e-15
Rsub_81_193 sn_81 sn_193 506702.6878566127
Csub_81_193 sn_81 sn_193 2.079421276962246e-17
Rsub_81_119 sn_81 sn_119 389860.1585023842
Csub_81_119 sn_81 sn_119 2.702631513490642e-17
Rsub_81_151 sn_81 sn_151 233796.3003462398
Csub_81_151 sn_81 sn_151 4.506693855559748e-17
Rsub_81_230 sn_81 0 53718.25158310807
Csub_81_230 sn_81 0 1.961434557476037e-16
Rsub_81_117 sn_81 sn_117 4441447.992370836
Csub_81_117 sn_81 sn_117 2.372308202263931e-18
Rsub_81_184 sn_81 sn_184 2585119.390929596
Csub_81_184 sn_81 sn_184 4.07582084572161e-18
Rsub_81_131 sn_81 sn_131 5281110.241183463
Csub_81_131 sn_81 sn_131 1.995126596688662e-18
Rsub_81_152 sn_81 sn_152 904564.1470570717
Csub_81_152 sn_81 sn_152 1.164813301136202e-17
Rsub_81_115 sn_81 sn_115 311279.3684701552
Csub_81_115 sn_81 sn_115 3.384896195984225e-17
Rsub_81_140 sn_81 sn_140 2108840.277048251
Csub_81_140 sn_81 sn_140 4.99634022401068e-18
Rsub_81_107 sn_81 sn_107 15432258.38214713
Csub_81_107 sn_81 sn_107 6.827570690767577e-19
Rsub_81_102 sn_81 sn_102 3645613.621114047
Csub_81_102 sn_81 sn_102 2.8901810771187e-18
Rsub_81_217 sn_81 sn_217 78306.19950554539
Csub_81_217 sn_81 sn_217 1.345549084077799e-16
Rsub_52_179 sn_52 sn_179 3621420.907109337
Csub_52_179 sn_52 sn_179 2.909488781473997e-18
Rsub_52_89 sn_52 sn_89 300933.7362321719
Csub_52_89 sn_52 sn_89 3.501263644997599e-17
Rsub_52_109 sn_52 sn_109 696360.5409466627
Csub_52_109 sn_52 sn_109 1.513078769211456e-17
Rsub_52_209 sn_52 sn_209 311688.4019770855
Csub_52_209 sn_52 sn_209 3.380454144394059e-17
Rsub_52_106 sn_52 sn_106 1379605.75752462
Csub_52_106 sn_52 sn_106 7.637314823283471e-18
Rsub_52_165 sn_52 sn_165 66762.94284250453
Csub_52_165 sn_52 sn_165 1.578193388971159e-16
Rsub_52_157 sn_52 sn_157 99905.88209589805
Csub_52_157 sn_52 sn_157 1.054640956186764e-16
Rsub_52_156 sn_52 sn_156 12603937.27584203
Csub_52_156 sn_52 sn_156 8.359676243728442e-19
Rsub_52_65 sn_52 sn_65 2353948.669998931
Csub_52_65 sn_52 sn_65 4.476088895445109e-18
Rsub_52_193 sn_52 sn_193 23634241.33917939
Csub_52_193 sn_52 sn_193 4.45814331461669e-19
Rsub_52_159 sn_52 sn_159 33222467.93916545
Csub_52_159 sn_52 sn_159 3.171493316367597e-19
Rsub_52_66 sn_52 sn_66 114963.5388139415
Csub_52_66 sn_52 sn_66 9.165065385889332e-17
Rsub_52_189 sn_52 sn_189 210493401.407103
Csub_52_189 sn_52 sn_189 5.005612257579516e-20
Rsub_52_75 sn_52 sn_75 437721.7981558864
Csub_52_75 sn_52 sn_75 2.407118755935849e-17
Rsub_52_125 sn_52 sn_125 56331.52046029128
Csub_52_125 sn_52 sn_125 1.870441879809953e-16
Rsub_52_175 sn_52 sn_175 18802639.17724181
Csub_52_175 sn_52 sn_175 5.603725840244313e-19
Rsub_52_154 sn_52 sn_154 465079.4105406292
Csub_52_154 sn_52 sn_154 2.265523534998447e-17
Rsub_52_128 sn_52 sn_128 252283.4439300187
Csub_52_128 sn_52 sn_128 4.176446673667866e-17
Rsub_52_143 sn_52 sn_143 11744795.62055075
Csub_52_143 sn_52 sn_143 8.971193575981456e-19
Rsub_52_98 sn_52 sn_98 15169299.87078433
Csub_52_98 sn_52 sn_98 6.945926042719343e-19
Rsub_52_194 sn_52 sn_194 8397783.169215834
Csub_52_194 sn_52 sn_194 1.254674393220119e-18
Rsub_52_68 sn_52 sn_68 611880.35184223
Csub_52_68 sn_52 sn_68 1.721984285082384e-17
Rsub_52_100 sn_52 sn_100 263167.2933951039
Csub_52_100 sn_52 sn_100 4.003720738356017e-17
Rsub_52_173 sn_52 sn_173 6070888.022648209
Csub_52_173 sn_52 sn_173 1.735575333118043e-18
Rsub_52_191 sn_52 sn_191 152849.1547741117
Csub_52_191 sn_52 sn_191 6.893386828210702e-17
Rsub_52_115 sn_52 sn_115 66817.45660322237
Csub_52_115 sn_52 sn_115 1.576905802445923e-16
Rsub_52_112 sn_52 sn_112 213937.6773486358
Csub_52_112 sn_52 sn_112 4.925024723466359e-17
Rsub_52_132 sn_52 sn_132 67780.63137625028
Csub_52_132 sn_52 sn_132 1.554497691787788e-16
Rsub_52_169 sn_52 sn_169 373300.9778721185
Csub_52_169 sn_52 sn_169 2.822516984094127e-17
Rsub_52_139 sn_52 sn_139 6556059.030747799
Csub_52_139 sn_52 sn_139 1.607136765061767e-18
Rsub_52_83 sn_52 sn_83 1104066.431546917
Csub_52_83 sn_52 sn_83 9.543341959475431e-18
Rsub_52_127 sn_52 sn_127 66806.31506521064
Csub_52_127 sn_52 sn_127 1.577168788900448e-16
Rsub_52_58 sn_52 sn_58 1011769.166946076
Csub_52_58 sn_52 sn_58 1.041392033524141e-17
Rsub_52_82 sn_52 sn_82 167270.3615361078
Csub_52_82 sn_52 sn_82 6.29907379016189e-17
Rsub_52_62 sn_52 sn_62 294547.8364062629
Csub_52_62 sn_52 sn_62 3.577172261994577e-17
Rsub_52_229 sn_52 sn_229 82529.36194811387
Csub_52_229 sn_52 sn_229 1.276695136556887e-16
Rsub_52_144 sn_52 sn_144 51952.59170873457
Csub_52_144 sn_52 sn_144 2.028095838086658e-16
Rsub_52_151 sn_52 sn_151 67763.36964535588
Csub_52_151 sn_52 sn_151 1.554893677420912e-16
Rsub_52_105 sn_52 sn_105 598676.8644877246
Csub_52_105 sn_52 sn_105 1.759961696740336e-17
Rsub_52_163 sn_52 sn_163 2968595.584409597
Csub_52_163 sn_52 sn_163 3.5493158979166e-18
Rsub_52_118 sn_52 sn_118 55849.27845301558
Csub_52_118 sn_52 sn_118 1.886592592435021e-16
Rsub_52_220 sn_52 sn_220 173561.9081189747
Csub_52_220 sn_52 sn_220 6.07073499964483e-17
Rsub_52_53 sn_52 sn_53 55386.44457643127
Csub_52_53 sn_52 sn_53 1.902357803034286e-16
Rsub_52_200 sn_52 sn_200 262189.2183322698
Csub_52_200 sn_52 sn_200 4.018656285430174e-17
Rsub_52_183 sn_52 sn_183 70963.59854448124
Csub_52_183 sn_52 sn_183 1.484772998881327e-16
Rsub_52_134 sn_52 sn_134 145346.9407349224
Csub_52_134 sn_52 sn_134 7.249195235175944e-17
Rsub_52_137 sn_52 sn_137 73824.59406894386
Csub_52_137 sn_52 sn_137 1.427232162277806e-16
Rsub_52_140 sn_52 sn_140 90616.41249722728
Csub_52_140 sn_52 sn_140 1.162756636669146e-16
Rsub_52_202 sn_52 sn_202 168262.4978269464
Csub_52_202 sn_52 sn_202 6.261932182337209e-17
Rsub_52_196 sn_52 sn_196 209820.813608954
Csub_52_196 sn_52 sn_196 5.021657918964603e-17
Rsub_52_64 sn_52 sn_64 9477.021510421366
Csub_52_64 sn_52 sn_64 1.111792717853769e-15
Rsub_52_182 sn_52 sn_182 93176.93095054696
Csub_52_182 sn_52 sn_182 1.1308038797524e-16
Rsub_52_119 sn_52 sn_119 2050998.351996852
Csub_52_119 sn_52 sn_119 5.137246205961932e-18
Rsub_52_133 sn_52 sn_133 29768.32588106799
Csub_52_133 sn_52 sn_133 3.539494812145608e-16
Rsub_52_103 sn_52 sn_103 263388.2911226117
Csub_52_103 sn_52 sn_103 4.000361389385031e-17
Rsub_52_95 sn_52 sn_95 524177.2002206637
Csub_52_95 sn_52 sn_95 2.010099542252971e-17
Rsub_52_204 sn_52 sn_204 126798.7613387639
Csub_52_204 sn_52 sn_204 8.309610749335351e-17
Rsub_52_174 sn_52 sn_174 780816.5998413408
Csub_52_174 sn_52 sn_174 1.349418481160746e-17
Rsub_52_201 sn_52 sn_201 109231.0565826862
Csub_52_201 sn_52 sn_201 9.646051069966581e-17
Rsub_52_78 sn_52 sn_78 111334.8529668082
Csub_52_78 sn_52 sn_78 9.46377816241532e-17
Rsub_52_90 sn_52 sn_90 4824855.010284156
Csub_52_90 sn_52 sn_90 2.183792772999714e-18
Rsub_52_70 sn_52 sn_70 139573.180658754
Csub_52_70 sn_52 sn_70 7.549074580446021e-17
Rsub_52_172 sn_52 sn_172 382860.7216098703
Csub_52_172 sn_52 sn_172 2.752040861733142e-17
Rsub_52_188 sn_52 sn_188 96162.53692690781
Csub_52_188 sn_52 sn_188 1.095695250868712e-16
Rsub_52_67 sn_52 sn_67 37366.67750493898
Csub_52_67 sn_52 sn_67 2.819753910643335e-16
Rsub_52_187 sn_52 sn_187 1945743.99309294
Csub_52_187 sn_52 sn_187 5.41514379056686e-18
Rsub_52_136 sn_52 sn_136 320901.4819454949
Csub_52_136 sn_52 sn_136 3.28340132253413e-17
Rsub_52_207 sn_52 sn_207 77813.84930338876
Csub_52_207 sn_52 sn_207 1.354062753167403e-16
Rsub_52_146 sn_52 sn_146 40740.24623387829
Csub_52_146 sn_52 sn_146 2.586259160473164e-16
Rsub_52_192 sn_52 sn_192 40191.63018596252
Csub_52_192 sn_52 sn_192 2.621561617052799e-16
Rsub_52_80 sn_52 sn_80 117606.1458043599
Csub_52_80 sn_52 sn_80 8.959126608704318e-17
Rsub_52_155 sn_52 sn_155 10889.58424795407
Csub_52_155 sn_52 sn_155 9.675744511742578e-16
Rsub_52_76 sn_52 sn_76 11243.02895557918
Csub_52_76 sn_52 sn_76 9.371570191502031e-16
Rsub_52_166 sn_52 sn_166 21418.13567951396
Csub_52_166 sn_52 sn_166 4.919421400578739e-16
Rsub_52_199 sn_52 sn_199 145452.8636456477
Csub_52_199 sn_52 sn_199 7.24391616510142e-17
Rsub_52_120 sn_52 sn_120 132172.9562394853
Csub_52_120 sn_52 sn_120 7.971739304323996e-17
Rsub_52_162 sn_52 sn_162 51934.20994134625
Csub_52_162 sn_52 sn_162 2.028813669088209e-16
Rsub_52_93 sn_52 sn_93 3340.974388643718
Csub_52_93 sn_52 sn_93 3.153715735757954e-15
Rsub_52_131 sn_52 sn_131 11495.40201309287
Csub_52_131 sn_52 sn_131 9.165824292381688e-16
Rsub_52_219 sn_52 sn_219 52664.43930733501
Csub_52_219 sn_52 sn_219 2.00068274547499e-16
Rsub_52_210 sn_52 sn_210 69761.63495609596
Csub_52_210 sn_52 sn_210 1.510355012301686e-16
Rsub_52_150 sn_52 sn_150 41062.2737824934
Csub_52_150 sn_52 sn_150 2.565976632965259e-16
Rsub_52_57 sn_52 sn_57 644385.2256355603
Csub_52_57 sn_52 sn_57 1.63512183132967e-17
Rsub_52_224 sn_52 sn_224 54126.10071031652
Csub_52_224 sn_52 sn_224 1.946654823450405e-16
Rsub_52_195 sn_52 sn_195 32772.35898957418
Csub_52_195 sn_52 sn_195 3.21505189955412e-16
Rsub_52_116 sn_52 sn_116 105494.2211049853
Csub_52_116 sn_52 sn_116 9.987735244515757e-17
Rsub_52_158 sn_52 sn_158 16627.62830883844
Csub_52_158 sn_52 sn_158 6.336732639512588e-16
Rsub_52_79 sn_52 sn_79 198082.656031548
Csub_52_79 sn_52 sn_79 5.319235774257737e-17
Rsub_52_84 sn_52 sn_84 30766.8946255399
Csub_52_84 sn_52 sn_84 3.424617151151667e-16
Rsub_52_121 sn_52 sn_121 1926760.684478096
Csub_52_121 sn_52 sn_121 5.468496210822378e-18
Rsub_52_178 sn_52 sn_178 101333.2582254531
Csub_52_178 sn_52 sn_178 1.039785326826037e-16
Rsub_52_99 sn_52 sn_99 58925.76657071504
Csub_52_99 sn_52 sn_99 1.788094430572317e-16
Rsub_52_141 sn_52 sn_141 28483.68487077404
Csub_52_141 sn_52 sn_141 3.699129361257982e-16
Rsub_52_107 sn_52 sn_107 1686904.676014583
Csub_52_107 sn_52 sn_107 6.246045583988242e-18
Rsub_52_186 sn_52 sn_186 153165.4636037179
Csub_52_186 sn_52 sn_186 6.87915098764748e-17
Rsub_52_148 sn_52 sn_148 108079.368998282
Csub_52_148 sn_52 sn_148 9.748838839350999e-17
Rsub_52_69 sn_52 sn_69 574509.8600796008
Csub_52_69 sn_52 sn_69 1.83399524261779e-17
Rsub_52_55 sn_52 sn_55 7704779.588007993
Csub_52_55 sn_52 sn_55 1.367525622488848e-18
Rsub_52_222 sn_52 sn_222 646.6291479894406
Csub_52_222 sn_52 sn_222 1.62944765712944e-14
Rsub_52_77 sn_52 sn_77 53429.27206741568
Csub_52_77 sn_52 sn_77 1.972043244185572e-16
Rsub_52_72 sn_52 sn_72 622511.4097834014
Csub_52_72 sn_52 sn_72 1.692576768335234e-17
Rsub_52_138 sn_52 sn_138 12740.13160893695
Csub_52_138 sn_52 sn_138 8.270309778306266e-16
Rsub_52_226 sn_52 sn_226 22155.85705906917
Csub_52_226 sn_52 sn_226 4.755619913117758e-16
Rsub_52_59 sn_52 sn_59 817967.4377088387
Csub_52_59 sn_52 sn_59 1.288129944603068e-17
Rsub_52_217 sn_52 sn_217 87805.06891503281
Csub_52_217 sn_52 sn_217 1.199985790390523e-16
Rsub_52_212 sn_52 sn_212 34581.20708811256
Csub_52_212 sn_52 sn_212 3.046881352459199e-16
Rsub_52_101 sn_52 sn_101 69542.55019203885
Csub_52_101 sn_52 sn_101 1.515113189426321e-16
Rsub_52_180 sn_52 sn_180 137083.8572545234
Csub_52_180 sn_52 sn_180 7.686159197189007e-17
Rsub_52_170 sn_52 sn_170 44180.81668763453
Csub_52_170 sn_52 sn_170 2.384854851535369e-16
Rsub_52_110 sn_52 sn_110 141470.8697616522
Csub_52_110 sn_52 sn_110 7.4478113550738e-17
Rsub_52_184 sn_52 sn_184 233169.1415853417
Csub_52_184 sn_52 sn_184 4.518815581938216e-17
Rsub_52_54 sn_52 sn_54 205348.5597266363
Csub_52_54 sn_52 sn_54 5.131023814462764e-17
Rsub_52_221 sn_52 sn_221 24021.3423247205
Csub_52_221 sn_52 sn_221 4.386300881856566e-16
Rsub_52_230 sn_52 0 2971.714956125625
Csub_52_230 sn_52 0 3.545590225775539e-15
Rsub_52_63 sn_52 sn_63 1701346.061675036
Csub_52_63 sn_52 sn_63 6.193027826365e-18
Rsub_52_142 sn_52 sn_142 51833.16780914398
Csub_52_142 sn_52 sn_142 2.032768581890772e-16
Rsub_52_153 sn_52 sn_153 35957.64624011338
Csub_52_153 sn_52 sn_153 2.930248390528906e-16
Rsub_52_74 sn_52 sn_74 21394.02512781103
Csub_52_74 sn_52 sn_74 4.924965470164454e-16
Rsub_52_216 sn_52 sn_216 13319.38705580898
Csub_52_216 sn_52 sn_216 7.910636922015661e-16
Rsub_52_208 sn_52 sn_208 62350.57812928581
Csub_52_208 sn_52 sn_208 1.689877434717973e-16
Rsub_52_129 sn_52 sn_129 15784.03053422228
Csub_52_129 sn_52 sn_129 6.675407450197994e-16
Rsub_52_206 sn_52 sn_206 69412.83227031889
Csub_52_206 sn_52 sn_206 1.517944615946097e-16
Rsub_52_218 sn_52 sn_218 32457.47733172583
Csub_52_218 sn_52 sn_218 3.246242274020178e-16
Rsub_52_227 sn_52 sn_227 58456.6591799213
Csub_52_227 sn_52 sn_227 1.802443665109256e-16
Rsub_52_60 sn_52 sn_60 489696.555770986
Csub_52_60 sn_52 sn_60 2.151635207162361e-17
Rsub_52_168 sn_52 sn_168 22717.85389088195
Csub_52_168 sn_52 sn_168 4.637974851338811e-16
Rsub_52_190 sn_52 sn_190 26757.86732875001
Csub_52_190 sn_52 sn_190 3.937714232893691e-16
Rsub_52_123 sn_52 sn_123 284524.448800204
Csub_52_123 sn_52 sn_123 3.703190902103751e-17
Rsub_52_160 sn_52 sn_160 11304.3565453392
Csub_52_160 sn_52 sn_160 9.32072821656904e-16
Rsub_52_56 sn_52 sn_56 87266.41471700031
Csub_52_56 sn_52 sn_56 1.20739273366497e-16
Rsub_52_214 sn_52 sn_214 61097.90861281552
Csub_52_214 sn_52 sn_214 1.724524413593419e-16
Rsub_52_198 sn_52 sn_198 27187.24039312522
Csub_52_198 sn_52 sn_198 3.875525191182823e-16
Rsub_52_114 sn_52 sn_114 369956.5552945561
Csub_52_114 sn_52 sn_114 2.848032654493971e-17
Rsub_52_88 sn_52 sn_88 263860.6458200933
Csub_52_88 sn_52 sn_88 3.993200073274299e-17
Rsub_52_86 sn_52 sn_86 168914.0716970167
Csub_52_86 sn_52 sn_86 6.237777229791385e-17
Rsub_52_215 sn_52 sn_215 23616.32587771304
Csub_52_215 sn_52 sn_215 4.461525284156664e-16
Rsub_52_171 sn_52 sn_171 30338.33254349462
Csub_52_171 sn_52 sn_171 3.472993608704219e-16
Rsub_52_228 sn_52 sn_228 1260802.5735892
Csub_52_228 sn_52 sn_228 8.356965414684376e-18
Rsub_52_61 sn_52 sn_61 66884.4491459908
Csub_52_61 sn_52 sn_61 1.575326348166774e-16
Rsub_52_176 sn_52 sn_176 128657.2378258398
Csub_52_176 sn_52 sn_176 8.189576956791955e-17
Rsub_52_97 sn_52 sn_97 22012.58952708945
Csub_52_97 sn_52 sn_97 4.78657156136194e-16
Rsub_52_203 sn_52 sn_203 75406.26317795628
Csub_52_203 sn_52 sn_203 1.397295537290351e-16
Rsub_52_213 sn_52 sn_213 75115.32534909139
Csub_52_213 sn_52 sn_213 1.402707563771133e-16
Rsub_52_126 sn_52 sn_126 116506.0507163187
Csub_52_126 sn_52 sn_126 9.043722139277859e-17
Rsub_52_185 sn_52 sn_185 158428.7491656464
Csub_52_185 sn_52 sn_185 6.650613324740386e-17
Rsub_52_197 sn_52 sn_197 134042.3583578524
Csub_52_197 sn_52 sn_197 7.860562609694461e-17
Rsub_52_117 sn_52 sn_117 270431.1543528613
Csub_52_117 sn_52 sn_117 3.896179612679496e-17
Rsub_52_177 sn_52 sn_177 20865.75963033376
Csub_52_177 sn_52 sn_177 5.049652487567481e-16
Rsub_52_181 sn_52 sn_181 64876.13464661092
Csub_52_181 sn_52 sn_181 1.624092366110227e-16
Rsub_17_95 sn_17 sn_95 52340903.18663461
Csub_17_95 sn_17 sn_95 2.013049615261611e-19
Rsub_17_83 sn_17 sn_83 109471485.9575487
Csub_17_83 sn_17 sn_83 9.624865699106233e-20
Rsub_17_100 sn_17 sn_100 153271300.5176243
Csub_17_100 sn_17 sn_100 6.874400795613027e-20
Rsub_17_80 sn_17 sn_80 17706781.87257172
Csub_17_80 sn_17 sn_80 5.950535550760521e-19
Rsub_17_196 sn_17 sn_196 73975757.399847
Csub_17_196 sn_17 sn_196 1.424315731609095e-19
Rsub_17_162 sn_17 sn_162 48489748.30860822
Csub_17_162 sn_17 sn_162 2.172930128482333e-19
Rsub_17_209 sn_17 sn_209 110389789.8132633
Csub_17_209 sn_17 sn_209 9.544798952922774e-20
Rsub_17_150 sn_17 sn_150 40756985.74613379
Csub_17_150 sn_17 sn_150 2.585196944607096e-19
Rsub_17_223 sn_17 sn_223 72813751.52616967
Csub_17_223 sn_17 sn_223 1.447045823266383e-19
Rsub_17_94 sn_17 sn_94 54547814.30092055
Csub_17_94 sn_17 sn_94 1.931605076622142e-19
Rsub_17_153 sn_17 sn_153 12374158.52821343
Csub_17_153 sn_17 sn_153 8.514909097217819e-19
Rsub_17_169 sn_17 sn_169 217444686.6768263
Csub_17_169 sn_17 sn_169 4.845592533557594e-20
Rsub_17_125 sn_17 sn_125 80162203.24335046
Csub_17_125 sn_17 sn_125 1.314395447720434e-19
Rsub_17_82 sn_17 sn_82 83213610.51557449
Csub_17_82 sn_17 sn_82 1.266197132530136e-19
Rsub_17_176 sn_17 sn_176 108722343.3384132
Csub_17_176 sn_17 sn_176 9.691185067115187e-20
Rsub_17_165 sn_17 sn_165 49684185.08033908
Csub_17_165 sn_17 sn_165 2.120691621527566e-19
Rsub_17_85 sn_17 sn_85 55116243.84516213
Csub_17_85 sn_17 sn_85 1.911683882492085e-19
Rsub_17_203 sn_17 sn_203 22203708.98825005
Csub_17_203 sn_17 sn_203 4.745370923301952e-19
Rsub_17_71 sn_17 sn_71 24088721.77457023
Csub_17_71 sn_17 sn_71 4.37403179829702e-19
Rsub_17_112 sn_17 sn_112 110075633.2310451
Csub_17_112 sn_17 sn_112 9.572039871998076e-20
Rsub_17_115 sn_17 sn_115 110075633.2310451
Csub_17_115 sn_17 sn_115 9.572039871998076e-20
Rsub_17_207 sn_17 sn_207 22072486.92534432
Csub_17_207 sn_17 sn_207 4.773582395978988e-19
Rsub_17_40 sn_17 sn_40 360842186.1575368
Csub_17_40 sn_17 sn_40 2.919969977576285e-20
Rsub_17_75 sn_17 sn_75 85999465.49749996
Csub_17_75 sn_17 sn_75 1.225180114931796e-19
Rsub_17_190 sn_17 sn_190 164004033.1608267
Csub_17_190 sn_17 sn_190 6.424527067512812e-20
Rsub_17_111 sn_17 sn_111 55226700.2008548
Csub_17_111 sn_17 sn_111 1.90786041242908e-19
Rsub_17_126 sn_17 sn_126 18874155.59260454
Csub_17_126 sn_17 sn_126 5.582492658033672e-19
Rsub_17_224 sn_17 sn_224 27857632.11933793
Csub_17_224 sn_17 sn_224 3.782260982230393e-19
Rsub_17_180 sn_17 sn_180 83160274.78292702
Csub_17_180 sn_17 sn_180 1.267009221618537e-19
Rsub_17_103 sn_17 sn_103 110951291.9770546
Csub_17_103 sn_17 sn_103 9.496494645965015e-20
Rsub_17_106 sn_17 sn_106 74580482.49396348
Csub_17_106 sn_17 sn_106 1.412766872764978e-19
Rsub_17_92 sn_17 sn_92 44427995.3958059
Csub_17_92 sn_17 sn_92 2.371586520697413e-19
Rsub_17_69 sn_17 sn_69 92372278.95231663
Csub_17_69 sn_17 sn_69 1.140654276557259e-19
Rsub_17_97 sn_17 sn_97 2121813.54747013
Csub_17_97 sn_17 sn_97 4.965791416872048e-18
Rsub_17_30 sn_17 sn_30 50453091.83921786
Csub_17_30 sn_17 sn_30 2.088372212313033e-19
Rsub_17_181 sn_17 sn_181 21079764.4256622
Csub_17_181 sn_17 sn_181 4.998387690425533e-19
Rsub_17_47 sn_17 sn_47 3177483.350146864
Csub_17_47 sn_17 sn_47 3.315983859283796e-18
Rsub_17_214 sn_17 sn_214 13725895.04462772
Csub_17_214 sn_17 sn_214 7.676354414755601e-19
Rsub_17_108 sn_17 sn_108 96951909.09770213
Csub_17_108 sn_17 sn_108 1.086774216236628e-19
Rsub_17_105 sn_17 sn_105 62878443.83072377
Csub_17_105 sn_17 sn_105 1.675690882330909e-19
Rsub_17_157 sn_17 sn_157 41902065.20564853
Csub_17_157 sn_17 sn_157 2.514549927436428e-19
Rsub_17_129 sn_17 sn_129 13077855.55124054
Csub_17_129 sn_17 sn_129 8.056736412898007e-19
Rsub_17_202 sn_17 sn_202 18810124.43754536
Csub_17_202 sn_17 sn_202 5.601495905683102e-19
Rsub_17_35 sn_17 sn_35 11241166.10402834
Csub_17_35 sn_17 sn_35 9.373123219355501e-19
Rsub_17_110 sn_17 sn_110 8286218.032728819
Csub_17_110 sn_17 sn_110 1.27156725307168e-18
Rsub_17_68 sn_17 sn_68 55798411.67458332
Csub_17_68 sn_17 sn_68 1.888312442239187e-19
Rsub_17_171 sn_17 sn_171 64734852.06642595
Csub_17_171 sn_17 sn_171 1.627636916728916e-19
Rsub_17_84 sn_17 sn_84 108897904.0487761
Csub_17_84 sn_17 sn_84 9.675561338178414e-20
Rsub_17_18 sn_17 sn_18 40266877.69354427
Csub_17_18 sn_17 sn_18 2.61666265321566e-19
Rsub_17_79 sn_17 sn_79 48763980.57032715
Csub_17_79 sn_17 sn_79 2.160710298666931e-19
Rsub_17_137 sn_17 sn_137 16245763.48261732
Csub_17_137 sn_17 sn_137 6.485680721317809e-19
Rsub_17_130 sn_17 sn_130 13328550.43261455
Csub_17_130 sn_17 sn_130 7.905198360091397e-19
Rsub_17_205 sn_17 sn_205 111453089.0146169
Csub_17_205 sn_17 sn_205 9.45373842518457e-20
Rsub_17_38 sn_17 sn_38 57783619.97559902
Csub_17_38 sn_17 sn_38 1.823437767775603e-19
Rsub_17_160 sn_17 sn_160 46872420.3591328
Csub_17_160 sn_17 sn_160 2.247906854713346e-19
Rsub_17_61 sn_17 sn_61 6329784.855485179
Csub_17_61 sn_17 sn_61 1.664587935101686e-18
Rsub_17_24 sn_17 sn_24 6282220.859914673
Csub_17_24 sn_17 sn_24 1.67719087519841e-18
Rsub_17_191 sn_17 sn_191 22626804.79674134
Csub_17_191 sn_17 sn_191 4.656637822653352e-19
Rsub_17_131 sn_17 sn_131 11968568.13092385
Csub_17_131 sn_17 sn_131 8.803462024004614e-19
Rsub_17_222 sn_17 sn_222 2746144.828821448
Csub_17_222 sn_17 sn_222 3.836827319392292e-18
Rsub_17_145 sn_17 sn_145 54835200.24770247
Csub_17_145 sn_17 sn_145 1.921481722440043e-19
Rsub_17_46 sn_17 sn_46 2056837.49829055
Csub_17_46 sn_17 sn_46 5.12266210188551e-18
Rsub_17_204 sn_17 sn_204 266375.8137953627
Csub_17_204 sn_17 sn_204 3.955495565496205e-17
Rsub_17_28 sn_17 sn_28 126229821.499521
Csub_17_28 sn_17 sn_28 8.347063615446833e-20
Rsub_17_195 sn_17 sn_195 691777.2160850099
Csub_17_195 sn_17 sn_195 1.523103573988654e-17
Rsub_17_25 sn_17 sn_25 96734193.20708543
Csub_17_25 sn_17 sn_25 1.089220176744932e-19
Rsub_17_221 sn_17 sn_221 34504538.31713758
Csub_17_221 sn_17 sn_221 3.053651495170646e-19
Rsub_17_218 sn_17 sn_218 26359323.36660274
Csub_17_218 sn_17 sn_218 3.997251126551952e-19
Rsub_17_51 sn_17 sn_51 737488.6958647756
Csub_17_51 sn_17 sn_51 1.428697627680242e-17
Rsub_17_88 sn_17 sn_88 8053370.36589917
Csub_17_88 sn_17 sn_88 1.308332166970144e-18
Rsub_17_199 sn_17 sn_199 2472417.429932471
Csub_17_199 sn_17 sn_199 4.261611884251189e-18
Rsub_17_41 sn_17 sn_41 177637092.635509
Csub_17_41 sn_17 sn_41 5.93146585879429e-20
Rsub_17_39 sn_17 sn_39 11660563.38567892
Csub_17_39 sn_17 sn_39 9.035998650949001e-19
Rsub_17_206 sn_17 sn_206 60495.75941036194
Csub_17_206 sn_17 sn_206 1.74168960021771e-16
Rsub_17_34 sn_17 sn_34 8188269.38276683
Csub_17_34 sn_17 sn_34 1.286777829318276e-18
Rsub_17_201 sn_17 sn_201 2975604.491705335
Csub_17_201 sn_17 sn_201 3.540955638291662e-18
Rsub_17_210 sn_17 sn_210 55116243.84516213
Csub_17_210 sn_17 sn_210 1.911683882492085e-19
Rsub_17_43 sn_17 sn_43 6631817.614129259
Csub_17_43 sn_17 sn_43 1.588777634623387e-18
Rsub_17_122 sn_17 sn_122 16320941.65637544
Csub_17_122 sn_17 sn_122 6.455806119565496e-19
Rsub_17_99 sn_17 sn_99 2538974.011324511
Csub_17_99 sn_17 sn_99 4.149898130203158e-18
Rsub_17_178 sn_17 sn_178 666100.6772158574
Csub_17_178 sn_17 sn_178 1.581815461631116e-17
Rsub_17_20 sn_17 sn_20 12667628.42518536
Csub_17_20 sn_17 sn_20 8.317644904457188e-19
Rsub_17_138 sn_17 sn_138 614904.0143454728
Csub_17_138 sn_17 sn_138 1.713516785777604e-17
Rsub_17_194 sn_17 sn_194 111453089.0146169
Csub_17_194 sn_17 sn_194 9.45373842518457e-20
Rsub_17_27 sn_17 sn_27 37123083.95771765
Csub_17_27 sn_17 sn_27 2.838256518297568e-19
Rsub_17_189 sn_17 sn_189 27233740.62745621
Csub_17_189 sn_17 sn_189 3.868907927986744e-19
Rsub_17_22 sn_17 sn_22 17606178.0641037
Csub_17_22 sn_17 sn_22 5.984537623024656e-19
Rsub_17_179 sn_17 sn_179 14355433.66190868
Csub_17_179 sn_17 sn_179 7.339718012272912e-19
Rsub_17_141 sn_17 sn_141 6614849.096800891
Csub_17_141 sn_17 sn_141 1.592853192573314e-18
Rsub_17_48 sn_17 sn_48 11935.14207857157
Csub_17_48 sn_17 sn_48 8.828117363719757e-16
Rsub_17_215 sn_17 sn_215 652464.0376919747
Csub_17_215 sn_17 sn_215 1.614875746945646e-17
Rsub_17_175 sn_17 sn_175 110486453.3770227
Csub_17_175 sn_17 sn_175 9.536448297670874e-20
Rsub_17_184 sn_17 sn_184 14699454.16806149
Csub_17_184 sn_17 sn_184 7.167942007753826e-19
Rsub_17_133 sn_17 sn_133 6910286.905815807
Csub_17_133 sn_17 sn_133 1.524753406889999e-18
Rsub_17_45 sn_17 sn_45 41019809.87040823
Csub_17_45 sn_17 sn_45 2.568632944793594e-19
Rsub_17_212 sn_17 sn_212 15492264.08195218
Csub_17_212 sn_17 sn_212 6.801125675687746e-19
Rsub_17_78 sn_17 sn_78 7462308.995986829
Csub_17_78 sn_17 sn_78 1.411960226773836e-18
Rsub_17_225 sn_17 sn_225 18701489.79242394
Csub_17_225 sn_17 sn_225 5.634034303779572e-19
Rsub_17_114 sn_17 sn_114 68722.2208087363
Csub_17_114 sn_17 sn_114 1.533198924341303e-16
Rsub_17_21 sn_17 sn_21 78974131.59145015
Csub_17_21 sn_17 sn_21 1.334168960127027e-19
Rsub_17_188 sn_17 sn_188 3217942.702132105
Csub_17_188 sn_17 sn_188 3.274291831003973e-18
Rsub_17_177 sn_17 sn_177 9978997.520803157
Csub_17_177 sn_17 sn_177 1.055865930446887e-18
Rsub_17_52 sn_17 sn_52 949274.5980302503
Csub_17_52 sn_17 sn_52 1.109951064117091e-17
Rsub_17_219 sn_17 sn_219 14393035.5940395
Csub_17_219 sn_17 sn_219 7.320542934385162e-19
Rsub_17_134 sn_17 sn_134 31229617.79542222
Csub_17_134 sn_17 sn_134 3.373875265221621e-19
Rsub_17_154 sn_17 sn_154 220972906.7540453
Csub_17_154 sn_17 sn_154 4.768224148835437e-20
Rsub_17_216 sn_17 sn_216 29095883.03152133
Csub_17_216 sn_17 sn_216 3.621297037390201e-19
Rsub_17_49 sn_17 sn_49 9472252.476507246
Csub_17_49 sn_17 sn_49 1.112352476706277e-18
Rsub_17_128 sn_17 sn_128 33470885.11021586
Csub_17_128 sn_17 sn_128 3.147954847185709e-19
Rsub_17_166 sn_17 sn_166 87396065.3314542
Csub_17_166 sn_17 sn_166 1.205601586555393e-19
Rsub_17_87 sn_17 sn_87 59435744.46180952
Csub_17_87 sn_17 sn_87 1.77275200262701e-19
Rsub_17_155 sn_17 sn_155 20099597.39929982
Csub_17_155 sn_17 sn_155 5.242136592545402e-19
Rsub_17_76 sn_17 sn_76 1531672.305988816
Csub_17_76 sn_17 sn_76 6.879071627157134e-18
Rsub_17_31 sn_17 sn_31 44302892.58630937
Csub_17_31 sn_17 sn_31 2.378283422849465e-19
Rsub_17_198 sn_17 sn_198 1825909.747845034
Csub_17_198 sn_17 sn_198 5.77053905028182e-18
Rsub_17_60 sn_17 sn_60 1656595.212541105
Csub_17_60 sn_17 sn_60 6.360324732598826e-18
Rsub_17_227 sn_17 sn_227 5368974.513962719
Csub_17_227 sn_17 sn_227 1.962475976525592e-18
Rsub_17_148 sn_17 sn_148 54798619.44148056
Csub_17_148 sn_17 sn_148 1.922764407136554e-19
Rsub_17_220 sn_17 sn_220 29016906.93596298
Csub_17_220 sn_17 sn_220 3.63115321887437e-19
Rsub_17_132 sn_17 sn_132 82386456.0409245
Csub_17_132 sn_17 sn_132 1.27890966653501e-19
Rsub_17_168 sn_17 sn_168 43318852.80434451
Csub_17_168 sn_17 sn_168 2.432308987917908e-19
Rsub_17_89 sn_17 sn_89 110486453.3770227
Csub_17_89 sn_17 sn_89 9.536448297670874e-20
Rsub_17_72 sn_17 sn_72 4706428.114024733
Csub_17_72 sn_17 sn_72 2.238743107715217e-18
Rsub_17_63 sn_17 sn_63 87214700.40194112
Csub_17_63 sn_17 sn_63 1.208108662148829e-19
Rsub_17_230 sn_17 0 150089.5989863137
Csub_17_230 sn_17 0 7.020129025190347e-17
Rsub_17_226 sn_17 sn_226 7979570.102915819
Csub_17_226 sn_17 sn_226 1.320432475225684e-18
Rsub_17_117 sn_17 sn_117 12984897.59570986
Csub_17_117 sn_17 sn_117 8.114414014101424e-19
Rsub_17_170 sn_17 sn_170 4044281.737589241
Csub_17_170 sn_17 sn_170 2.605279301958498e-18
Rsub_17_62 sn_17 sn_62 34481498.65081008
Csub_17_62 sn_17 sn_62 3.055691867958433e-19
Rsub_17_229 sn_17 sn_229 17893268.6491412
Csub_17_229 sn_17 sn_229 5.888518028110929e-19
Rsub_17_65 sn_17 sn_65 110486453.3770227
Csub_17_65 sn_17 sn_65 9.536448297670874e-20
Rsub_17_44 sn_17 sn_44 19256498.69546816
Csub_17_44 sn_17 sn_44 5.471650723664352e-19
Rsub_17_156 sn_17 sn_156 26305298.87591787
Csub_17_156 sn_17 sn_156 4.005460478487855e-19
Rsub_17_200 sn_17 sn_200 21423136.51844386
Csub_17_200 sn_17 sn_200 4.918273051734888e-19
Rsub_17_182 sn_17 sn_182 16457989.53704314
Csub_17_182 sn_17 sn_182 6.402047758333304e-19
Rsub_96_214 sn_96 sn_214 6458358.945131047
Csub_96_214 sn_96 sn_214 1.631449040188987e-18
Rsub_96_151 sn_96 sn_151 143132.8549825849
Csub_96_151 sn_96 sn_151 7.361331193674567e-17
Rsub_96_113 sn_96 sn_113 1722238.407151573
Csub_96_113 sn_96 sn_113 6.117900668384462e-18
Rsub_96_141 sn_96 sn_141 153007.6263621023
Csub_96_141 sn_96 sn_141 6.886247275867639e-17
Rsub_96_148 sn_96 sn_148 10594326.58803297
Csub_96_148 sn_96 sn_148 9.94540182868413e-19
Rsub_96_137 sn_96 sn_137 392992.9825654136
Csub_96_137 sn_96 sn_137 2.68108693276125e-17
Rsub_96_178 sn_96 sn_178 12926518.73639893
Csub_96_178 sn_96 sn_178 8.151060403108391e-19
Rsub_96_225 sn_96 sn_225 351731.3832556311
Csub_96_225 sn_96 sn_225 2.995605170259232e-17
Rsub_96_194 sn_96 sn_194 3403424.032976528
Csub_96_194 sn_96 sn_194 3.095848004873822e-18
Rsub_96_218 sn_96 sn_218 1849335.083664365
Csub_96_218 sn_96 sn_218 5.697444230254091e-18
Rsub_96_139 sn_96 sn_139 91154.08505757997
Csub_96_139 sn_96 sn_139 1.155898114228709e-16
Rsub_96_162 sn_96 sn_162 8497863.091063121
Csub_96_162 sn_96 sn_162 1.239898006042345e-18
Rsub_96_117 sn_96 sn_117 274860.0876622773
Csub_96_117 sn_96 sn_117 3.83339887280261e-17
Rsub_96_163 sn_96 sn_163 2803517.411021318
Csub_96_163 sn_96 sn_163 3.758308566520218e-18
Rsub_96_128 sn_96 sn_128 96724.28942780176
Csub_96_128 sn_96 sn_128 1.089331704017819e-16
Rsub_96_207 sn_96 sn_207 21475421.74855223
Csub_96_207 sn_96 sn_207 4.906298756596162e-19
Rsub_96_119 sn_96 sn_119 380231.6215785937
Csub_96_119 sn_96 sn_119 2.771069764920147e-17
Rsub_96_114 sn_96 sn_114 15395721.04250326
Csub_96_114 sn_96 sn_114 6.843773976640478e-19
Rsub_96_173 sn_96 sn_173 25325853.70496933
Csub_96_173 sn_96 sn_173 4.16036656650298e-19
Rsub_96_195 sn_96 sn_195 881497.6541206142
Csub_96_195 sn_96 sn_195 1.19529342511311e-17
Rsub_96_121 sn_96 sn_121 3760112.471976307
Csub_96_121 sn_96 sn_121 2.802172429882675e-18
Rsub_96_200 sn_96 sn_200 13268981.95947632
Csub_96_200 sn_96 sn_200 7.940687186408564e-19
Rsub_96_209 sn_96 sn_209 1432.750725610013
Csub_96_209 sn_96 sn_209 7.354024195481701e-15
Rsub_96_170 sn_96 sn_170 3051736.025591491
Csub_96_170 sn_96 sn_170 3.452619562725058e-18
Rsub_96_135 sn_96 sn_135 6017008.594462053
Csub_96_135 sn_96 sn_135 1.751116578415326e-18
Rsub_96_172 sn_96 sn_172 2232230.962387617
Csub_96_172 sn_96 sn_172 4.72015829892444e-18
Rsub_96_98 sn_96 sn_98 22720449.60643126
Csub_96_98 sn_96 sn_98 4.637444982271626e-19
Rsub_96_177 sn_96 sn_177 243966.0457913224
Csub_96_177 sn_96 sn_177 4.31883193747479e-17
Rsub_96_161 sn_96 sn_161 1310999.5834872
Csub_96_161 sn_96 sn_161 8.036984629852761e-18
Rsub_96_124 sn_96 sn_124 1326736.679091599
Csub_96_124 sn_96 sn_124 7.941653885263962e-18
Rsub_96_187 sn_96 sn_187 4118.962217612041
Csub_96_187 sn_96 sn_187 2.558043251083401e-15
Rsub_96_157 sn_96 sn_157 5636.507038650855
Csub_96_157 sn_96 sn_157 1.869328545139544e-15
Rsub_96_109 sn_96 sn_109 172318.3807966621
Csub_96_109 sn_96 sn_109 6.114544167324313e-17
Rsub_96_188 sn_96 sn_188 88737151.53115207
Csub_96_188 sn_96 sn_188 1.187381307651177e-19
Rsub_96_220 sn_96 sn_220 350.5809483281801
Csub_96_220 sn_96 sn_220 3.005435278920736e-14
Rsub_96_145 sn_96 sn_145 529986.2103463704
Csub_96_145 sn_96 sn_145 1.988067481103693e-17
Rsub_96_226 sn_96 sn_226 1371590.57836022
Csub_96_226 sn_96 sn_226 7.681945085119135e-18
Rsub_96_189 sn_96 sn_189 70528.79905983101
Csub_96_189 sn_96 sn_189 1.493926402077496e-16
Rsub_96_104 sn_96 sn_104 23966.41527184763
Csub_96_104 sn_96 sn_104 4.396353556723512e-16
Rsub_96_222 sn_96 sn_222 5390616.123955372
Csub_96_222 sn_96 sn_222 1.954597259375769e-18
Rsub_96_127 sn_96 sn_127 259831.6774820001
Csub_96_127 sn_96 sn_127 4.055118915575611e-17
Rsub_96_206 sn_96 sn_206 11196214.92042688
Csub_96_206 sn_96 sn_206 9.410754953450177e-19
Rsub_96_205 sn_96 sn_205 203032.0910612575
Csub_96_205 sn_96 sn_205 5.189565574168768e-17
Rsub_96_126 sn_96 sn_126 2210230.909720979
Csub_96_126 sn_96 sn_126 4.767141503581692e-18
Rsub_96_100 sn_96 sn_100 54441.93401757621
Csub_96_100 sn_96 sn_100 1.935361719300488e-16
Rsub_96_229 sn_96 sn_229 485590.8359586205
Csub_96_229 sn_96 sn_229 2.169827501260313e-17
Rsub_96_129 sn_96 sn_129 130997.6608551378
Csub_96_129 sn_96 sn_129 8.043260798283753e-17
Rsub_96_144 sn_96 sn_144 90283616.40718544
Csub_96_144 sn_96 sn_144 1.167042695178461e-19
Rsub_96_133 sn_96 sn_133 43547992.66315243
Csub_96_133 sn_96 sn_133 2.419510718606626e-19
Rsub_96_212 sn_96 sn_212 3574738.450768866
Csub_96_212 sn_96 sn_212 2.947483752262709e-18
Rsub_96_131 sn_96 sn_131 1799234.410600306
Csub_96_131 sn_96 sn_131 5.856092702625975e-18
Rsub_96_155 sn_96 sn_155 715883.366991763
Csub_96_155 sn_96 sn_155 1.471815659931548e-17
Rsub_96_219 sn_96 sn_219 2511921.429633395
Csub_96_219 sn_96 sn_219 4.194591191400346e-18
Rsub_96_102 sn_96 sn_102 46955400.26417395
Csub_96_102 sn_96 sn_102 2.24393433831915e-19
Rsub_96_204 sn_96 sn_204 11955049.41721689
Csub_96_204 sn_96 sn_204 8.813416937495913e-19
Rsub_96_185 sn_96 sn_185 1517085.346979668
Csub_96_185 sn_96 sn_185 6.945214732451841e-18
Rsub_96_106 sn_96 sn_106 49629799.78883816
Csub_96_106 sn_96 sn_106 2.123015516294643e-19
Rsub_96_191 sn_96 sn_191 778233.5606625235
Csub_96_191 sn_96 sn_191 1.353897343268018e-17
Rsub_96_211 sn_96 sn_211 11576957.78980905
Csub_96_211 sn_96 sn_211 9.101254140794262e-19
Rsub_96_230 sn_96 0 73614.71825140926
Csub_96_230 sn_96 0 1.431301206131872e-16
Rsub_96_197 sn_96 sn_197 16230033.01984661
Csub_96_197 sn_96 sn_197 6.491966768857247e-19
Rsub_96_180 sn_96 sn_180 7444957.518062199
Csub_96_180 sn_96 sn_180 1.415250990575494e-18
Rsub_96_160 sn_96 sn_160 15965354.69374523
Csub_96_160 sn_96 sn_160 6.59959249534111e-19
Rsub_96_192 sn_96 sn_192 8492568.519956229
Csub_96_192 sn_96 sn_192 1.24067100282687e-18
Rsub_96_227 sn_96 sn_227 41927144.81167322
Csub_96_227 sn_96 sn_227 2.513045796358752e-19
Rsub_96_182 sn_96 sn_182 76774631.84333758
Csub_96_182 sn_96 sn_182 1.372391276812661e-19
Rsub_96_171 sn_96 sn_171 12314405.27450022
Csub_96_171 sn_96 sn_171 8.556226035574928e-19
Rsub_96_166 sn_96 sn_166 4309754.400366189
Csub_96_166 sn_96 sn_166 2.444799058928913e-18
Rsub_96_142 sn_96 sn_142 8877350.879616678
Csub_96_142 sn_96 sn_142 1.186895014640332e-18
Rsub_96_216 sn_96 sn_216 3128558.611252441
Csub_96_216 sn_96 sn_216 3.367839574535566e-18
Rsub_96_136 sn_96 sn_136 308698.7098661068
Csub_96_136 sn_96 sn_136 3.413193241656253e-17
Rsub_96_215 sn_96 sn_215 1691299.958140336
Csub_96_215 sn_96 sn_215 6.229813612610362e-18
Rsub_96_184 sn_96 sn_184 48001090.74053548
Csub_96_184 sn_96 sn_184 2.195050849820015e-19
Rsub_132_227 sn_132 sn_227 1629926.717539946
Csub_132_227 sn_132 sn_227 6.464390937853176e-18
Rsub_132_147 sn_132 sn_147 144527.4338992501
Csub_132_147 sn_132 sn_147 7.290299992162713e-17
Rsub_132_149 sn_132 sn_149 693784.547197661
Csub_132_149 sn_132 sn_149 1.518696769016985e-17
Rsub_132_145 sn_132 sn_145 1767658.040525565
Csub_132_145 sn_132 sn_145 5.960702387378763e-18
Rsub_132_159 sn_132 sn_159 94426.82282475661
Csub_132_159 sn_132 sn_159 1.11583585966715e-16
Rsub_132_182 sn_132 sn_182 16727190.32873321
Csub_132_182 sn_132 sn_182 6.299015731369366e-19
Rsub_132_205 sn_132 sn_205 390898.8300501204
Csub_132_205 sn_132 sn_205 2.695450252659757e-17
Rsub_132_175 sn_132 sn_175 498513.5475216809
Csub_132_175 sn_132 sn_175 2.113580173419812e-17
Rsub_132_197 sn_132 sn_197 2920131.076370187
Csub_132_197 sn_132 sn_197 3.608222790919089e-18
Rsub_132_210 sn_132 sn_210 895686.242331909
Csub_132_210 sn_132 sn_210 1.176358752011015e-17
Rsub_132_198 sn_132 sn_198 754528.2350524862
Csub_132_198 sn_132 sn_198 1.39643329603127e-17
Rsub_132_188 sn_132 sn_188 17452522.87289441
Csub_132_188 sn_132 sn_188 6.037226582635949e-19
Rsub_132_181 sn_132 sn_181 47428.16840605
Csub_132_181 sn_132 sn_181 2.221566604053373e-16
Rsub_132_135 sn_132 sn_135 263848.060885936
Csub_132_135 sn_132 sn_135 3.993390539559441e-17
Rsub_132_214 sn_132 sn_214 7548311.975319919
Csub_132_214 sn_132 sn_214 1.395872817217976e-18
Rsub_132_172 sn_132 sn_172 1072870.143054838
Csub_132_172 sn_132 sn_172 9.820837657229356e-18
Rsub_132_168 sn_132 sn_168 18390199.30307523
Csub_132_168 sn_132 sn_168 5.72940147552837e-19
Rsub_132_162 sn_132 sn_162 781426.5634557611
Csub_132_162 sn_132 sn_162 1.348365156110604e-17
Rsub_132_199 sn_132 sn_199 25239136.53870786
Csub_132_199 sn_132 sn_199 4.174660843119884e-19
Rsub_132_163 sn_132 sn_163 1511921.579344811
Csub_132_163 sn_132 sn_163 6.96893519225777e-18
Rsub_132_216 sn_132 sn_216 241259.9800750108
Csub_132_216 sn_132 sn_216 4.367273635251928e-17
Rsub_132_137 sn_132 sn_137 609.3963671476789
Csub_132_137 sn_132 sn_137 1.729003333503074e-14
Rsub_132_142 sn_132 sn_142 8882983.887742523
Csub_132_142 sn_132 sn_142 1.186142363352602e-18
Rsub_132_221 sn_132 sn_221 8060390.770689397
Csub_132_221 sn_132 sn_221 1.307192641397066e-18
Rsub_132_158 sn_132 sn_158 192598.944683649
Csub_132_158 sn_132 sn_158 5.470685999622983e-17
Rsub_132_139 sn_132 sn_139 4677.469654787144
Csub_132_139 sn_132 sn_139 2.252603283368491e-15
Rsub_132_190 sn_132 sn_190 140105.4320011703
Csub_132_190 sn_132 sn_190 7.520396141487212e-17
Rsub_132_208 sn_132 sn_208 1310446.522855464
Csub_132_208 sn_132 sn_208 8.040376557504229e-18
Rsub_132_171 sn_132 sn_171 1347164.021944402
Csub_132_171 sn_132 sn_171 7.8212328495994e-18
Rsub_132_213 sn_132 sn_213 4120345.892029613
Csub_132_213 sn_132 sn_213 2.557184221502313e-18
Rsub_132_185 sn_132 sn_185 38104.21808432988
Csub_132_185 sn_132 sn_185 2.765175099226892e-16
Rsub_132_178 sn_132 sn_178 6389507.314910841
Csub_132_178 sn_132 sn_178 1.649029100826224e-18
Rsub_132_141 sn_132 sn_141 2925.27438689067
Csub_132_141 sn_132 sn_141 3.601878698780606e-15
Rsub_132_206 sn_132 sn_206 769721.4374915446
Csub_132_206 sn_132 sn_206 1.36886969610298e-17
Rsub_132_211 sn_132 sn_211 5284671.480686998
Csub_132_211 sn_132 sn_211 1.993782118857514e-18
Rsub_132_146 sn_132 sn_146 1244343.178567695
Csub_132_146 sn_132 sn_146 8.467506137943437e-18
Rsub_132_154 sn_132 sn_154 44335.26845387784
Csub_132_154 sn_132 sn_154 2.376546679353289e-16
Rsub_132_226 sn_132 sn_226 1807693.270239965
Csub_132_226 sn_132 sn_226 5.828689897612619e-18
Rsub_132_189 sn_132 sn_189 96920.4771412632
Csub_132_189 sn_132 sn_189 1.087126664355243e-16
Rsub_132_138 sn_132 sn_138 1014904.256511883
Csub_132_138 sn_132 sn_138 1.038175121901919e-17
Rsub_132_155 sn_132 sn_155 75550.94149746624
Csub_132_155 sn_132 sn_155 1.394619748396301e-16
Rsub_132_156 sn_132 sn_156 456.4232924852107
Csub_132_156 sn_132 sn_156 2.308489438577767e-14
Rsub_132_230 sn_132 0 8493.226986605257
Csub_132_230 sn_132 0 1.240574815537979e-15
Rsub_132_151 sn_132 sn_151 53961.02035482565
Csub_132_151 sn_132 sn_151 1.952610130969797e-16
Rsub_132_186 sn_132 sn_186 5529442.584197792
Csub_132_186 sn_132 sn_186 1.905523629514028e-18
Rsub_132_148 sn_132 sn_148 1218143.902627397
Csub_132_148 sn_132 sn_148 8.649621345642345e-18
Rsub_132_184 sn_132 sn_184 2594154.94394586
Csub_132_184 sn_132 sn_184 4.061624586773294e-18
Rsub_132_212 sn_132 sn_212 845024.9554309216
Csub_132_212 sn_132 sn_212 1.24688430022246e-17
Rsub_132_133 sn_132 sn_133 17765504.92444361
Csub_132_133 sn_132 sn_133 5.930866331715022e-19
Rsub_132_192 sn_132 sn_192 1066000.160167485
Csub_132_192 sn_132 sn_192 9.884129380031762e-18
Rsub_132_229 sn_132 sn_229 36740.81460369535
Csub_132_229 sn_132 sn_229 2.86778712336178e-16
Rsub_132_150 sn_132 sn_150 1097381.110883215
Csub_132_150 sn_132 sn_150 9.60148065037299e-18
Rsub_132_160 sn_132 sn_160 364569.2712754073
Csub_132_160 sn_132 sn_160 2.890118375958901e-17
Rsub_132_222 sn_132 sn_222 183129.6100305159
Csub_132_222 sn_132 sn_222 5.753566285907696e-17
Rsub_132_219 sn_132 sn_219 1492468.364696924
Csub_132_219 sn_132 sn_219 7.059770077183276e-18
Rsub_132_140 sn_132 sn_140 1168112.573602965
Csub_132_140 sn_132 sn_140 9.020092532461081e-18
Rsub_132_170 sn_132 sn_170 858629.243207508
Csub_132_170 sn_132 sn_170 1.227128424239286e-17
Rsub_132_195 sn_132 sn_195 1581692.883943762
Csub_132_195 sn_132 sn_195 6.661522985396846e-18
Rsub_132_204 sn_132 sn_204 2163534.074050214
Csub_132_204 sn_132 sn_204 4.87003353846206e-18
Rsub_132_157 sn_132 sn_157 198573.264655565
Csub_132_157 sn_132 sn_157 5.30609370828749e-17
Rsub_132_215 sn_132 sn_215 1770372.83065215
Csub_132_215 sn_132 sn_215 5.951561908204778e-18
Rsub_132_228 sn_132 sn_228 4548228.378380692
Csub_132_228 sn_132 sn_228 2.316612673258354e-18
Rsub_132_193 sn_132 sn_193 22570942.13782572
Csub_132_193 sn_132 sn_193 4.668162914020474e-19
Rsub_132_166 sn_132 sn_166 2557992.509705983
Csub_132_166 sn_132 sn_166 4.119043923018004e-18
Rsub_132_179 sn_132 sn_179 39680.33746995653
Csub_132_179 sn_132 sn_179 2.655341202732353e-16
Rsub_132_196 sn_132 sn_196 43429.69082543611
Csub_132_196 sn_132 sn_196 2.426101430143947e-16
Rsub_132_200 sn_132 sn_200 24318323.96148444
Csub_132_200 sn_132 sn_200 4.332734245549887e-19
Rsub_132_191 sn_132 sn_191 45124.56221199706
Csub_132_191 sn_132 sn_191 2.334977445926049e-16
Rsub_132_224 sn_132 sn_224 409017.6102199711
Csub_132_224 sn_132 sn_224 2.576046419263817e-17
Rsub_132_207 sn_132 sn_207 2027285.252057428
Csub_132_207 sn_132 sn_207 5.197336433803213e-18
Rsub_132_164 sn_132 sn_164 1621827.243818954
Csub_132_164 sn_132 sn_164 6.496674379090772e-18
Rsub_132_144 sn_132 sn_144 6973100.836281954
Csub_132_144 sn_132 sn_144 1.511018376130071e-18
Rsub_132_209 sn_132 sn_209 236707.8580184244
Csub_132_209 sn_132 sn_209 4.451260549791246e-17
Rsub_132_176 sn_132 sn_176 5913468.381491756
Csub_132_176 sn_132 sn_176 1.781777262089972e-18
Rsub_169_193 sn_169 sn_193 47268482.67835878
Csub_169_193 sn_169 sn_193 2.229071657308345e-19
Rsub_169_172 sn_169 sn_172 6358136.326923896
Csub_169_172 sn_169 sn_172 1.657165395717084e-18
Rsub_169_214 sn_169 sn_214 6412113.828278644
Csub_169_214 sn_169 sn_214 1.643215292866777e-18
Rsub_169_182 sn_169 sn_182 29788854.3817255
Csub_169_182 sn_169 sn_182 3.53705562732006e-19
Rsub_169_219 sn_169 sn_219 1026733.133264733
Csub_169_219 sn_169 sn_219 1.026214423287076e-17
Rsub_169_204 sn_169 sn_204 2128430.738083486
Csub_169_204 sn_169 sn_204 4.950353005950957e-18
Rsub_169_226 sn_169 sn_226 199673505.1450302
Csub_169_226 sn_169 sn_226 5.276856082922451e-20
Rsub_169_189 sn_169 sn_189 418780.4832531738
Csub_169_189 sn_169 sn_189 2.515992010988766e-17
Rsub_169_208 sn_169 sn_208 2405763.505478052
Csub_169_208 sn_169 sn_208 4.379683821056336e-18
Rsub_169_224 sn_169 sn_224 1895206.055351962
Csub_169_224 sn_169 sn_224 5.559545080850458e-18
Rsub_169_190 sn_169 sn_190 1066124.754284327
Csub_169_190 sn_169 sn_190 9.882974257832493e-18
Rsub_169_180 sn_169 sn_180 415144.5509160879
Csub_169_180 sn_169 sn_180 2.538027653013736e-17
Rsub_169_213 sn_169 sn_213 11275308.61259807
Csub_169_213 sn_169 sn_213 9.344740675618791e-19
Rsub_169_191 sn_169 sn_191 1584.057674887818
Csub_169_191 sn_169 sn_191 6.651578202779887e-15
Rsub_169_228 sn_169 sn_228 2587129.051205324
Csub_169_228 sn_169 sn_228 4.072654782072481e-18
Rsub_169_177 sn_169 sn_177 2929.021508602812
Csub_169_177 sn_169 sn_177 3.597270785237785e-15
Rsub_169_206 sn_169 sn_206 3063648.467031563
Csub_169_206 sn_169 sn_206 3.439194677723268e-18
Rsub_169_181 sn_169 sn_181 450.6895891903811
Csub_169_181 sn_169 sn_181 2.337858196626584e-14
Rsub_169_230 sn_169 0 10003.69712969302
Csub_169_230 sn_169 0 1.05325894673036e-15
Rsub_169_185 sn_169 sn_185 3683.994727403805
Csub_169_185 sn_169 sn_185 2.860070190614876e-15
Rsub_169_222 sn_169 sn_222 1676451.809269509
Csub_169_222 sn_169 sn_222 6.284990385032976e-18
Rsub_169_207 sn_169 sn_207 1880050.015159377
Csub_169_207 sn_169 sn_207 5.604363403777211e-18
Rsub_169_170 sn_169 sn_170 8802708.086652676
Csub_169_170 sn_169 sn_170 1.19695932189393e-18
Rsub_169_184 sn_169 sn_184 9946003.983614005
Csub_169_184 sn_169 sn_184 1.059368518209807e-18
Rsub_169_221 sn_169 sn_221 8349670.700469441
Csub_169_221 sn_169 sn_221 1.261904077443151e-18
Rsub_169_215 sn_169 sn_215 1812108.639428569
Csub_169_215 sn_169 sn_215 5.814487759162488e-18
Rsub_169_195 sn_169 sn_195 394308.691749101
Csub_169_195 sn_169 sn_195 2.672140818274017e-17
Rsub_169_210 sn_169 sn_210 643886.3788352724
Csub_169_210 sn_169 sn_210 1.636388631374602e-17
Rsub_169_205 sn_169 sn_205 19302837.3391638
Csub_169_205 sn_169 sn_205 5.458515407396809e-19
Rsub_169_223 sn_169 sn_223 971200.8559883109
Csub_169_223 sn_169 sn_223 1.084892320395238e-17
Rsub_169_216 sn_169 sn_216 7154795.385693438
Csub_169_216 sn_169 sn_216 1.472646376903874e-18
Rsub_169_211 sn_169 sn_211 33518090.73358058
Csub_169_211 sn_169 sn_211 3.143521385504776e-19
Rsub_169_197 sn_169 sn_197 63950578.76084059
Csub_169_197 sn_169 sn_197 1.647597833576121e-19
Rsub_2_7 sn_2 sn_7 407001935.2090585
Csub_2_7 sn_2 sn_7 2.588804276033205e-20
Rsub_2_18 sn_2 sn_18 226570587.2840116
Csub_2_18 sn_2 sn_18 4.650419822155587e-20
Rsub_2_15 sn_2 sn_15 343687737.8180324
Csub_2_15 sn_2 sn_15 3.065714118613277e-20
Rsub_2_148 sn_2 sn_148 374885466.1499896
Csub_2_148 sn_2 sn_148 2.81058735363574e-20
Rsub_2_104 sn_2 sn_104 193200079.5407752
Csub_2_104 sn_2 sn_104 5.453664163738742e-20
Rsub_2_112 sn_2 sn_112 374885466.1499896
Csub_2_112 sn_2 sn_112 2.81058735363574e-20
Rsub_2_150 sn_2 sn_150 231803002.5713647
Csub_2_150 sn_2 sn_150 4.545447377881207e-20
Rsub_2_167 sn_2 sn_167 140408709.2795602
Csub_2_167 sn_2 sn_167 7.50415238220827e-20
Rsub_2_158 sn_2 sn_158 321718814.0945464
Csub_2_158 sn_2 sn_158 3.27505978532345e-20
Rsub_2_125 sn_2 sn_125 296206772.2244041
Csub_2_125 sn_2 sn_125 3.557137948975602e-20
Rsub_2_229 sn_2 sn_229 162917525.5938869
Csub_2_229 sn_2 sn_229 6.467372656085415e-20
Rsub_2_121 sn_2 sn_121 204830225.7593226
Csub_2_121 sn_2 sn_121 5.144008147806498e-20
Rsub_2_162 sn_2 sn_162 374885466.1499896
Csub_2_162 sn_2 sn_162 2.81058735363574e-20
Rsub_2_135 sn_2 sn_135 374885466.1499896
Csub_2_135 sn_2 sn_135 2.81058735363574e-20
Rsub_2_155 sn_2 sn_155 254952109.036599
Csub_2_155 sn_2 sn_155 4.132730473203289e-20
Rsub_2_137 sn_2 sn_137 277224229.6977519
Csub_2_137 sn_2 sn_137 3.800708009439712e-20
Rsub_2_33 sn_2 sn_33 374885466.1499896
Csub_2_33 sn_2 sn_33 2.81058735363574e-20
Rsub_2_200 sn_2 sn_200 4619293.519780648
Csub_2_200 sn_2 sn_200 2.280972936036838e-18
Rsub_2_209 sn_2 sn_209 304758989.8512636
Csub_2_209 sn_2 sn_209 3.457316716849694e-20
Rsub_2_136 sn_2 sn_136 375900433.5694636
Csub_2_136 sn_2 sn_136 2.80299849675032e-20
Rsub_2_154 sn_2 sn_154 124252953.951207
Csub_2_154 sn_2 sn_154 8.479865602525296e-20
Rsub_2_130 sn_2 sn_130 56719361.80770986
Csub_2_130 sn_2 sn_130 1.857651984511183e-19
Rsub_2_175 sn_2 sn_175 264671782.0258038
Csub_2_175 sn_2 sn_175 3.980962164377146e-20
Rsub_2_77 sn_2 sn_77 183999045.1762674
Csub_2_77 sn_2 sn_77 5.726379445141284e-20
Rsub_2_202 sn_2 sn_202 225397616.4861814
Csub_2_202 sn_2 sn_202 4.674620639955155e-20
Rsub_2_35 sn_2 sn_35 176340623.2000926
Csub_2_35 sn_2 sn_35 5.97507443890244e-20
Rsub_2_117 sn_2 sn_117 36757129.81078617
Csub_2_117 sn_2 sn_117 2.866514212744144e-19
Rsub_2_129 sn_2 sn_129 110976960.4271213
Csub_2_129 sn_2 sn_129 9.494298151326033e-20
Rsub_2_230 sn_2 0 1103739.676662205
Csub_2_230 sn_2 0 9.546167203206059e-18
Rsub_2_20 sn_2 sn_20 310391729.0105488
Csub_2_20 sn_2 sn_20 3.394576117030462e-20
Rsub_2_132 sn_2 sn_132 49138110.84995563
Csub_2_132 sn_2 sn_132 2.144258971290817e-19
Rsub_2_96 sn_2 sn_96 104549033.7781797
Csub_2_96 sn_2 sn_96 1.007803049101833e-19
Rsub_2_79 sn_2 sn_79 130270319.5944123
Csub_2_79 sn_2 sn_79 8.088168920621839e-20
Rsub_2_201 sn_2 sn_201 40273508.85639907
Csub_2_201 sn_2 sn_201 2.616231811287994e-19
Rsub_2_34 sn_2 sn_34 45817789.02243041
Csub_2_34 sn_2 sn_34 2.299649050518739e-19
Rsub_2_198 sn_2 sn_198 16968307.8428019
Csub_2_198 sn_2 sn_198 6.20950751238266e-19
Rsub_2_40 sn_2 sn_40 1799730561.854852
Rsub_2_94 sn_2 sn_94 375900433.5694636
Csub_2_94 sn_2 sn_94 2.80299849675032e-20
Rsub_2_3 sn_2 sn_3 347795502.4064108
Csub_2_3 sn_2 sn_3 3.029505393062203e-20
Rsub_2_170 sn_2 sn_170 25016593.23817613
Csub_2_170 sn_2 sn_170 4.211797906259668e-19
Rsub_2_179 sn_2 sn_179 187696131.903022
Csub_2_179 sn_2 sn_179 5.61358585038606e-20
Rsub_2_133 sn_2 sn_133 44613234.71241243
Csub_2_133 sn_2 sn_133 2.361739418840775e-19
Rsub_2_105 sn_2 sn_105 198335511.053607
Csub_2_105 sn_2 sn_105 5.3124543589081e-20
Rsub_2_72 sn_2 sn_72 22697527.96708799
Csub_2_72 sn_2 sn_72 4.642128216565336e-19
Rsub_2_151 sn_2 sn_151 146623274.6962259
Csub_2_151 sn_2 sn_151 7.186092060799685e-20
Rsub_2_41 sn_2 sn_41 23782727.20459965
Csub_2_41 sn_2 sn_41 4.430309195234856e-19
Rsub_2_199 sn_2 sn_199 16848392.31853268
Csub_2_199 sn_2 sn_199 6.25370261033168e-19
Rsub_2_226 sn_2 sn_226 114783420.3445535
Csub_2_226 sn_2 sn_226 9.179447232537502e-20
Rsub_2_44 sn_2 sn_44 31418875.21041857
Csub_2_44 sn_2 sn_44 3.35355210257052e-19
Rsub_2_222 sn_2 sn_222 52557662.57856429
Csub_2_222 sn_2 sn_222 2.004747354675419e-19
Rsub_2_219 sn_2 sn_219 1771822.199318326
Csub_2_219 sn_2 sn_219 5.946693469741891e-18
Rsub_2_52 sn_2 sn_52 8816612.530772623
Csub_2_52 sn_2 sn_52 1.195071629319596e-18
Rsub_2_131 sn_2 sn_131 33011931.17650127
Csub_2_131 sn_2 sn_131 3.191719819690567e-19
Rsub_2_213 sn_2 sn_213 375900433.5694636
Csub_2_213 sn_2 sn_213 2.80299849675032e-20
Rsub_2_46 sn_2 sn_46 370738.7141762628
Csub_2_46 sn_2 sn_46 2.842024072301381e-17
Rsub_2_204 sn_2 sn_204 470407.7301800638
Csub_2_204 sn_2 sn_204 2.2398618955936e-17
Rsub_2_17 sn_2 sn_17 1572451.026142038
Csub_2_17 sn_2 sn_17 6.70067514158514e-18
Rsub_2_99 sn_2 sn_99 2552200.417684015
Csub_2_99 sn_2 sn_99 4.128391888514498e-18
Rsub_2_178 sn_2 sn_178 15689584.90595087
Csub_2_178 sn_2 sn_178 6.715590989429963e-19
Rsub_2_127 sn_2 sn_127 116359539.5469829
Csub_2_127 sn_2 sn_127 9.055109313126533e-20
Rsub_2_218 sn_2 sn_218 146016211.2270085
Csub_2_218 sn_2 sn_218 7.215968291253047e-20
Rsub_2_51 sn_2 sn_51 56479.77211743969
Csub_2_51 sn_2 sn_51 1.865532226355526e-16
Rsub_2_172 sn_2 sn_172 196886071.2744736
Csub_2_172 sn_2 sn_172 5.351563690628663e-20
Rsub_2_97 sn_2 sn_97 108720370.0329698
Csub_2_97 sn_2 sn_97 9.691360964863141e-20
Rsub_2_227 sn_2 sn_227 49154342.5713542
Csub_2_227 sn_2 sn_227 2.143550895210299e-19
Rsub_2_60 sn_2 sn_60 201975548.9451718
Csub_2_60 sn_2 sn_60 5.216712397741881e-20
Rsub_2_139 sn_2 sn_139 48747293.8710014
Csub_2_139 sn_2 sn_139 2.161449931992615e-19
Rsub_2_138 sn_2 sn_138 24241691.21409342
Csub_2_138 sn_2 sn_138 4.346430869519696e-19
Rsub_2_50 sn_2 sn_50 54456470.8604838
Csub_2_50 sn_2 sn_50 1.934845085577475e-19
Rsub_2_217 sn_2 sn_217 94027318.21697246
Csub_2_217 sn_2 sn_217 1.120576838947653e-19
Rsub_2_101 sn_2 sn_101 5785405.376122495
Csub_2_101 sn_2 sn_101 1.821217843388493e-18
Rsub_2_24 sn_2 sn_24 23484821.59297426
Csub_2_24 sn_2 sn_24 4.486507789942975e-19
Rsub_2_195 sn_2 sn_195 15036070.72260839
Csub_2_195 sn_2 sn_195 7.007471364435149e-19
Rsub_2_107 sn_2 sn_107 6873089.711414068
Csub_2_107 sn_2 sn_107 1.533005379623108e-18
Rsub_2_188 sn_2 sn_188 35647197.77622175
Csub_2_188 sn_2 sn_188 2.955767678675236e-19
Rsub_2_30 sn_2 sn_30 375900433.5694636
Csub_2_30 sn_2 sn_30 2.80299849675032e-20
Rsub_2_109 sn_2 sn_109 751800867.1389272
Csub_2_109 sn_2 sn_109 1.40149924837516e-20
Rsub_2_114 sn_2 sn_114 789206.3075179838
Csub_2_114 sn_2 sn_114 1.335073402462626e-17
Rsub_2_76 sn_2 sn_76 58610286.56369087
Csub_2_76 sn_2 sn_76 1.797719158185683e-19
Rsub_2_206 sn_2 sn_206 900661.7271229918
Csub_2_206 sn_2 sn_206 1.169860246630772e-17
Rsub_2_39 sn_2 sn_39 17991050.34266344
Csub_2_39 sn_2 sn_39 5.856513823011264e-19
Rsub_2_177 sn_2 sn_177 18233735.29847399
Csub_2_177 sn_2 sn_177 5.778565570770251e-19
Rsub_2_128 sn_2 sn_128 159442835.5254517
Csub_2_128 sn_2 sn_128 6.60831417573985e-20
Rsub_2_153 sn_2 sn_153 37663981.55684298
Csub_2_153 sn_2 sn_153 2.797495927595494e-19
Rsub_2_115 sn_2 sn_115 161328717.296266
Csub_2_115 sn_2 sn_115 6.531065069389152e-20
Rsub_2_214 sn_2 sn_214 92499781.47073038
Csub_2_214 sn_2 sn_214 1.139081988595189e-19
Rsub_2_47 sn_2 sn_47 37843463.56930652
Csub_2_47 sn_2 sn_47 2.784228109283254e-19
Rsub_2_78 sn_2 sn_78 40893256.17729382
Csub_2_78 sn_2 sn_78 2.576582176911712e-19
Rsub_2_157 sn_2 sn_157 150139035.3220816
Csub_2_157 sn_2 sn_157 7.017817504706154e-20
Rsub_2_66 sn_2 sn_66 60077620.9169157
Csub_2_66 sn_2 sn_66 1.753811709155631e-19
Rsub_2_224 sn_2 sn_224 375900433.5694636
Csub_2_224 sn_2 sn_224 2.80299849675032e-20
Rsub_2_225 sn_2 sn_225 126166406.6089082
Csub_2_225 sn_2 sn_225 8.351259091408609e-20
Rsub_2_53 sn_2 sn_53 33169916.00170997
Csub_2_53 sn_2 sn_53 3.176517993499539e-19
Rsub_2_220 sn_2 sn_220 321962032.338717
Csub_2_220 sn_2 sn_220 3.272585722513143e-20
Rsub_2_152 sn_2 sn_152 187696131.903022
Csub_2_152 sn_2 sn_152 5.61358585038606e-20
Rsub_2_48 sn_2 sn_48 48634.20172078273
Csub_2_48 sn_2 sn_48 2.166476086668751e-16
Rsub_2_215 sn_2 sn_215 6896127.143138378
Csub_2_215 sn_2 sn_215 1.527884170858677e-18
Rsub_2_49 sn_2 sn_49 306322055.2478757
Csub_2_49 sn_2 sn_49 3.439675113730836e-20
Rsub_2_216 sn_2 sn_216 751800867.1389272
Csub_2_216 sn_2 sn_216 1.40149924837516e-20
Rsub_2_14 sn_2 sn_14 297826248.1741188
Csub_2_14 sn_2 sn_14 3.537795465250609e-20
Rsub_2_181 sn_2 sn_181 36094060.48604611
Csub_2_181 sn_2 sn_181 2.919173781044498e-19
Rsub_2_192 sn_2 sn_192 112360777.471216
Csub_2_192 sn_2 sn_192 9.377367920873616e-20
Rsub_2_203 sn_2 sn_203 181648194.6584356
Csub_2_203 sn_2 sn_203 5.800488973778357e-20
Rsub_2_212 sn_2 sn_212 92187889.65229359
Csub_2_212 sn_2 sn_212 1.142935752404205e-19
Rsub_2_45 sn_2 sn_45 73635639.32505518
Csub_2_45 sn_2 sn_45 1.430894550357339e-19
Rsub_2_54 sn_2 sn_54 375900433.5694636
Csub_2_54 sn_2 sn_54 2.80299849675032e-20
Rsub_2_221 sn_2 sn_221 751800867.1389272
Csub_2_221 sn_2 sn_221 1.40149924837516e-20
Rsub_2_65 sn_2 sn_65 375900433.5694636
Csub_2_65 sn_2 sn_65 2.80299849675032e-20
Rsub_2_110 sn_2 sn_110 63837147.38670241
Csub_2_110 sn_2 sn_110 1.650525428149818e-19
Rsub_2_189 sn_2 sn_189 210799667.8780173
Csub_2_189 sn_2 sn_189 4.998339707217713e-20
Rsub_2_106 sn_2 sn_106 375900433.5694636
Csub_2_106 sn_2 sn_106 2.80299849675032e-20
Rsub_2_160 sn_2 sn_160 187950216.7847318
Csub_2_160 sn_2 sn_160 5.60599699350064e-20
Rsub_2_210 sn_2 sn_210 375900433.5694636
Csub_2_210 sn_2 sn_210 2.80299849675032e-20
Rsub_2_43 sn_2 sn_43 42689510.78115344
Csub_2_43 sn_2 sn_43 2.468166842258977e-19
Rsub_48_109 sn_48 sn_109 1575288.856558454
Csub_48_109 sn_48 sn_109 6.688604098456671e-18
Rsub_48_96 sn_48 sn_96 1078916.107620799
Csub_48_96 sn_48 sn_96 9.765804243542917e-18
Rsub_48_75 sn_48 sn_75 2030274.009347079
Csub_48_75 sn_48 sn_75 5.189685458081816e-18
Rsub_48_87 sn_48 sn_87 704688.8883676733
Csub_48_87 sn_48 sn_87 1.495196486869048e-17
Rsub_48_122 sn_48 sn_122 340315.1063395624
Csub_48_122 sn_48 sn_122 3.096096325420483e-17
Rsub_48_121 sn_48 sn_121 12735424.52530423
Csub_48_121 sn_48 sn_121 8.273366530730785e-19
Rsub_48_85 sn_48 sn_85 449284.5825345046
Csub_48_85 sn_48 sn_85 2.345169167121556e-17
Rsub_48_124 sn_48 sn_124 1245598.999322655
Csub_48_124 sn_48 sn_124 8.458969144933192e-18
Rsub_48_119 sn_48 sn_119 1281895.901891813
Csub_48_119 sn_48 sn_119 8.219453300911824e-18
Rsub_48_113 sn_48 sn_113 3288967.248269198
Csub_48_113 sn_48 sn_113 3.203584197372221e-18
Rsub_48_73 sn_48 sn_73 3532120.536809301
Csub_48_73 sn_48 sn_73 2.983047546771438e-18
Rsub_48_65 sn_48 sn_65 1766060.268404651
Csub_48_65 sn_48 sn_65 5.966095093542875e-18
Rsub_48_111 sn_48 sn_111 125988236.470442
Csub_48_111 sn_48 sn_111 8.3630692812356e-20
Rsub_48_145 sn_48 sn_145 2106598.849716757
Csub_48_145 sn_48 sn_145 5.001656344608128e-18
Rsub_48_71 sn_48 sn_71 255682.6858698477
Csub_48_71 sn_48 sn_71 4.120921784900788e-17
Rsub_48_202 sn_48 sn_202 2300501.978096281
Csub_48_202 sn_48 sn_202 4.580080174914341e-18
Rsub_48_142 sn_48 sn_142 1380323.909593841
Csub_48_142 sn_48 sn_142 7.633341296920919e-18
Rsub_48_125 sn_48 sn_125 162929.4630044235
Csub_48_125 sn_48 sn_125 6.466898808807797e-17
Rsub_48_66 sn_48 sn_66 151205.2128968226
Csub_48_66 sn_48 sn_66 6.968333498805855e-17
Rsub_48_120 sn_48 sn_120 6231427.852516873
Csub_48_120 sn_48 sn_120 1.690861830001661e-18
Rsub_48_118 sn_48 sn_118 1109288.408289243
Csub_48_118 sn_48 sn_118 9.498416663777718e-18
Rsub_48_81 sn_48 sn_81 2009146.503009964
Csub_48_81 sn_48 sn_81 5.244258438319442e-18
Rsub_48_196 sn_48 sn_196 649895.6187929901
Csub_48_196 sn_48 sn_196 1.621257813954607e-17
Rsub_48_123 sn_48 sn_123 13095611.71853691
Csub_48_123 sn_48 sn_123 8.045812390203622e-19
Rsub_48_69 sn_48 sn_69 64425.75905968719
Csub_48_69 sn_48 sn_69 1.635445768278568e-16
Rsub_48_225 sn_48 sn_225 501000.4538252563
Csub_48_225 sn_48 sn_225 2.103088614347845e-17
Rsub_48_58 sn_48 sn_58 5087995.010699264
Csub_48_58 sn_48 sn_58 2.070851775615624e-18
Rsub_48_95 sn_48 sn_95 3061120.118965009
Csub_48_95 sn_48 sn_95 3.442035298435945e-18
Rsub_48_200 sn_48 sn_200 365156.6570497747
Csub_48_200 sn_48 sn_200 2.885469372887201e-17
Rsub_48_158 sn_48 sn_158 728062.1780239737
Csub_48_158 sn_48 sn_158 1.447195558328132e-17
Rsub_48_140 sn_48 sn_140 792910.6451090372
Csub_48_140 sn_48 sn_140 1.328836176840718e-17
Rsub_48_64 sn_48 sn_64 14312896.39186178
Csub_48_64 sn_48 sn_64 7.361531316764772e-19
Rsub_48_175 sn_48 sn_175 622203.1413360398
Csub_48_175 sn_48 sn_175 1.693415349785168e-17
Rsub_48_146 sn_48 sn_146 2754348.100672785
Csub_48_146 sn_48 sn_146 3.825400100900946e-18
Rsub_48_203 sn_48 sn_203 4501691.733328148
Csub_48_203 sn_48 sn_203 2.340560866090284e-18
Rsub_48_79 sn_48 sn_79 896100.48495886
Csub_48_79 sn_48 sn_79 1.175814953689455e-17
Rsub_48_189 sn_48 sn_189 1295585.001144884
Csub_48_189 sn_48 sn_189 8.132606886401983e-18
Rsub_48_159 sn_48 sn_159 1777655.010498786
Csub_48_159 sn_48 sn_159 5.927181280958226e-18
Rsub_48_88 sn_48 sn_88 5584845.130922629
Csub_48_88 sn_48 sn_88 1.886620533824785e-18
Rsub_48_213 sn_48 sn_213 449909.607457136
Csub_48_213 sn_48 sn_213 2.341911203404084e-17
Rsub_48_180 sn_48 sn_180 839927.0690013587
Csub_48_180 sn_48 sn_180 1.254452188897481e-17
Rsub_48_205 sn_48 sn_205 38703.4740467849
Csub_48_205 sn_48 sn_205 2.722361173442327e-16
Rsub_48_130 sn_48 sn_130 615457.1224736319
Csub_48_130 sn_48 sn_130 1.711976857117519e-17
Rsub_48_112 sn_48 sn_112 267994.4216210875
Csub_48_112 sn_48 sn_112 3.931605530628301e-17
Rsub_48_74 sn_48 sn_74 14789525.25519201
Csub_48_74 sn_48 sn_74 7.124287845907064e-19
Rsub_48_62 sn_48 sn_62 452605.7302829355
Csub_48_62 sn_48 sn_62 2.327960694541665e-17
Rsub_48_229 sn_48 sn_229 164025.4504395345
Csub_48_229 sn_48 sn_229 6.423688198383652e-17
Rsub_48_151 sn_48 sn_151 2185315.491193139
Csub_48_151 sn_48 sn_151 4.821493072598543e-18
Rsub_48_171 sn_48 sn_171 7482046.36806485
Csub_48_171 sn_48 sn_171 1.408235525938761e-18
Rsub_48_160 sn_48 sn_160 247051.981680407
Csub_48_160 sn_48 sn_160 4.264885240167907e-17
Rsub_48_166 sn_48 sn_166 504678.6378538921
Csub_48_166 sn_48 sn_166 2.087760945665465e-17
Rsub_48_107 sn_48 sn_107 6453159.209643463
Csub_48_107 sn_48 sn_107 1.63276360615503e-18
Rsub_48_132 sn_48 sn_132 43255.44747054402
Csub_48_132 sn_48 sn_132 2.435874350717354e-16
Rsub_48_144 sn_48 sn_144 1349422.336506497
Csub_48_144 sn_48 sn_144 7.808143690216197e-18
Rsub_48_126 sn_48 sn_126 2257446.956658388
Csub_48_126 sn_48 sn_126 4.667433478847607e-18
Rsub_48_105 sn_48 sn_105 308462.2382089565
Csub_48_105 sn_48 sn_105 3.415809845447742e-17
Rsub_48_214 sn_48 sn_214 271652.0506480622
Csub_48_214 sn_48 sn_214 3.878668862279454e-17
Rsub_48_167 sn_48 sn_167 128920.8207559222
Csub_48_167 sn_48 sn_167 8.172833092784968e-17
Rsub_48_164 sn_48 sn_164 19277656.17440271
Csub_48_164 sn_48 sn_164 5.465645515672477e-19
Rsub_48_54 sn_48 sn_54 6998448.876066043
Csub_48_54 sn_48 sn_54 1.505545541421852e-18
Rsub_48_221 sn_48 sn_221 2001186.188644801
Csub_48_221 sn_48 sn_221 5.265119038906261e-18
Rsub_48_127 sn_48 sn_127 4951680.057832886
Csub_48_127 sn_48 sn_127 2.127860317946575e-18
Rsub_48_162 sn_48 sn_162 2595772.908991151
Csub_48_162 sn_48 sn_162 4.059092945201054e-18
Rsub_48_169 sn_48 sn_169 2172735.555030006
Csub_48_169 sn_48 sn_169 4.849409067678506e-18
Rsub_48_179 sn_48 sn_179 127095835.2192055
Csub_48_179 sn_48 sn_179 8.290187860253213e-20
Rsub_48_150 sn_48 sn_150 851859.9353503166
Csub_48_150 sn_48 sn_150 1.236879804412565e-17
Rsub_48_183 sn_48 sn_183 150104.1979648077
Csub_48_183 sn_48 sn_183 7.019446254727872e-17
Rsub_48_82 sn_48 sn_82 181214.0407898508
Csub_48_82 sn_48 sn_82 5.814385825902359e-17
Rsub_48_220 sn_48 sn_220 637724.0604586027
Csub_48_220 sn_48 sn_220 1.652201031062394e-17
Rsub_48_53 sn_48 sn_53 735896.8128418985
Csub_48_53 sn_48 sn_53 1.431788168987991e-17
Rsub_48_86 sn_48 sn_86 2331476.181919981
Csub_48_86 sn_48 sn_86 4.519232743588725e-18
Rsub_48_56 sn_48 sn_56 4196428.963979651
Csub_48_56 sn_48 sn_56 2.510821365658912e-18
Rsub_48_223 sn_48 sn_223 410372.8126164132
Csub_48_223 sn_48 sn_223 2.567539363792782e-17
Rsub_48_170 sn_48 sn_170 63598.63350283618
Csub_48_170 sn_48 sn_170 1.656715391811072e-16
Rsub_48_50 sn_48 sn_50 324606.6276066947
Csub_48_50 sn_48 sn_50 3.245923713854786e-17
Rsub_48_217 sn_48 sn_217 181070.2313979063
Csub_48_217 sn_48 sn_217 5.819003720758393e-17
Rsub_48_138 sn_48 sn_138 75856.8385821915
Csub_48_138 sn_48 sn_138 1.388995863677292e-16
Rsub_48_226 sn_48 sn_226 119023.0582488484
Csub_48_226 sn_48 sn_226 8.852472501757404e-17
Rsub_48_59 sn_48 sn_59 4097350.846296294
Csub_48_59 sn_48 sn_59 2.571535584206613e-18
Rsub_48_110 sn_48 sn_110 238198.0292933397
Csub_48_110 sn_48 sn_110 4.423413381499632e-17
Rsub_48_153 sn_48 sn_153 84953.86077729188
Csub_48_153 sn_48 sn_153 1.240259525091107e-16
Rsub_48_224 sn_48 sn_224 540907.0249431211
Csub_48_224 sn_48 sn_224 1.947928759723164e-17
Rsub_48_115 sn_48 sn_115 186807.3556459488
Csub_48_115 sn_48 sn_115 5.640293694965378e-17
Rsub_48_99 sn_48 sn_99 168680.8481146885
Csub_48_99 sn_48 sn_99 6.246401781822972e-17
Rsub_48_178 sn_48 sn_178 59589.85136599232
Csub_48_178 sn_48 sn_178 1.76816744138468e-16
Rsub_48_219 sn_48 sn_219 184246.6008964172
Csub_48_219 sn_48 sn_219 5.718685419957124e-17
Rsub_48_52 sn_48 sn_52 16433.16330511629
Csub_48_52 sn_48 sn_52 6.411719585936067e-16
Rsub_48_131 sn_48 sn_131 114203.0254771698
Csub_48_131 sn_48 sn_131 9.226098396435515e-17
Rsub_48_148 sn_48 sn_148 147855.0387310048
Csub_48_148 sn_48 sn_148 7.126225519712729e-17
Rsub_48_185 sn_48 sn_185 46980.26115036595
Csub_48_185 sn_48 sn_185 2.242746899278982e-16
Rsub_48_114 sn_48 sn_114 12880.09647002591
Csub_48_114 sn_48 sn_114 8.180438342795116e-16
Rsub_48_177 sn_48 sn_177 86324.30725876211
Csub_48_177 sn_48 sn_177 1.220569714002602e-16
Rsub_48_72 sn_48 sn_72 28203.12925830803
Csub_48_72 sn_48 sn_72 3.735927104303924e-16
Rsub_48_206 sn_48 sn_206 17108.001904751
Csub_48_206 sn_48 sn_206 6.158804260656501e-16
Rsub_48_97 sn_48 sn_97 27493.26235200454
Csub_48_97 sn_48 sn_97 3.832387501827983e-16
Rsub_48_227 sn_48 sn_227 283397.247337928
Csub_48_227 sn_48 sn_227 3.717920199015239e-17
Rsub_48_60 sn_48 sn_60 113319.958350219
Csub_48_60 sn_48 sn_60 9.297994506551669e-17
Rsub_48_139 sn_48 sn_139 163342.6312778944
Csub_48_139 sn_48 sn_139 6.450541061937656e-17
Rsub_48_156 sn_48 sn_156 195316.078460785
Csub_48_156 sn_48 sn_156 5.394580715148592e-17
Rsub_48_77 sn_48 sn_77 2197145.845731771
Csub_48_77 sn_48 sn_77 4.795532132151552e-18
Rsub_48_199 sn_48 sn_199 249818.1651515902
Csub_48_199 sn_48 sn_199 4.217661071938639e-17
Rsub_48_218 sn_48 sn_218 254605.3755320681
Csub_48_218 sn_48 sn_218 4.138358618788435e-17
Rsub_48_51 sn_48 sn_51 2747.388993525596
Csub_48_51 sn_48 sn_51 3.835089798736153e-15
Rsub_48_209 sn_48 sn_209 190266.5706224396
Csub_48_209 sn_48 sn_209 5.537748153950989e-17
Rsub_48_93 sn_48 sn_93 399861.70876646
Csub_48_93 sn_48 sn_93 2.635031880080284e-17
Rsub_48_172 sn_48 sn_172 4791233.459578146
Csub_48_172 sn_48 sn_172 2.199117114856204e-18
Rsub_48_204 sn_48 sn_204 17038.7285956949
Csub_48_204 sn_48 sn_204 6.1838437316809e-16
Rsub_48_212 sn_48 sn_212 63585.4009822069
Csub_48_212 sn_48 sn_212 1.657060164671828e-16
Rsub_48_133 sn_48 sn_133 303713.1393694754
Csub_48_133 sn_48 sn_133 3.469222149592969e-17
Rsub_48_101 sn_48 sn_101 73580.662686625
Csub_48_101 sn_48 sn_101 1.431963659678381e-16
Rsub_48_195 sn_48 sn_195 31700.13319398085
Csub_48_195 sn_48 sn_195 3.323797864745453e-16
Rsub_48_141 sn_48 sn_141 109880.6040947167
Csub_48_141 sn_48 sn_141 9.589029464333478e-17
Rsub_48_128 sn_48 sn_128 169536.2822168143
Csub_48_128 sn_48 sn_128 6.21488413244502e-17
Rsub_48_216 sn_48 sn_216 4028023.906010372
Csub_48_216 sn_48 sn_216 2.615794679497335e-18
Rsub_48_49 sn_48 sn_49 194627.2856203512
Csub_48_49 sn_48 sn_49 5.413672326902274e-17
Rsub_48_207 sn_48 sn_207 802843.2045176219
Csub_48_207 sn_48 sn_207 1.312396174363924e-17
Rsub_48_154 sn_48 sn_154 109008.459327646
Csub_48_154 sn_48 sn_154 9.665748481556431e-17
Rsub_48_84 sn_48 sn_84 2136620.775179487
Csub_48_84 sn_48 sn_84 4.931377446400092e-18
Rsub_48_163 sn_48 sn_163 534924.0598606584
Csub_48_163 sn_48 sn_163 1.969715758340471e-17
Rsub_48_215 sn_48 sn_215 37442.4699980209
Csub_48_215 sn_48 sn_215 2.814046055932455e-16
Rsub_48_230 sn_48 0 4589.524122666729
Csub_48_230 sn_48 0 2.295768193088352e-15
Rsub_48_63 sn_48 sn_63 16072467.49045588
Csub_48_63 sn_48 sn_63 6.555610399266169e-19
Rsub_48_186 sn_48 sn_186 4905873.019866124
Csub_48_186 sn_48 sn_186 2.147728540784272e-18
Rsub_48_76 sn_48 sn_76 182252.4369518622
Csub_48_76 sn_48 sn_76 5.781257951032485e-17
Rsub_48_155 sn_48 sn_155 132214.6917545111
Csub_48_155 sn_48 sn_155 7.969222907385786e-17
Rsub_48_168 sn_48 sn_168 1454429.458653905
Csub_48_168 sn_48 sn_168 7.244410129028648e-18
Rsub_48_184 sn_48 sn_184 8306210.310471115
Csub_48_184 sn_48 sn_184 1.268506708642728e-18
Rsub_48_208 sn_48 sn_208 607756.6379095605
Csub_48_208 sn_48 sn_208 1.733668189700287e-17
Rsub_48_129 sn_48 sn_129 236850.1353391497
Csub_48_129 sn_48 sn_129 4.448586650433039e-17
Rsub_48_117 sn_48 sn_117 1736917.604531159
Csub_48_117 sn_48 sn_117 6.066196505086424e-18
Rsub_48_55 sn_48 sn_55 41332282.05205683
Csub_48_55 sn_48 sn_55 2.549214071693307e-19
Rsub_48_222 sn_48 sn_222 90845.40951070665
Csub_48_222 sn_48 sn_222 1.159825637748731e-16
Rsub_48_192 sn_48 sn_192 387131.4566318509
Csub_48_192 sn_48 sn_192 2.721681052193556e-17
Rsub_48_157 sn_48 sn_157 468043.6090723067
Csub_48_157 sn_48 sn_157 2.251175595178835e-17
Rsub_48_78 sn_48 sn_78 340211.2283262682
Csub_48_78 sn_48 sn_78 3.097041668514638e-17
Rsub_48_211 sn_48 sn_211 619806.2457624674
Csub_48_211 sn_48 sn_211 1.699964073332035e-17
Rsub_48_70 sn_48 sn_70 2521187.500129318
Csub_48_70 sn_48 sn_70 4.179174893453802e-18
Rsub_48_61 sn_48 sn_61 98998.75265656723
Csub_48_61 sn_48 sn_61 1.06430467248226e-16
Rsub_48_228 sn_48 sn_228 2514374.210715085
Csub_48_228 sn_48 sn_228 4.190499352613642e-18
Rsub_48_90 sn_48 sn_90 60969174.53944865
Csub_48_90 sn_48 sn_90 1.728165680742917e-19
Rsub_48_152 sn_48 sn_152 570122.5838637248
Csub_48_152 sn_48 sn_152 1.848108424476746e-17
Rsub_48_198 sn_48 sn_198 147597.4798432496
Csub_48_198 sn_48 sn_198 7.138660845307035e-17
Rsub_48_174 sn_48 sn_174 3162092.753940206
Csub_48_174 sn_48 sn_174 3.332123477118358e-18
Rsub_48_197 sn_48 sn_197 5707360.10833847
Csub_48_197 sn_48 sn_197 1.846122077847545e-18
Rsub_48_182 sn_48 sn_182 494688.2715752857
Csub_48_182 sn_48 sn_182 2.129923854607997e-17
Rsub_48_67 sn_48 sn_67 418129.1461868897
Csub_48_67 sn_48 sn_67 2.519911275814422e-17
Rsub_48_135 sn_48 sn_135 519325.89228914
Csub_48_135 sn_48 sn_135 2.028876984312522e-17
Rsub_48_68 sn_48 sn_68 667281.9482715549
Csub_48_68 sn_48 sn_68 1.579015216809388e-17
Rsub_48_94 sn_48 sn_94 2986790.088738927
Csub_48_94 sn_48 sn_94 3.527694678630289e-18
Rsub_48_80 sn_48 sn_80 1125953.408104531
Csub_48_80 sn_48 sn_80 9.357832594483179e-18
Rsub_215_225 sn_215 sn_225 1243669.134769882
Csub_215_225 sn_215 sn_225 8.472095356921103e-18
Rsub_215_228 sn_215 sn_228 34312159.04471724
Csub_215_228 sn_215 sn_228 3.07077251784079e-19
Rsub_215_217 sn_215 sn_217 14689248.52273487
Csub_215_217 sn_215 sn_217 7.172922076934336e-19
Rsub_215_219 sn_215 sn_219 22919450.52923192
Csub_215_219 sn_215 sn_219 4.597179800969295e-19
Rsub_215_220 sn_215 sn_220 1376365.611968015
Csub_215_220 sn_215 sn_220 7.65529406620692e-18
Rsub_215_216 sn_215 sn_216 718364.6946364804
Csub_215_216 sn_215 sn_216 1.466731811974955e-17
Rsub_215_224 sn_215 sn_224 862418.6806536769
Csub_215_224 sn_215 sn_224 1.221736464966621e-17
Rsub_215_223 sn_215 sn_223 676372.0247061451
Csub_215_223 sn_215 sn_223 1.557794101080342e-17
Rsub_215_229 sn_215 sn_229 297455.0168969975
Csub_215_229 sn_215 sn_229 3.542210722194196e-17
Rsub_215_218 sn_215 sn_218 211188.1267735936
Csub_215_218 sn_215 sn_218 4.989145774054687e-17
Rsub_215_222 sn_215 sn_222 52426.60929891072
Csub_215_222 sn_215 sn_222 2.009758716638751e-16
Rsub_215_230 sn_215 0 7011.790733368294
Csub_215_230 sn_215 0 1.502680827607718e-15
Rsub_215_227 sn_215 sn_227 40677.934590842
Csub_215_227 sn_215 sn_227 2.590220867458233e-16
Rsub_215_226 sn_215 sn_226 91071.88732728267
Csub_215_226 sn_215 sn_226 1.156941380204993e-16
Rsub_215_221 sn_215 sn_221 335701.6792596176
Csub_215_221 sn_215 sn_221 3.138644860361728e-17
Rsub_127_227 sn_127 sn_227 2040581.350341007
Csub_127_227 sn_127 sn_227 5.163471429585115e-18
Rsub_127_138 sn_127 sn_138 667648.6657847022
Csub_127_138 sn_127 sn_138 1.578147915542711e-17
Rsub_127_217 sn_127 sn_217 929381.1268548978
Csub_127_217 sn_127 sn_217 1.133709648041415e-17
Rsub_127_130 sn_127 sn_130 103187.0228859208
Csub_127_130 sn_127 sn_130 1.0211054847351e-16
Rsub_127_151 sn_127 sn_151 32357.15660112914
Csub_127_151 sn_127 sn_151 3.256306983989538e-16
Rsub_127_230 sn_127 0 27338.51034409506
Csub_127_230 sn_127 0 3.854081063530155e-16
Rsub_127_224 sn_127 sn_224 541354.6313287063
Csub_127_224 sn_127 sn_224 1.946318160494748e-17
Rsub_127_145 sn_127 sn_145 224556.5082615409
Csub_127_145 sn_127 sn_145 4.692130094024336e-17
Rsub_127_174 sn_127 sn_174 11302559.50497066
Csub_127_174 sn_127 sn_174 9.322210157439337e-19
Rsub_127_172 sn_127 sn_172 5929579.623746675
Csub_127_172 sn_127 sn_172 1.776936000662455e-18
Rsub_127_160 sn_127 sn_160 2427744.412848261
Csub_127_160 sn_127 sn_160 4.340029966279879e-18
Rsub_127_222 sn_127 sn_222 574284.0615701276
Csub_127_222 sn_127 sn_222 1.834716337664433e-17
Rsub_127_185 sn_127 sn_185 31526.32837757625
Csub_127_185 sn_127 sn_185 3.342121980092136e-16
Rsub_127_141 sn_127 sn_141 31872.8614155226
Csub_127_141 sn_127 sn_141 3.305785246221591e-16
Rsub_127_220 sn_127 sn_220 519663.3549640002
Csub_127_220 sn_127 sn_220 2.027559457787805e-17
Rsub_127_215 sn_127 sn_215 430909.2974993609
Csub_127_215 sn_127 sn_215 2.445174324010873e-17
Rsub_127_136 sn_127 sn_136 21410.62299032888
Csub_127_136 sn_127 sn_136 4.921147556981085e-16
Rsub_127_131 sn_127 sn_131 1474334.598828881
Csub_127_131 sn_127 sn_131 7.146602616936158e-18
Rsub_127_210 sn_127 sn_210 853933.5154114254
Csub_127_210 sn_127 sn_210 1.233876327848957e-17
Rsub_127_195 sn_127 sn_195 80838.98833165102
Csub_127_195 sn_127 sn_195 1.303391311504653e-16
Rsub_127_153 sn_127 sn_153 4658796.32437584
Csub_127_153 sn_127 sn_153 2.261632140280702e-18
Rsub_127_159 sn_127 sn_159 1026.685813146944
Csub_127_159 sn_127 sn_159 1.026261721678428e-14
Rsub_127_165 sn_127 sn_165 3811.411301974413
Csub_127_165 sn_127 sn_165 2.764457222649212e-15
Rsub_127_199 sn_127 sn_199 11070730.34242743
Csub_127_199 sn_127 sn_199 9.517424032857183e-19
Rsub_127_177 sn_127 sn_177 239.3201304402969
Csub_127_177 sn_127 sn_177 4.402673307441864e-14
Rsub_127_206 sn_127 sn_206 392894.1744211016
Csub_127_206 sn_127 sn_206 2.68176119377557e-17
Rsub_127_169 sn_127 sn_169 967.3754785504091
Csub_127_169 sn_127 sn_169 1.089182404956004e-14
Rsub_127_161 sn_127 sn_161 5140.775731390248
Csub_127_161 sn_127 sn_161 2.049590188868356e-15
Rsub_127_181 sn_127 sn_181 6912.313448031657
Csub_127_181 sn_127 sn_181 1.524306381856911e-15
Rsub_127_147 sn_127 sn_147 8019.449764020339
Csub_127_147 sn_127 sn_147 1.313866139482843e-15
Rsub_127_226 sn_127 sn_226 1896480.809249868
Csub_127_226 sn_127 sn_226 5.555808132009304e-18
Rsub_127_157 sn_127 sn_157 112164.8049404716
Csub_127_157 sn_127 sn_157 9.393751906243632e-17
Rsub_127_228 sn_127 sn_228 11280882.7693305
Csub_127_228 sn_127 sn_228 9.340123213473769e-19
Rsub_127_191 sn_127 sn_191 95905.72075651214
Csub_127_191 sn_127 sn_191 1.098629301684755e-16
Rsub_127_152 sn_127 sn_152 22585.04008796344
Csub_127_152 sn_127 sn_152 4.665248970642897e-16
Rsub_127_189 sn_127 sn_189 116651.5780777249
Csub_127_189 sn_127 sn_189 9.032439745658263e-17
Rsub_127_180 sn_127 sn_180 1981105.838197382
Csub_127_180 sn_127 sn_180 5.318485917853435e-18
Rsub_127_135 sn_127 sn_135 254835.6828008162
Csub_127_135 sn_127 sn_135 4.134618584974809e-17
Rsub_127_214 sn_127 sn_214 3370808.947039914
Csub_127_214 sn_127 sn_214 3.125802639002322e-18
Rsub_127_207 sn_127 sn_207 3259585.688822545
Csub_127_207 sn_127 sn_207 3.232460965318595e-18
Rsub_127_128 sn_127 sn_128 45793.63592261775
Csub_127_128 sn_127 sn_128 2.300861962573705e-16
Rsub_127_221 sn_127 sn_221 4646287.561853328
Csub_127_221 sn_127 sn_221 2.267720919543596e-18
Rsub_127_192 sn_127 sn_192 618545.5148297218
Csub_127_192 sn_127 sn_192 1.70342897161425e-17
Rsub_127_200 sn_127 sn_200 6443710.868590449
Csub_127_200 sn_127 sn_200 1.635157709137691e-18
Rsub_127_162 sn_127 sn_162 6819469.698541556
Csub_127_162 sn_127 sn_162 1.545059068813427e-18
Rsub_127_212 sn_127 sn_212 1580387.38257792
Csub_127_212 sn_127 sn_212 6.667025830744703e-18
Rsub_127_190 sn_127 sn_190 4337184.545299335
Csub_127_190 sn_127 sn_190 2.429337140760934e-18
Rsub_127_158 sn_127 sn_158 1955842.029218322
Csub_127_158 sn_127 sn_158 5.387185337478938e-18
Rsub_127_146 sn_127 sn_146 6703649.170019145
Csub_127_146 sn_127 sn_146 1.571753418921818e-18
Rsub_127_129 sn_127 sn_129 6151907.08990547
Csub_127_129 sn_127 sn_129 1.712718243017533e-18
Rsub_127_148 sn_127 sn_148 3855602.281471053
Csub_127_148 sn_127 sn_148 2.732772400531403e-18
Rsub_127_176 sn_127 sn_176 708813.2938107398
Csub_127_176 sn_127 sn_176 1.486496316340724e-17
Rsub_127_201 sn_127 sn_201 26727475.37948099
Csub_127_201 sn_127 sn_201 3.942191827934107e-19
Rsub_127_182 sn_127 sn_182 4427334.820576729
Csub_127_182 sn_127 sn_182 2.379870493024393e-18
Rsub_127_170 sn_127 sn_170 1967928.810813597
Csub_127_170 sn_127 sn_170 5.354097894361291e-18
Rsub_127_198 sn_127 sn_198 4631321.922473622
Csub_127_198 sn_127 sn_198 2.275048825930543e-18
Rsub_127_163 sn_127 sn_163 17520270.93139577
Csub_127_163 sn_127 sn_163 6.013881602338102e-19
Rsub_127_211 sn_127 sn_211 7295716.403321337
Csub_127_211 sn_127 sn_211 1.444201353198614e-18
Rsub_127_155 sn_127 sn_155 2918326.347234675
Csub_127_155 sn_127 sn_155 3.610454160554758e-18
Rsub_127_216 sn_127 sn_216 4487981.928402353
Csub_127_216 sn_127 sn_216 2.347710768519252e-18
Rsub_127_213 sn_127 sn_213 16864074.04084364
Csub_127_213 sn_127 sn_213 6.247887359075484e-19
Rsub_127_187 sn_127 sn_187 1300687.081762144
Csub_127_187 sn_127 sn_187 8.100705888425825e-18
Rsub_127_186 sn_127 sn_186 27133015.74959232
Csub_127_186 sn_127 sn_186 3.88327032994418e-19
Rsub_127_194 sn_127 sn_194 6065638.625903913
Csub_127_194 sn_127 sn_194 1.737077355257021e-18
Rsub_122_158 sn_122 sn_158 1456339.623241638
Csub_122_158 sn_122 sn_158 7.234908213770254e-18
Rsub_122_134 sn_122 sn_134 985582.0408215511
Csub_122_134 sn_122 sn_134 1.069062043119932e-17
Rsub_122_194 sn_122 sn_194 3917836.052290976
Csub_122_194 sn_122 sn_194 2.6893630467433e-18
Rsub_122_208 sn_122 sn_208 1699341.096676106
Csub_122_208 sn_122 sn_208 6.200334660792501e-18
Rsub_122_129 sn_122 sn_129 11224919.12884838
Csub_122_129 sn_122 sn_129 9.386689900643398e-19
Rsub_122_198 sn_122 sn_198 4298685.541301484
Csub_122_198 sn_122 sn_198 2.451094270794216e-18
Rsub_122_178 sn_122 sn_178 14688963.96708745
Csub_122_178 sn_122 sn_178 7.173061031287418e-19
Rsub_122_224 sn_122 sn_224 1515296.294109772
Csub_122_224 sn_122 sn_224 6.953414684103167e-18
Rsub_122_192 sn_122 sn_192 3579113.268584172
Csub_122_192 sn_122 sn_192 2.943880987146861e-18
Rsub_122_195 sn_122 sn_195 2991054.422422402
Csub_122_195 sn_122 sn_195 3.522665259195349e-18
Rsub_122_153 sn_122 sn_153 1091322.11549724
Csub_122_153 sn_122 sn_153 9.654787850999658e-18
Rsub_122_211 sn_122 sn_211 34991158.78707364
Csub_122_211 sn_122 sn_211 3.011184501303902e-19
Rsub_122_132 sn_122 sn_132 450675.3388660537
Csub_122_132 sn_122 sn_132 2.33793211954772e-17
Rsub_122_223 sn_122 sn_223 473906.4288829702
Csub_122_223 sn_122 sn_223 2.223325715809598e-17
Rsub_122_180 sn_122 sn_180 11776844.36398844
Csub_122_180 sn_122 sn_180 8.946779949345983e-19
Rsub_122_176 sn_122 sn_176 25112388.33500059
Csub_122_176 sn_122 sn_176 4.195731350468443e-19
Rsub_122_216 sn_122 sn_216 4854430.457060669
Csub_122_216 sn_122 sn_216 2.170488092357962e-18
Rsub_122_137 sn_122 sn_137 58158046.78624345
Csub_122_137 sn_122 sn_137 1.811698309084595e-19
Rsub_122_155 sn_122 sn_155 2935746.157820669
Csub_122_155 sn_122 sn_155 3.589030841158177e-18
Rsub_122_203 sn_122 sn_203 9092443.592505669
Csub_122_203 sn_122 sn_203 1.158817582427959e-18
Rsub_122_168 sn_122 sn_168 2463679.94801765
Csub_122_168 sn_122 sn_168 4.27672576168344e-18
Rsub_122_199 sn_122 sn_199 24151405.808702
Csub_122_199 sn_122 sn_199 4.362679168942454e-19
Rsub_122_131 sn_122 sn_131 1515697.534128656
Csub_122_131 sn_122 sn_131 6.951573955213442e-18
Rsub_122_173 sn_122 sn_173 287141.7783652747
Csub_122_173 sn_122 sn_173 3.669435901043449e-17
Rsub_122_157 sn_122 sn_157 510655.7692948718
Csub_122_157 sn_122 sn_157 2.063324089489693e-17
Rsub_122_206 sn_122 sn_206 2969463.941278866
Csub_122_206 sn_122 sn_206 3.548277975617456e-18
Rsub_122_163 sn_122 sn_163 14547.6401793935
Csub_122_163 sn_122 sn_163 7.242744096155722e-16
Rsub_122_200 sn_122 sn_200 2937604.662999087
Csub_122_200 sn_122 sn_200 3.586760204646802e-18
Rsub_122_202 sn_122 sn_202 26571.25055300054
Csub_122_202 sn_122 sn_202 3.965369819991471e-16
Rsub_122_184 sn_122 sn_184 22269443.43773777
Csub_122_184 sn_122 sn_184 4.731363642602263e-19
Rsub_122_167 sn_122 sn_167 4319.313894648501
Csub_122_167 sn_122 sn_167 2.439388236007664e-15
Rsub_122_130 sn_122 sn_130 2257333.695584679
Csub_122_130 sn_122 sn_130 4.667667665989861e-18
Rsub_122_209 sn_122 sn_209 233804.3846815013
Csub_122_209 sn_122 sn_209 4.506538026043979e-17
Rsub_122_172 sn_122 sn_172 1369708.25808581
Csub_122_172 sn_122 sn_172 7.692501990865495e-18
Rsub_122_215 sn_122 sn_215 3523053.998687996
Csub_122_215 sn_122 sn_215 2.990724384625908e-18
Rsub_122_175 sn_122 sn_175 649.0942385914993
Csub_122_175 sn_122 sn_175 1.623259439968782e-14
Rsub_122_217 sn_122 sn_217 116842.1885813052
Csub_122_217 sn_122 sn_217 9.017704675138071e-17
Rsub_122_138 sn_122 sn_138 1093945.856851667
Csub_122_138 sn_122 sn_138 9.631631617083487e-18
Rsub_122_179 sn_122 sn_179 11981.51352994169
Csub_122_179 sn_122 sn_179 8.793950343501616e-16
Rsub_122_230 sn_122 0 22159.18736093295
Csub_122_230 sn_122 0 4.754905191517093e-16
Rsub_122_162 sn_122 sn_162 7167120.580070093
Csub_122_162 sn_122 sn_162 1.470113888069532e-18
Rsub_122_226 sn_122 sn_226 1598476.442887907
Csub_122_226 sn_122 sn_226 6.591578843160262e-18
Rsub_122_207 sn_122 sn_207 1844170.665176145
Csub_122_207 sn_122 sn_207 5.713399362213376e-18
Rsub_122_133 sn_122 sn_133 64438524.7074521
Csub_122_133 sn_122 sn_133 1.635121776928498e-19
Rsub_122_170 sn_122 sn_170 1962295.335759316
Csub_122_170 sn_122 sn_170 5.36946875947849e-18
Rsub_122_225 sn_122 sn_225 1007717.696791821
Csub_122_225 sn_122 sn_225 1.045578889382815e-17
Rsub_122_229 sn_122 sn_229 772980.3575294238
Csub_122_229 sn_122 sn_229 1.363098479747453e-17
Rsub_122_150 sn_122 sn_150 5395403.644384057
Csub_122_150 sn_122 sn_150 1.952862880462552e-18
Rsub_122_141 sn_122 sn_141 691959.5806450791
Csub_122_141 sn_122 sn_141 1.52270216309562e-17
Rsub_122_220 sn_122 sn_220 1566330.1398139
Csub_122_220 sn_122 sn_220 6.726859960366894e-18
Rsub_122_183 sn_122 sn_183 549168.0852426556
Csub_122_183 sn_122 sn_183 1.918626334153112e-17
Rsub_122_139 sn_122 sn_139 173366.3595275574
Csub_122_139 sn_122 sn_139 6.077582485404373e-17
Rsub_122_218 sn_122 sn_218 623806.4836404045
Csub_122_218 sn_122 sn_218 1.689062838965905e-17
Rsub_122_222 sn_122 sn_222 544884.6427990822
Csub_122_222 sn_122 sn_222 1.933709022905086e-17
Rsub_122_219 sn_122 sn_219 58049238.78992316
Csub_122_219 sn_122 sn_219 1.815094172097747e-19
Rsub_175_207 sn_175 sn_207 5845681.565905626
Csub_175_207 sn_175 sn_207 1.80243884026852e-18
Rsub_175_219 sn_175 sn_219 383104065.7834148
Csub_175_219 sn_175 sn_219 2.750292790728753e-20
Rsub_175_204 sn_175 sn_204 7894100.742010199
Csub_175_204 sn_175 sn_204 1.33472878628946e-18
Rsub_175_205 sn_175 sn_205 126089.5718653018
Csub_175_205 sn_175 sn_205 8.356348067773483e-17
Rsub_175_226 sn_175 sn_226 19850291.36517361
Csub_175_226 sn_175 sn_226 5.307974229897583e-19
Rsub_175_197 sn_175 sn_197 63950578.76084059
Csub_175_197 sn_175 sn_197 1.647597833576121e-19
Rsub_175_198 sn_175 sn_198 6176873.301617783
Csub_175_198 sn_175 sn_198 1.705795632795381e-18
Rsub_175_176 sn_175 sn_176 4584470.893715225
Csub_175_176 sn_175 sn_176 2.298298701530484e-18
Rsub_175_213 sn_175 sn_213 6831378.793105452
Csub_175_213 sn_175 sn_213 1.542365578214447e-18
Rsub_175_220 sn_175 sn_220 262183.6712645165
Csub_175_220 sn_175 sn_220 4.018741308874177e-17
Rsub_175_217 sn_175 sn_217 2892249.294069314
Csub_175_217 sn_175 sn_217 3.64300668128281e-18
Rsub_175_209 sn_175 sn_209 179951.3310293526
Csub_175_209 sn_175 sn_209 5.855185089190227e-17
Rsub_175_229 sn_175 sn_229 602551.9362644404
Csub_175_229 sn_175 sn_229 1.748643207015749e-17
Rsub_175_192 sn_175 sn_192 592858.6724772685
Csub_175_192 sn_175 sn_192 1.777233595690378e-17
Rsub_175_216 sn_175 sn_216 9708860.914121337
Csub_175_216 sn_175 sn_216 1.085244046178981e-18
Rsub_175_179 sn_175 sn_179 1610.665121554328
Csub_175_179 sn_175 sn_179 6.541697191568943e-15
Rsub_175_202 sn_175 sn_202 447670.8312003321
Csub_175_202 sn_175 sn_202 2.353622967567198e-17
Rsub_175_195 sn_175 sn_195 4085879.321332809
Csub_175_195 sn_175 sn_195 2.578755433920406e-18
Rsub_175_230 sn_175 0 14575.69006103092
Csub_175_230 sn_175 0 7.228805948886079e-16
Rsub_175_193 sn_175 sn_193 9699805.045669803
Csub_175_193 sn_175 sn_193 1.086257244616861e-18
Rsub_175_215 sn_175 sn_215 4728452.83612329
Csub_175_215 sn_175 sn_215 2.228315237012818e-18
Rsub_175_185 sn_175 sn_185 623726.1920496691
Csub_175_185 sn_175 sn_185 1.689280270178385e-17
Rsub_175_222 sn_175 sn_222 288432.2588562694
Csub_175_222 sn_175 sn_222 3.653018405087797e-17
Rsub_175_188 sn_175 sn_188 28432963.19259085
Csub_175_188 sn_175 sn_188 3.705728253105758e-19
Rsub_175_225 sn_175 sn_225 170726.9812857136
Csub_175_225 sn_175 sn_225 6.171539743092555e-17
Rsub_175_218 sn_175 sn_218 10624437.71585891
Csub_175_218 sn_175 sn_218 9.917215182599615e-19
Rsub_92_126 sn_92 sn_126 10228347.94472742
Csub_92_126 sn_92 sn_126 1.030125642886584e-18
Rsub_92_212 sn_92 sn_212 2271500.345811044
Csub_92_212 sn_92 sn_212 4.638556855895142e-18
Rsub_92_109 sn_92 sn_109 1067775.097381319
Csub_92_109 sn_92 sn_109 9.867699226241886e-18
Rsub_92_121 sn_92 sn_121 9703892.929626143
Csub_92_121 sn_92 sn_121 1.085799645424976e-18
Rsub_92_97 sn_92 sn_97 4906374.678087544
Csub_92_97 sn_92 sn_97 2.147508943678353e-18
Rsub_92_129 sn_92 sn_129 61966432.19110712
Csub_92_129 sn_92 sn_129 1.70035342195191e-19
Rsub_92_217 sn_92 sn_217 102958.4681139247
Csub_92_217 sn_92 sn_217 1.023372209711907e-16
Rsub_92_105 sn_92 sn_105 22640109.83672538
Csub_92_105 sn_92 sn_105 4.65390123025745e-19
Rsub_92_197 sn_92 sn_197 16855810.21809998
Csub_92_197 sn_92 sn_197 6.250950482887967e-19
Rsub_92_118 sn_92 sn_118 8119739.355791692
Csub_92_118 sn_92 sn_118 1.297638143361644e-18
Rsub_92_95 sn_92 sn_95 52899135.26734529
Csub_92_95 sn_92 sn_95 1.991806378115634e-19
Rsub_92_93 sn_92 sn_93 2764299.754990748
Csub_92_93 sn_92 sn_93 3.811628418085673e-18
Rsub_92_173 sn_92 sn_173 13345479.25969132
Csub_92_173 sn_92 sn_173 7.895170564652849e-19
Rsub_92_199 sn_92 sn_199 29753729.67872467
Csub_92_199 sn_92 sn_199 3.541231172024826e-19
Rsub_92_134 sn_92 sn_134 356917.5307333297
Csub_92_134 sn_92 sn_134 2.952077887735449e-17
Rsub_92_223 sn_92 sn_223 47001752.27096546
Csub_92_223 sn_92 sn_223 2.241721423807158e-19
Rsub_92_229 sn_92 sn_229 233773.0677199202
Csub_92_229 sn_92 sn_229 4.507141735785235e-17
Rsub_92_156 sn_92 sn_156 614365.3644179202
Csub_92_156 sn_92 sn_156 1.715019125827965e-17
Rsub_92_132 sn_92 sn_132 27339882.85417305
Csub_92_132 sn_92 sn_132 3.853887581900064e-19
Rsub_92_201 sn_92 sn_201 17980622.96732666
Csub_92_201 sn_92 sn_201 5.859910149596196e-19
Rsub_92_122 sn_92 sn_122 55843.22327591106
Csub_92_122 sn_92 sn_122 1.886797158926729e-16
Rsub_92_98 sn_92 sn_98 4213.561011502231
Csub_92_98 sn_92 sn_98 2.500612539718157e-15
Rsub_92_157 sn_92 sn_157 28204.88348605087
Csub_92_157 sn_92 sn_157 3.735694745004343e-16
Rsub_92_222 sn_92 sn_222 4821056.197264505
Csub_92_222 sn_92 sn_222 2.185513520503757e-18
Rsub_92_143 sn_92 sn_143 4952325.923409315
Csub_92_143 sn_92 sn_143 2.127582809609672e-18
Rsub_92_179 sn_92 sn_179 669.2116806108347
Csub_92_179 sn_92 sn_179 1.574461983779578e-14
Rsub_92_142 sn_92 sn_142 7201771.846295178
Csub_92_142 sn_92 sn_142 1.463040447143616e-18
Rsub_92_102 sn_92 sn_102 557432.7461861219
Csub_92_102 sn_92 sn_102 1.890180218926708e-17
Rsub_92_139 sn_92 sn_139 190990.1547311647
Csub_92_139 sn_92 sn_139 5.516767875842094e-17
Rsub_92_108 sn_92 sn_108 5038.926516083297
Csub_92_108 sn_92 sn_108 2.091017495214416e-15
Rsub_92_187 sn_92 sn_187 34790.15822545133
Csub_92_187 sn_92 sn_187 3.028581656326546e-16
Rsub_92_193 sn_92 sn_193 2997513.231783343
Csub_92_193 sn_92 sn_193 3.515074892917625e-18
Rsub_92_230 sn_92 0 24210.36301873492
Csub_92_230 sn_92 0 4.352055148481854e-16
Rsub_92_111 sn_92 sn_111 181031.3898738023
Csub_92_111 sn_92 sn_111 5.820252227845694e-17
Rsub_92_190 sn_92 sn_190 4328290.813624497
Csub_92_190 sn_92 sn_190 2.434328920104789e-18
Rsub_92_194 sn_92 sn_194 5015893.663708067
Csub_92_194 sn_92 sn_194 2.100619392804425e-18
Rsub_92_115 sn_92 sn_115 386739.056629016
Csub_92_115 sn_92 sn_115 2.724442572227001e-17
Rsub_92_202 sn_92 sn_202 117178.6162724639
Csub_92_202 sn_92 sn_202 8.991814238299723e-17
Rsub_92_104 sn_92 sn_104 1233135.110505142
Csub_92_104 sn_92 sn_104 8.544468008792512e-18
Rsub_92_220 sn_92 sn_220 325318.7475377682
Csub_92_220 sn_92 sn_220 3.238818414855344e-17
Rsub_92_160 sn_92 sn_160 7312276.151765711
Csub_92_160 sn_92 sn_160 1.440930742158272e-18
Rsub_92_209 sn_92 sn_209 2970.832647036586
Csub_92_209 sn_92 sn_209 3.54664323240832e-15
Rsub_92_167 sn_92 sn_167 219330.8177410344
Csub_92_167 sn_92 sn_167 4.803922955628839e-17
Rsub_92_103 sn_92 sn_103 7340640.797514712
Csub_92_103 sn_92 sn_103 1.435362905347077e-18
Rsub_92_206 sn_92 sn_206 7265176.491219309
Csub_92_206 sn_92 sn_206 1.450272201227925e-18
Rsub_92_127 sn_92 sn_127 481838.666489995
Csub_92_127 sn_92 sn_127 2.186724361285518e-17
Rsub_92_195 sn_92 sn_195 1769851.218952199
Csub_92_195 sn_92 sn_195 5.953315956393156e-18
Rsub_92_161 sn_92 sn_161 2359799.25027696
Csub_92_161 sn_92 sn_161 4.464991461029311e-18
Rsub_92_175 sn_92 sn_175 22317.97103996141
Csub_92_175 sn_92 sn_175 4.721075891425755e-16
Rsub_92_96 sn_92 sn_96 162957.8136803697
Csub_92_96 sn_92 sn_96 6.46577372650358e-17
Rsub_89_200 sn_89 sn_200 13095369.11140841
Csub_89_200 sn_89 sn_200 8.045961448349587e-19
Rsub_89_121 sn_89 sn_121 27549115.6714361
Csub_89_121 sn_89 sn_121 3.824617685697476e-19
Rsub_89_128 sn_89 sn_128 82558.32689166848
Csub_89_128 sn_89 sn_128 1.276247218049341e-16
Rsub_89_115 sn_89 sn_115 408044.8558528583
Csub_89_115 sn_89 sn_115 2.58218755881816e-17
Rsub_89_110 sn_89 sn_110 34702219.38963354
Csub_89_110 sn_89 sn_110 3.036256380010531e-19
Rsub_89_97 sn_89 sn_97 8072450.352298507
Csub_89_97 sn_89 sn_97 1.305239802339559e-18
Rsub_89_176 sn_89 sn_176 4818074.506133835
Csub_89_176 sn_89 sn_176 2.186866037213854e-18
Rsub_89_211 sn_89 sn_211 12875883.49143718
Csub_89_211 sn_89 sn_211 8.183114975556477e-19
Rsub_89_131 sn_89 sn_131 4755502.11291402
Csub_89_131 sn_89 sn_131 2.21564058895425e-18
Rsub_89_223 sn_89 sn_223 625916.1816145324
Csub_89_223 sn_89 sn_223 1.683369724529481e-17
Rsub_89_229 sn_89 sn_229 609455.8446709852
Csub_89_229 sn_89 sn_229 1.72883459800408e-17
Rsub_89_155 sn_89 sn_155 2275071.167123248
Csub_89_155 sn_89 sn_155 4.631276442904876e-18
Rsub_89_102 sn_89 sn_102 7386879.823243809
Csub_89_102 sn_89 sn_102 1.426378085788744e-18
Rsub_89_122 sn_89 sn_122 120070.9439254634
Csub_89_122 sn_89 sn_122 8.775215016857656e-17
Rsub_89_92 sn_89 sn_92 42236.492603541
Csub_89_92 sn_89 sn_92 2.494639789608536e-16
Rsub_89_167 sn_89 sn_167 495213.2229545502
Csub_89_167 sn_89 sn_167 2.127666026235536e-17
Rsub_89_163 sn_89 sn_163 141531.041978512
Csub_89_163 sn_89 sn_163 7.444644902585896e-17
Rsub_89_172 sn_89 sn_172 1277733.048804973
Csub_89_172 sn_89 sn_172 8.246232272135775e-18
Rsub_89_130 sn_89 sn_130 564617.6569018118
Csub_89_130 sn_89 sn_130 1.866127170029739e-17
Rsub_89_209 sn_89 sn_209 3675.824603090852
Csub_89_209 sn_89 sn_209 2.866427166674465e-15
Rsub_89_98 sn_89 sn_98 715903.8017564473
Csub_89_98 sn_89 sn_98 1.47177364841185e-17
Rsub_89_104 sn_89 sn_104 6861.388193452228
Csub_89_104 sn_89 sn_104 1.535619790800481e-15
Rsub_89_220 sn_89 sn_220 312728.9160281386
Csub_89_220 sn_89 sn_220 3.369206671404173e-17
Rsub_89_113 sn_89 sn_113 4777318.916181394
Csub_89_113 sn_89 sn_113 2.205522320593163e-18
Rsub_89_133 sn_89 sn_133 127832443.2691433
Csub_89_133 sn_89 sn_133 8.24241736508633e-20
Rsub_89_179 sn_89 sn_179 1923.10271664995
Csub_89_179 sn_89 sn_179 5.478897934575529e-15
Rsub_89_111 sn_89 sn_111 95781.8033257702
Csub_89_111 sn_89 sn_111 1.10005065016302e-16
Rsub_89_230 sn_89 0 60087.03868842268
Csub_89_230 sn_89 0 1.753536824616409e-16
Rsub_89_184 sn_89 sn_184 5170238.781859193
Csub_89_184 sn_89 sn_184 2.037910422860805e-18
Rsub_89_217 sn_89 sn_217 314339.3199238075
Csub_89_217 sn_89 sn_217 3.351945758737385e-17
Rsub_89_222 sn_89 sn_222 2105666.400868081
Csub_89_222 sn_89 sn_222 5.003871220002482e-18
Rsub_89_143 sn_89 sn_143 53285789.52238297
Csub_89_143 sn_89 sn_143 1.977353361312981e-19
Rsub_89_135 sn_89 sn_135 8246320.420042301
Csub_89_135 sn_89 sn_135 1.277719390653505e-18
Rsub_89_117 sn_89 sn_117 2360312.36165993
Csub_89_117 sn_89 sn_117 4.464020810711698e-18
Rsub_89_187 sn_89 sn_187 20060.35967687422
Csub_89_187 sn_89 sn_187 5.252390122584175e-16
Rsub_89_108 sn_89 sn_108 319012.7435959239
Csub_89_108 sn_89 sn_108 3.302840940917392e-17
Rsub_89_91 sn_89 sn_91 207459.9828896556
Csub_89_91 sn_89 sn_91 5.078802839694717e-17
Rsub_89_114 sn_89 sn_114 32557208.85026984
Csub_89_114 sn_89 sn_114 3.236298157709754e-19
Rsub_89_116 sn_89 sn_116 18090854.4674757
Csub_89_116 sn_89 sn_116 5.824204446049143e-19
Rsub_89_96 sn_89 sn_96 267585.238758455
Csub_89_96 sn_89 sn_96 3.937617617144091e-17
Rsub_89_175 sn_89 sn_175 326267.5175961447
Csub_89_175 sn_89 sn_175 3.229400088571522e-17
Rsub_89_174 sn_89 sn_174 16030719.78500943
Csub_89_174 sn_89 sn_174 6.572682726375658e-19
Rsub_89_112 sn_89 sn_112 1534399.293878564
Csub_89_112 sn_89 sn_112 6.866845901366717e-18
Rsub_179_186 sn_179 sn_186 30551463.48059591
Csub_179_186 sn_179 sn_186 3.448765558783138e-19
Rsub_179_206 sn_179 sn_206 2990605.648546795
Csub_179_206 sn_179 sn_206 3.523193874575179e-18
Rsub_179_202 sn_179 sn_202 354302.8912427304
Csub_179_202 sn_179 sn_202 2.973863257303066e-17
Rsub_179_193 sn_179 sn_193 3500844.494984113
Csub_179_193 sn_179 sn_193 3.009697665042336e-18
Rsub_179_230 sn_179 0 6480.11415101209
Csub_179_230 sn_179 0 1.625971897514239e-15
Rsub_179_188 sn_179 sn_188 5246660.074351529
Csub_179_188 sn_179 sn_188 2.008226824859104e-18
Rsub_179_225 sn_179 sn_225 343200.8916979117
Csub_179_225 sn_179 sn_225 3.070062973934317e-17
Rsub_179_183 sn_179 sn_183 963458.8249753122
Csub_179_183 sn_179 sn_183 1.093610150127587e-17
Rsub_179_220 sn_179 sn_220 71998.10349658411
Csub_179_220 sn_179 sn_220 1.463439033880926e-16
Rsub_179_217 sn_179 sn_217 253932.4650052851
Csub_179_217 sn_179 sn_217 4.149325097919522e-17
Rsub_179_215 sn_179 sn_215 321008.4217353894
Csub_179_215 sn_179 sn_215 3.282307499993047e-17
Rsub_179_181 sn_179 sn_181 56777.04886080221
Csub_179_181 sn_179 sn_181 1.855764558679658e-16
Rsub_179_216 sn_179 sn_216 69217242.15164171
Csub_179_216 sn_179 sn_216 1.522233936906441e-19
Rsub_179_209 sn_179 sn_209 13670.95861718486
Csub_179_209 sn_179 sn_209 7.70720166542329e-16
Rsub_179_187 sn_179 sn_187 15611.69196760946
Csub_179_187 sn_179 sn_187 6.74909774295489e-16
Rsub_179_219 sn_179 sn_219 2762567.816867718
Csub_179_219 sn_179 sn_219 3.814018044334051e-18
Rsub_179_210 sn_179 sn_210 1643787.804863227
Csub_179_210 sn_179 sn_210 6.409880564302335e-18
Rsub_179_221 sn_179 sn_221 2108267.258463017
Csub_179_221 sn_179 sn_221 4.997698209244771e-18
Rsub_179_184 sn_179 sn_184 24445706.51915983
Csub_179_184 sn_179 sn_184 4.310157079719425e-19
Rsub_179_228 sn_179 sn_228 31425071.71532093
Csub_179_228 sn_179 sn_228 3.352890837507003e-19
Rsub_179_191 sn_179 sn_191 538950.200213094
Csub_179_191 sn_179 sn_191 1.955001315161217e-17
Rsub_179_199 sn_179 sn_199 46298146.94019492
Csub_179_199 sn_179 sn_199 2.275789464282529e-19
Rsub_179_204 sn_179 sn_204 6294521.196511834
Csub_179_204 sn_179 sn_204 1.67391341982753e-18
Rsub_179_195 sn_179 sn_195 493774.113790998
Csub_179_195 sn_179 sn_195 2.133867128297824e-17
Rsub_179_211 sn_179 sn_211 14248536.64775585
Csub_179_211 sn_179 sn_211 7.394782890837776e-19
Rsub_179_226 sn_179 sn_226 641372.5993671201
Csub_179_226 sn_179 sn_226 1.642802251394426e-17
Rsub_179_194 sn_179 sn_194 6210633.97154305
Csub_179_194 sn_179 sn_194 1.696523020114834e-18
Rsub_179_198 sn_179 sn_198 538950.200213094
Csub_179_198 sn_179 sn_198 1.955001315161217e-17
Rsub_179_223 sn_179 sn_223 282029.5942049338
Csub_179_223 sn_179 sn_223 3.735949602003035e-17
Rsub_12_65 sn_12 sn_65 45721865.65820798
Csub_12_65 sn_12 sn_65 2.304473658401227e-19
Rsub_12_125 sn_12 sn_125 45721865.65820798
Csub_12_125 sn_12 sn_125 2.304473658401227e-19
Rsub_12_88 sn_12 sn_88 12276905.02883641
Csub_12_88 sn_12 sn_88 8.582361334132302e-19
Rsub_12_53 sn_12 sn_53 45721865.65820798
Csub_12_53 sn_12 sn_53 2.304473658401227e-19
Rsub_12_29 sn_12 sn_29 51708613.65623675
Csub_12_29 sn_12 sn_29 2.037665053694426e-19
Rsub_12_50 sn_12 sn_50 139101893.975742
Csub_12_50 sn_12 sn_50 7.574651358857456e-20
Rsub_12_144 sn_12 sn_144 61546165.91036945
Csub_12_144 sn_12 sn_144 1.711964237963163e-19
Rsub_12_117 sn_12 sn_117 23034803.02371296
Csub_12_117 sn_12 sn_117 4.574158281876044e-19
Rsub_12_75 sn_12 sn_75 46422676.49546381
Csub_12_75 sn_12 sn_75 2.269684623474817e-19
Rsub_12_58 sn_12 sn_58 44610234.67497459
Csub_12_58 sn_12 sn_58 2.361898245772006e-19
Rsub_12_169 sn_12 sn_169 19875807.43528949
Csub_12_169 sn_12 sn_169 5.301159983831638e-19
Rsub_12_166 sn_12 sn_166 40674530.79378873
Csub_12_166 sn_12 sn_166 2.590437626840183e-19
Rsub_12_155 sn_12 sn_155 36183358.79685147
Csub_12_155 sn_12 sn_155 2.911969439151913e-19
Rsub_12_20 sn_12 sn_20 44252720.6307853
Csub_12_20 sn_12 sn_20 2.380979824978282e-19
Rsub_12_107 sn_12 sn_107 2696795.433129054
Csub_12_107 sn_12 sn_107 3.907038469730969e-18
Rsub_12_27 sn_12 sn_27 33643916.82676224
Csub_12_27 sn_12 sn_27 3.131764816945659e-19
Rsub_12_118 sn_12 sn_118 46060188.13136596
Csub_12_118 sn_12 sn_118 2.287546779483276e-19
Rsub_12_18 sn_12 sn_18 295258855.5031633
Csub_12_18 sn_12 sn_18 3.568557997786154e-20
Rsub_12_185 sn_12 sn_185 13894101.49205564
Csub_12_185 sn_12 sn_185 7.583422006996668e-19
Rsub_12_192 sn_12 sn_192 42327760.00618619
Csub_12_192 sn_12 sn_192 2.489260830407774e-19
Rsub_12_30 sn_12 sn_30 31879173.73094787
Csub_12_30 sn_12 sn_30 3.305130675956424e-19
Rsub_12_105 sn_12 sn_105 6836717.001265836
Csub_12_105 sn_12 sn_105 1.541161276717925e-18
Rsub_12_159 sn_12 sn_159 20313126.05861124
Csub_12_159 sn_12 sn_159 5.187032006707467e-19
Rsub_12_115 sn_12 sn_115 46768073.88213374
Csub_12_115 sn_12 sn_115 2.252922266754956e-19
Rsub_12_190 sn_12 sn_190 45721865.65820798
Csub_12_190 sn_12 sn_190 2.304473658401227e-19
Rsub_12_23 sn_12 sn_23 49225919.84448713
Csub_12_23 sn_12 sn_23 2.140434050905804e-19
Rsub_12_129 sn_12 sn_129 5373246.176095697
Csub_12_129 sn_12 sn_129 1.960915833170705e-18
Rsub_12_135 sn_12 sn_135 49225919.84448713
Csub_12_135 sn_12 sn_135 2.140434050905804e-19
Rsub_12_168 sn_12 sn_168 13752437.11213502
Csub_12_168 sn_12 sn_168 7.661539126714279e-19
Rsub_12_72 sn_12 sn_72 5287707.935578111
Csub_12_72 sn_12 sn_72 1.992637193770808e-18
Rsub_12_57 sn_12 sn_57 7363479.894465931
Csub_12_57 sn_12 sn_57 1.430910880893253e-18
Rsub_12_224 sn_12 sn_224 11879146.35582747
Csub_12_224 sn_12 sn_224 8.869731196687542e-19
Rsub_12_84 sn_12 sn_84 26697435.90852002
Csub_12_84 sn_12 sn_84 3.946627510721907e-19
Rsub_12_150 sn_12 sn_150 14423624.48709286
Csub_12_150 sn_12 sn_150 7.305017897310547e-19
Rsub_12_114 sn_12 sn_114 11673081.04584845
Csub_12_114 sn_12 sn_114 9.026308873249294e-19
Rsub_12_59 sn_12 sn_59 45721865.65820798
Csub_12_59 sn_12 sn_59 2.304473658401227e-19
Rsub_12_226 sn_12 sn_226 8246403.50067741
Csub_12_226 sn_12 sn_226 1.277706517921961e-18
Rsub_12_71 sn_12 sn_71 6997409968.312348
Rsub_12_162 sn_12 sn_162 7282010.964788911
Csub_12_162 sn_12 sn_162 1.446919477762065e-18
Rsub_12_228 sn_12 sn_228 31886429.40666916
Csub_12_228 sn_12 sn_228 3.3043786018971e-19
Rsub_12_61 sn_12 sn_61 10103130.84704644
Csub_12_61 sn_12 sn_61 1.042892907331815e-18
Rsub_12_182 sn_12 sn_182 282884885.4783971
Csub_12_182 sn_12 sn_182 3.72465410600194e-20
Rsub_12_191 sn_12 sn_191 121462629.271984
Csub_12_191 sn_12 sn_191 8.674671020529519e-20
Rsub_12_198 sn_12 sn_198 492991.2222923308
Csub_12_198 sn_12 sn_198 2.137255802088529e-17
Rsub_12_157 sn_12 sn_157 8094965.641759876
Csub_12_157 sn_12 sn_157 1.301609416088804e-18
Rsub_12_78 sn_12 sn_78 8050879.595404542
Csub_12_78 sn_12 sn_78 1.308736937047754e-18
Rsub_12_99 sn_12 sn_99 96300.97565995193
Csub_12_99 sn_12 sn_99 1.094120119762373e-16
Rsub_12_178 sn_12 sn_178 1093682.660104524
Csub_12_178 sn_12 sn_178 9.633949486977349e-18
Rsub_12_133 sn_12 sn_133 298919.4739720149
Csub_12_133 sn_12 sn_133 3.524856832585098e-17
Rsub_12_221 sn_12 sn_221 27135268.15940323
Csub_12_221 sn_12 sn_221 3.882947992381928e-19
Rsub_12_110 sn_12 sn_110 12528262.76352561
Csub_12_110 sn_12 sn_110 8.410171227335357e-19
Rsub_12_34 sn_12 sn_34 49225919.84448713
Csub_12_34 sn_12 sn_34 2.140434050905804e-19
Rsub_12_201 sn_12 sn_201 608573.8097764
Csub_12_201 sn_12 sn_201 1.731340280006673e-17
Rsub_12_16 sn_12 sn_16 406486031.5467456
Csub_12_16 sn_12 sn_16 2.592089932866073e-20
Rsub_12_174 sn_12 sn_174 28219655.7684031
Csub_12_174 sn_12 sn_174 3.733739202455992e-19
Rsub_12_160 sn_12 sn_160 7215245.816973913
Csub_12_160 sn_12 sn_160 1.460308320673268e-18
Rsub_12_40 sn_12 sn_40 71118339.10873462
Csub_12_40 sn_12 sn_40 1.481542403024978e-19
Rsub_12_128 sn_12 sn_128 13318789.65822542
Csub_12_128 sn_12 sn_128 7.910991743700135e-19
Rsub_12_76 sn_12 sn_76 61126.35013488293
Csub_12_76 sn_12 sn_76 1.723722008426797e-16
Rsub_12_60 sn_12 sn_60 3069184.310327816
Csub_12_60 sn_12 sn_60 3.432991452085395e-18
Rsub_12_227 sn_12 sn_227 2072945.246325785
Csub_12_227 sn_12 sn_227 5.082856636423712e-18
Rsub_12_69 sn_12 sn_69 34453527.48214921
Csub_12_69 sn_12 sn_69 3.058172637820345e-19
Rsub_12_148 sn_12 sn_148 6697703.871524256
Csub_12_148 sn_12 sn_148 1.573148605005751e-18
Rsub_12_153 sn_12 sn_153 1507989.116479101
Csub_12_153 sn_12 sn_153 6.987108452633201e-18
Rsub_12_219 sn_12 sn_219 13656339.5593516
Csub_12_219 sn_12 sn_219 7.7154521945193e-19
Rsub_12_52 sn_12 sn_52 26014.78135691781
Csub_12_52 sn_12 sn_52 4.050191065483683e-16
Rsub_12_43 sn_12 sn_43 3093191.172629581
Csub_12_43 sn_12 sn_43 3.406347333285817e-18
Rsub_12_210 sn_12 sn_210 4591315.601742428
Csub_12_210 sn_12 sn_210 2.294872410476716e-18
Rsub_12_222 sn_12 sn_222 465716.7207700684
Csub_12_222 sn_12 sn_222 2.262423278427237e-17
Rsub_12_143 sn_12 sn_143 53285789.52238297
Csub_12_143 sn_12 sn_143 1.977353361312981e-19
Rsub_12_188 sn_12 sn_188 234195.659880023
Csub_12_188 sn_12 sn_188 4.499008866188118e-17
Rsub_12_35 sn_12 sn_35 17593995.95703594
Csub_12_35 sn_12 sn_35 5.988681325129213e-19
Rsub_12_180 sn_12 sn_180 44467116.77963358
Csub_12_180 sn_12 sn_180 2.369500040770762e-19
Rsub_12_101 sn_12 sn_101 862843.2528358252
Csub_12_101 sn_12 sn_101 1.221135295153637e-17
Rsub_12_22 sn_12 sn_22 5200787.677321465
Csub_12_22 sn_12 sn_22 2.025939945246246e-18
Rsub_12_41 sn_12 sn_41 145947.3503878869
Csub_12_41 sn_12 sn_41 7.219372927447468e-17
Rsub_12_218 sn_12 sn_218 51478127.13644705
Csub_12_218 sn_12 sn_218 2.046788430026247e-19
Rsub_12_51 sn_12 sn_51 10027070.32521582
Csub_12_51 sn_12 sn_51 1.050803790189156e-18
Rsub_12_215 sn_12 sn_215 1049627.767539891
Csub_12_215 sn_12 sn_215 1.003830484298764e-17
Rsub_12_48 sn_12 sn_48 1022044.364593807
Csub_12_48 sn_12 sn_48 1.030922322674079e-17
Rsub_12_39 sn_12 sn_39 89936043.88609657
Csub_12_39 sn_12 sn_39 1.171552922160373e-19
Rsub_12_206 sn_12 sn_206 5621080.796015845
Csub_12_206 sn_12 sn_206 1.87445864676027e-18
Rsub_12_19 sn_12 sn_19 10540402.45479866
Csub_12_19 sn_12 sn_19 9.996281970650115e-19
Rsub_12_177 sn_12 sn_177 6004569.244668892
Csub_12_177 sn_12 sn_177 1.754744274384833e-18
Rsub_12_138 sn_12 sn_138 198977.5651749096
Csub_12_138 sn_12 sn_138 5.295312309690789e-17
Rsub_12_137 sn_12 sn_137 45542902.83053533
Csub_12_137 sn_12 sn_137 2.31352918838664e-19
Rsub_12_49 sn_12 sn_49 702417.9496802402
Csub_12_49 sn_12 sn_49 1.500030502783491e-17
Rsub_12_216 sn_12 sn_216 5699782.028555916
Csub_12_216 sn_12 sn_216 1.848576568269138e-18
Rsub_12_212 sn_12 sn_212 4993811.170144196
Csub_12_212 sn_12 sn_212 2.109908273108725e-18
Rsub_12_203 sn_12 sn_203 11285477.6723173
Csub_12_203 sn_12 sn_203 9.336320365132137e-19
Rsub_12_28 sn_12 sn_28 49346595.33591767
Csub_12_28 sn_12 sn_28 2.135199689158871e-19
Rsub_12_195 sn_12 sn_195 2334445.705301119
Csub_12_195 sn_12 sn_195 4.513484069603111e-18
Rsub_12_204 sn_12 sn_204 1607515.655924614
Csub_12_204 sn_12 sn_204 6.554513769988516e-18
Rsub_12_37 sn_12 sn_37 4840801.978481684
Csub_12_37 sn_12 sn_37 2.176598743155936e-18
Rsub_12_200 sn_12 sn_200 3680807.238461896
Csub_12_200 sn_12 sn_200 2.86254694136955e-18
Rsub_12_170 sn_12 sn_170 1095755.668569138
Csub_12_170 sn_12 sn_170 9.615723472358373e-18
Rsub_12_77 sn_12 sn_77 30123901.52090551
Csub_12_77 sn_12 sn_77 3.497715425380026e-19
Rsub_12_46 sn_12 sn_46 318250.3793424551
Csub_12_46 sn_12 sn_46 3.310752849375918e-17
Rsub_12_213 sn_12 sn_213 35968496.1634615
Csub_12_213 sn_12 sn_213 2.929364478944621e-19
Rsub_12_112 sn_12 sn_112 12174908.93546656
Csub_12_112 sn_12 sn_112 8.65426062574999e-19
Rsub_12_132 sn_12 sn_132 7576021.46995794
Csub_12_132 sn_12 sn_132 1.390767376255666e-18
Rsub_12_44 sn_12 sn_44 8418337.859237673
Csub_12_44 sn_12 sn_44 1.251610909232875e-18
Rsub_12_211 sn_12 sn_211 11170709.32411031
Csub_12_211 sn_12 sn_211 9.432242122251429e-19
Rsub_12_141 sn_12 sn_141 11389349.30580639
Csub_12_141 sn_12 sn_141 9.251172493988231e-19
Rsub_12_199 sn_12 sn_199 1700645.681103964
Csub_12_199 sn_12 sn_199 6.195578314343706e-18
Rsub_12_32 sn_12 sn_32 22949406.57902326
Csub_12_32 sn_12 sn_32 4.591179064238112e-19
Rsub_12_229 sn_12 sn_229 4612076.182851302
Csub_12_229 sn_12 sn_229 2.284542380589229e-18
Rsub_12_230 sn_12 0 283749.5844514124
Csub_12_230 sn_12 0 3.713303588655725e-17
Rsub_12_175 sn_12 sn_175 200772925.2456709
Csub_12_175 sn_12 sn_175 5.247960345916805e-20
Rsub_12_17 sn_12 sn_17 36483908.00690771
Csub_12_17 sn_12 sn_17 2.887981051874999e-19
Rsub_12_167 sn_12 sn_167 31226432.38297038
Csub_12_167 sn_12 sn_167 3.374219434678734e-19
Rsub_12_97 sn_12 sn_97 47019231.80730351
Csub_12_97 sn_12 sn_97 2.240888057340266e-19
Rsub_12_181 sn_12 sn_181 15349879.61524027
Csub_12_181 sn_12 sn_181 6.864212467027271e-19
Rsub_12_14 sn_12 sn_14 1993731.815117602
Csub_12_14 sn_12 sn_14 5.284804817948144e-18
Rsub_12_79 sn_12 sn_79 177443359.3120053
Csub_12_79 sn_12 sn_79 5.937941855408241e-20
Rsub_111_112 sn_111 sn_112 5186444.691678326
Csub_111_112 sn_111 sn_112 2.031542632496561e-18
Rsub_111_157 sn_111 sn_157 945334.41434049
Csub_111_157 sn_111 sn_157 1.114577375201214e-17
Rsub_111_197 sn_111 sn_197 1621803.629974904
Csub_111_197 sn_111 sn_197 6.496768972204755e-18
Rsub_111_156 sn_111 sn_156 617266.5343347675
Csub_111_156 sn_111 sn_156 1.706958488132723e-17
Rsub_111_204 sn_111 sn_204 1654973.748276825
Csub_111_204 sn_111 sn_204 6.3665562751075e-18
Rsub_111_121 sn_111 sn_121 534869.6651518979
Csub_111_121 sn_111 sn_121 1.969916072775924e-17
Rsub_111_146 sn_111 sn_146 32464037.78895685
Csub_111_146 sn_111 sn_146 3.245586260934599e-19
Rsub_111_135 sn_111 sn_135 3095213.685790966
Csub_111_135 sn_111 sn_135 3.40412151529288e-18
Rsub_111_124 sn_111 sn_124 2617709.093248064
Csub_111_124 sn_111 sn_124 4.025078084271117e-18
Rsub_111_167 sn_111 sn_167 226647.9044589041
Csub_111_167 sn_111 sn_167 4.648833408534992e-17
Rsub_111_129 sn_111 sn_129 30716119.40507465
Csub_111_129 sn_111 sn_129 3.430278207763854e-19
Rsub_111_208 sn_111 sn_208 18366077.15224464
Csub_111_208 sn_111 sn_208 5.736926516690729e-19
Rsub_111_163 sn_111 sn_163 361017.5100690068
Csub_111_163 sn_111 sn_163 2.918551928469066e-17
Rsub_111_126 sn_111 sn_126 10036612.35892078
Csub_111_126 sn_111 sn_126 1.04980476732918e-18
Rsub_111_205 sn_111 sn_205 116214.5402019167
Csub_111_205 sn_111 sn_205 9.066407253277787e-17
Rsub_111_119 sn_111 sn_119 30578.28012499765
Csub_111_119 sn_111 sn_119 3.445741048600198e-16
Rsub_111_193 sn_111 sn_193 207408.7804630096
Csub_111_193 sn_111 sn_193 5.080056629574143e-17
Rsub_111_151 sn_111 sn_151 1299308.050673598
Csub_111_151 sn_111 sn_151 8.109303638015316e-18
Rsub_111_230 sn_111 0 40752.98339525939
Csub_111_230 sn_111 0 2.585450836822824e-16
Rsub_111_223 sn_111 sn_223 38301.93221724415
Csub_111_223 sn_111 sn_223 2.750901297216098e-16
Rsub_111_159 sn_111 sn_159 1189415.897465419
Csub_111_159 sn_111 sn_159 8.858535962637354e-18
Rsub_111_122 sn_111 sn_122 4481177.365413742
Csub_111_122 sn_111 sn_122 2.351275712394655e-18
Rsub_111_229 sn_111 sn_229 640834.2238813273
Csub_111_229 sn_111 sn_229 1.64418239687854e-17
Rsub_111_179 sn_111 sn_179 63474.0143051917
Csub_111_179 sn_111 sn_179 1.659968038506144e-16
Rsub_111_222 sn_111 sn_222 2632912.781349495
Csub_111_222 sn_111 sn_222 4.001835372924714e-18
Rsub_111_143 sn_111 sn_143 9842103.861487899
Csub_111_143 sn_111 sn_143 1.07055195215519e-18
Rsub_111_217 sn_111 sn_217 53159.84087602014
Csub_111_217 sn_111 sn_217 1.982038194358648e-16
Rsub_111_141 sn_111 sn_141 390258.6105564203
Csub_111_141 sn_111 sn_141 2.699872140478173e-17
Rsub_111_220 sn_111 sn_220 62481.45097411021
Csub_111_220 sn_111 sn_220 1.686337839144596e-16
Rsub_111_113 sn_111 sn_113 21869.71371668527
Csub_111_113 sn_111 sn_113 4.817842445825572e-16
Rsub_111_187 sn_111 sn_187 29506.94803497223
Csub_111_187 sn_111 sn_187 3.570848292999313e-16
Rsub_111_224 sn_111 sn_224 866886.7839686368
Csub_111_224 sn_111 sn_224 1.215439397287109e-17
Rsub_111_196 sn_111 sn_196 7310755.073988629
Csub_111_196 sn_111 sn_196 1.441230542617736e-18
Rsub_111_117 sn_111 sn_117 1504543.943901928
Csub_111_117 sn_111 sn_117 7.003107848684285e-18
Rsub_111_115 sn_111 sn_115 458922.2872462944
Csub_111_115 sn_111 sn_115 2.295918894123197e-17
Rsub_111_194 sn_111 sn_194 250923.9094110473
Csub_111_194 sn_111 sn_194 4.199075140731136e-17
Rsub_111_202 sn_111 sn_202 93212.286436797
Csub_111_202 sn_111 sn_202 1.130374965040076e-16
Rsub_111_128 sn_111 sn_128 945836.1838733215
Csub_111_128 sn_111 sn_128 1.113986087853156e-17
Rsub_111_175 sn_111 sn_175 352298.9141676552
Csub_111_175 sn_111 sn_175 2.990779442827293e-17
Rsub_111_177 sn_111 sn_177 1622876.180013467
Csub_111_177 sn_111 sn_177 6.492475292934896e-18
Rsub_111_173 sn_111 sn_173 35994872.77095916
Csub_111_173 sn_111 sn_173 2.927217876077864e-19
Rsub_111_136 sn_111 sn_136 1682516.215829428
Csub_111_136 sn_111 sn_136 6.262336970723246e-18
Rsub_111_188 sn_111 sn_188 15938478.61484332
Csub_111_188 sn_111 sn_188 6.610720983380116e-19
Rsub_111_199 sn_111 sn_199 28339877.06610969
Csub_111_199 sn_111 sn_199 3.717900214475553e-19
Rsub_111_139 sn_111 sn_139 487149.8526332373
Csub_111_139 sn_111 sn_139 2.162883442389677e-17
Rsub_111_218 sn_111 sn_218 4869533.953102003
Csub_111_218 sn_111 sn_218 2.163756039839916e-18
Rsub_111_209 sn_111 sn_209 8149.295375857518
Csub_111_209 sn_111 sn_209 1.292931844567149e-15
Rsub_111_130 sn_111 sn_130 442617.4191643883
Csub_111_130 sn_111 sn_130 2.380494541340395e-17
Rsub_111_153 sn_111 sn_153 5395331.306316673
Csub_111_153 sn_111 sn_153 1.952889063530582e-18
Rsub_111_226 sn_111 sn_226 904297.4260431057
Csub_111_226 sn_111 sn_226 1.165156860871984e-17
Rsub_46_162 sn_46 sn_162 11953579.11704686
Csub_46_162 sn_46 sn_162 8.814500995107022e-19
Rsub_46_65 sn_46 sn_65 9661611.501585318
Csub_46_65 sn_46 sn_65 1.090551353726149e-18
Rsub_46_191 sn_46 sn_191 10679881.05565885
Csub_46_191 sn_46 sn_191 9.865731132508384e-19
Rsub_46_165 sn_46 sn_165 10385486.68311213
Csub_46_165 sn_46 sn_165 1.014539214552498e-18
Rsub_46_81 sn_46 sn_81 11235335.86233614
Csub_46_81 sn_46 sn_81 9.377987121463026e-19
Rsub_46_95 sn_46 sn_95 35834469.10873246
Csub_46_95 sn_46 sn_95 2.940320804044611e-19
Rsub_46_157 sn_46 sn_157 5156621.756086306
Csub_46_157 sn_46 sn_157 2.043291907108351e-18
Rsub_46_83 sn_46 sn_83 10780872.83869108
Csub_46_83 sn_46 sn_83 9.773312105505964e-19
Rsub_46_158 sn_46 sn_158 7523694.516271822
Csub_46_158 sn_46 sn_158 1.400440100198418e-18
Rsub_46_79 sn_46 sn_79 8457575.722290337
Csub_46_79 sn_46 sn_79 1.245804217213285e-18
Rsub_46_208 sn_46 sn_208 5870129.303479816
Csub_46_208 sn_46 sn_208 1.794932097319214e-18
Rsub_46_111 sn_46 sn_111 6956552.775624427
Csub_46_111 sn_46 sn_111 1.514612746006838e-18
Rsub_46_171 sn_46 sn_171 1501355.631611923
Csub_46_171 sn_46 sn_171 7.017979804636666e-18
Rsub_46_167 sn_46 sn_167 5710670.496328607
Csub_46_167 sn_46 sn_167 1.845051909229207e-18
Rsub_46_115 sn_46 sn_115 3819145.022566101
Csub_46_115 sn_46 sn_115 2.758859231574949e-18
Rsub_46_125 sn_46 sn_125 7470362.178621246
Csub_46_125 sn_46 sn_125 1.410438108661373e-18
Rsub_46_124 sn_46 sn_124 10073930.35746544
Csub_46_124 sn_46 sn_124 1.045915856905024e-18
Rsub_46_87 sn_46 sn_87 4635597.778752916
Csub_46_87 sn_46 sn_87 2.272950330273168e-18
Rsub_46_100 sn_46 sn_100 10806120.78444914
Csub_46_100 sn_46 sn_100 9.750477264137962e-19
Rsub_46_117 sn_46 sn_117 1014414.341114663
Csub_46_117 sn_46 sn_117 1.038676512661706e-17
Rsub_46_70 sn_46 sn_70 29171682.63454073
Csub_46_70 sn_46 sn_70 3.611887471226729e-19
Rsub_46_180 sn_46 sn_180 46276151.05236766
Csub_46_180 sn_46 sn_180 2.276871187991966e-19
Rsub_46_144 sn_46 sn_144 15110947.07780627
Csub_46_144 sn_46 sn_144 6.972748596085771e-19
Rsub_46_221 sn_46 sn_221 2214828.264743389
Csub_46_221 sn_46 sn_221 4.75724627049166e-18
Rsub_46_210 sn_46 sn_210 7260938.90660009
Csub_46_210 sn_46 sn_210 1.451118600192668e-18
Rsub_46_212 sn_46 sn_212 1284498.767267328
Csub_46_212 sn_46 sn_212 8.202797675427561e-18
Rsub_46_148 sn_46 sn_148 1938569.29861898
Csub_46_148 sn_46 sn_148 5.435185376006987e-18
Rsub_46_132 sn_46 sn_132 807817.7418091013
Csub_46_132 sn_46 sn_132 1.304314445809723e-17
Rsub_46_196 sn_46 sn_196 5407592.822271599
Csub_46_196 sn_46 sn_196 1.948460960084616e-18
Rsub_46_182 sn_46 sn_182 16212627.60273382
Csub_46_182 sn_46 sn_182 6.498936360231522e-19
Rsub_46_126 sn_46 sn_126 4235173.491207308
Csub_46_126 sn_46 sn_126 2.487851684023078e-18
Rsub_46_160 sn_46 sn_160 1153236.532507979
Csub_46_160 sn_46 sn_160 9.136446171468385e-18
Rsub_46_112 sn_46 sn_112 1750192.007279394
Csub_46_112 sn_46 sn_112 6.020187189980692e-18
Rsub_46_211 sn_46 sn_211 2026466.590188653
Csub_46_211 sn_46 sn_211 5.199436079155449e-18
Rsub_46_53 sn_46 sn_53 546799.0234184507
Csub_46_53 sn_46 sn_53 1.926938975925477e-17
Rsub_46_201 sn_46 sn_201 276947.009421938
Csub_46_201 sn_46 sn_201 3.804512467645865e-17
Rsub_46_198 sn_46 sn_198 240351.0153675563
Csub_46_198 sn_46 sn_198 4.383789885853865e-17
Rsub_46_131 sn_46 sn_131 209264.8214850173
Csub_46_131 sn_46 sn_131 5.034999875975038e-17
Rsub_46_219 sn_46 sn_219 794985.4605062013
Csub_46_219 sn_46 sn_219 1.325368075979776e-17
Rsub_46_52 sn_46 sn_52 39381.82575292134
Csub_46_52 sn_46 sn_52 2.675468518990236e-16
Rsub_46_139 sn_46 sn_139 4659041.037012714
Csub_46_139 sn_46 sn_139 2.261513349748426e-18
Rsub_46_181 sn_46 sn_181 4433783.073357882
Csub_46_181 sn_46 sn_181 2.376409338910282e-18
Rsub_46_170 sn_46 sn_170 1039949.523452381
Csub_46_170 sn_46 sn_170 1.013172588151339e-17
Rsub_46_63 sn_46 sn_63 3552791.814677803
Csub_46_63 sn_46 sn_63 2.965691223082695e-18
Rsub_46_230 sn_46 0 27228.05199156301
Csub_46_230 sn_46 0 3.869716241725584e-16
Rsub_46_72 sn_46 sn_72 617652.5740504385
Csub_46_72 sn_46 sn_72 1.705891620127787e-17
Rsub_46_151 sn_46 sn_151 17780646.27593837
Csub_46_151 sn_46 sn_151 5.925815821716492e-19
Rsub_46_190 sn_46 sn_190 2352437.018770191
Csub_46_190 sn_46 sn_190 4.478965182982145e-18
Rsub_46_60 sn_46 sn_60 267755.4070856138
Csub_46_60 sn_46 sn_60 3.935115117530008e-17
Rsub_46_188 sn_46 sn_188 319512.694272809
Csub_46_188 sn_46 sn_188 3.297672890966158e-17
Rsub_46_206 sn_46 sn_206 188562.5970090769
Csub_46_206 sn_46 sn_206 5.587790828805143e-17
Rsub_46_204 sn_46 sn_204 10130.7350468127
Csub_46_204 sn_46 sn_204 1.040051235526583e-15
Rsub_46_138 sn_46 sn_138 239986.2914380216
Csub_46_138 sn_46 sn_138 4.390452237540049e-17
Rsub_46_50 sn_46 sn_50 546855.7275720544
Csub_46_50 sn_46 sn_50 1.92673916921565e-17
Rsub_46_217 sn_46 sn_217 7948576.492019294
Csub_46_217 sn_46 sn_217 1.325581192155485e-18
Rsub_46_101 sn_46 sn_101 12722.81233133772
Csub_46_101 sn_46 sn_101 8.281567964558791e-16
Rsub_46_99 sn_46 sn_99 12075.60790972684
Csub_46_99 sn_46 sn_99 8.725426977256289e-16
Rsub_46_178 sn_46 sn_178 321568.68089269
Csub_46_178 sn_46 sn_178 3.276588837252503e-17
Rsub_46_199 sn_46 sn_199 558949.4462917064
Csub_46_199 sn_46 sn_199 1.885051246071221e-17
Rsub_46_218 sn_46 sn_218 5560680.93895479
Csub_46_218 sn_46 sn_218 1.894818929174254e-18
Rsub_46_51 sn_46 sn_51 19094.58208633278
Csub_46_51 sn_46 sn_51 5.518048760947555e-16
Rsub_46_209 sn_46 sn_209 5398025.389154638
Csub_46_209 sn_46 sn_209 1.951914402514523e-18
Rsub_46_130 sn_46 sn_130 2011120.546198903
Csub_46_130 sn_46 sn_130 5.23911086391334e-18
Rsub_46_76 sn_46 sn_76 21033.60043725678
Csub_46_76 sn_46 sn_76 5.009358019165727e-16
Rsub_46_155 sn_46 sn_155 2960063.943533265
Csub_46_155 sn_46 sn_155 3.559545909556664e-18
Rsub_46_48 sn_46 sn_48 21302.30388446348
Csub_46_48 sn_46 sn_48 4.946170873993883e-16
Rsub_46_215 sn_46 sn_215 214876.8313590038
Csub_46_215 sn_46 sn_215 4.903499104855216e-17
Rsub_46_141 sn_46 sn_141 660932.5174052258
Csub_46_141 sn_46 sn_141 1.59418446282466e-17
Rsub_46_195 sn_46 sn_195 418921.1864574176
Csub_46_195 sn_46 sn_195 2.51514696387909e-17
Rsub_46_97 sn_46 sn_97 377177.6530319761
Csub_46_97 sn_46 sn_97 2.793506830940683e-17
Rsub_46_129 sn_46 sn_129 486982.0043958303
Csub_46_129 sn_46 sn_129 2.163628924091762e-17
Rsub_46_166 sn_46 sn_166 601502.332082863
Csub_46_166 sn_46 sn_166 1.75169453886315e-17
Rsub_46_110 sn_46 sn_110 831570.9179316899
Csub_46_110 sn_46 sn_110 1.267057718713478e-17
Rsub_46_114 sn_46 sn_114 483527.7874482717
Csub_46_114 sn_46 sn_114 2.179085416752229e-17
Rsub_46_214 sn_46 sn_214 10905447.50723721
Csub_46_214 sn_46 sn_214 9.661670000463212e-19
Rsub_46_47 sn_46 sn_47 1207557.239105195
Csub_46_47 sn_46 sn_47 8.725452641928247e-18
Rsub_46_224 sn_46 sn_224 4491935.077357966
Csub_46_224 sn_46 sn_224 2.345644654425254e-18
Rsub_46_78 sn_46 sn_78 255124.8947954827
Csub_46_78 sn_46 sn_78 4.129931542226182e-17
Rsub_46_128 sn_46 sn_128 1592353.385117408
Csub_46_128 sn_46 sn_128 6.616925363871488e-18
Rsub_46_216 sn_46 sn_216 2617787.150486542
Csub_46_216 sn_46 sn_216 4.024958064398662e-18
Rsub_46_49 sn_46 sn_49 1710590.751577187
Csub_46_49 sn_46 sn_49 6.159558323646512e-18
Rsub_46_62 sn_46 sn_62 11033352.29627167
Csub_46_62 sn_46 sn_62 9.549666519567613e-19
Rsub_46_229 sn_46 sn_229 2982560.373460711
Csub_46_229 sn_46 sn_229 3.532697475627076e-18
Rsub_46_154 sn_46 sn_154 4550006.736714156
Csub_46_154 sn_46 sn_154 2.315707231202707e-18
Rsub_46_68 sn_46 sn_68 4048137.907849153
Csub_46_68 sn_46 sn_68 2.60279756818567e-18
Rsub_46_59 sn_46 sn_59 10209106.60543792
Csub_46_59 sn_46 sn_59 1.032067144505838e-18
Rsub_46_226 sn_46 sn_226 2772378.497294611
Csub_46_226 sn_46 sn_226 3.800521289756031e-18
Rsub_46_223 sn_46 sn_223 6058563.773764633
Csub_46_223 sn_46 sn_223 1.739105817100759e-18
Rsub_46_153 sn_46 sn_153 1872727.3600665
Csub_46_153 sn_46 sn_153 5.626277335882919e-18
Rsub_46_67 sn_46 sn_67 182535.1167072481
Csub_46_67 sn_46 sn_67 5.772304908938994e-17
Rsub_46_58 sn_46 sn_58 46885804.88813345
Csub_46_58 sn_46 sn_58 2.24726514290826e-19
Rsub_46_225 sn_46 sn_225 5459151.342799139
Csub_46_225 sn_46 sn_225 1.930058875566453e-18
Rsub_46_133 sn_46 sn_133 418904.4166652991
Csub_46_133 sn_46 sn_133 2.515247651506276e-17
Rsub_46_90 sn_46 sn_90 90397311.24302362
Csub_46_90 sn_46 sn_90 1.16557487798545e-19
Rsub_46_142 sn_46 sn_142 2904282.06017566
Csub_46_142 sn_46 sn_142 3.627913296270102e-18
Rsub_46_177 sn_46 sn_177 962780.5576998355
Csub_46_177 sn_46 sn_177 1.094380585270911e-17
Rsub_46_105 sn_46 sn_105 363059.3091303308
Csub_46_105 sn_46 sn_105 2.902138366171909e-17
Rsub_46_88 sn_46 sn_88 2944579.180572429
Csub_46_88 sn_46 sn_88 3.578264619863848e-18
Rsub_46_159 sn_46 sn_159 96193428.61998391
Csub_46_159 sn_46 sn_159 1.095343377753465e-19
Rsub_46_168 sn_46 sn_168 2105068.149462198
Csub_46_168 sn_46 sn_168 5.005293298899542e-18
Rsub_46_107 sn_46 sn_107 2833646.806733559
Csub_46_107 sn_46 sn_107 3.718347493834549e-18
Rsub_46_118 sn_46 sn_118 2251016.401266986
Csub_46_118 sn_46 sn_118 4.680767095388349e-18
Rsub_46_93 sn_46 sn_93 4384732.594938623
Csub_46_93 sn_46 sn_93 2.402993403609711e-18
Rsub_46_213 sn_46 sn_213 4308318.902663306
Csub_46_213 sn_46 sn_213 2.445613646593473e-18
Rsub_46_222 sn_46 sn_222 251964.4143171059
Csub_46_222 sn_46 sn_222 4.181734762342063e-17
Rsub_46_200 sn_46 sn_200 1923531.898033357
Csub_46_200 sn_46 sn_200 5.477675474476214e-18
Rsub_46_61 sn_46 sn_61 361851.2614059397
Csub_46_61 sn_46 sn_61 2.911827213560474e-17
Rsub_46_228 sn_46 sn_228 2393652.383654812
Csub_46_228 sn_46 sn_228 4.401843632007289e-18
Rsub_213_229 sn_213 sn_229 7750433.34302246
Csub_213_229 sn_213 sn_229 1.359470243262689e-18
Rsub_213_217 sn_213 sn_217 6333027.361877044
Csub_213_217 sn_213 sn_217 1.663735667029725e-18
Rsub_213_224 sn_213 sn_224 2358105.117432317
Csub_213_224 sn_213 sn_224 4.468199243680417e-18
Rsub_213_219 sn_213 sn_219 1436789.779441387
Csub_213_219 sn_213 sn_219 7.333350816517156e-18
Rsub_213_225 sn_213 sn_225 2556873.677673565
Csub_213_225 sn_213 sn_225 4.120846326603386e-18
Rsub_213_218 sn_213 sn_218 1907939.440762364
Csub_213_218 sn_213 sn_218 5.522441266804511e-18
Rsub_213_221 sn_213 sn_221 385690.1377068723
Csub_213_221 sn_213 sn_221 2.731851938158143e-17
Rsub_213_226 sn_213 sn_226 315803.9641511642
Csub_213_226 sn_213 sn_226 3.336400013391397e-17
Rsub_213_216 sn_213 sn_216 2116481.002338699
Csub_213_216 sn_213 sn_216 4.978302895507804e-18
Rsub_213_215 sn_213 sn_215 66205.63170848352
Csub_213_215 sn_213 sn_215 1.591478433228191e-16
Rsub_213_222 sn_213 sn_222 39072.78395183505
Csub_213_222 sn_213 sn_222 2.696629837080027e-16
Rsub_213_230 sn_213 0 49539.38574670842
Csub_213_230 sn_213 0 2.126890219451315e-16
Rsub_213_227 sn_213 sn_227 88760.97708643434
Csub_213_227 sn_213 sn_227 1.187062586295068e-16
Rsub_213_214 sn_213 sn_214 46207.49491678895
Csub_213_214 sn_213 sn_214 2.280254214430849e-16
Rsub_32_78 sn_32 sn_78 22754948.93290811
Csub_32_78 sn_32 sn_78 4.630414040170481e-19
Rsub_32_135 sn_32 sn_135 11963121.73533436
Csub_32_135 sn_32 sn_135 8.807469935802267e-19
Rsub_32_192 sn_32 sn_192 7715199.077724384
Csub_32_192 sn_32 sn_192 1.365678759042179e-18
Rsub_32_179 sn_32 sn_179 28539917.1999702
Csub_32_179 sn_32 sn_179 3.691840949784185e-19
Rsub_32_50 sn_32 sn_50 182331647.1412152
Csub_32_50 sn_32 sn_50 5.778746403837141e-20
Rsub_32_148 sn_32 sn_148 11980019.31496224
Csub_32_148 sn_32 sn_148 8.795047174148242e-19
Rsub_32_39 sn_32 sn_39 58812142.88135503
Csub_32_39 sn_32 sn_39 1.791548987338521e-19
Rsub_32_170 sn_32 sn_170 26799973.05230056
Csub_32_170 sn_32 sn_170 3.931527648056919e-19
Rsub_32_153 sn_32 sn_153 8995584.909735681
Csub_32_153 sn_32 sn_153 1.171294986146665e-18
Rsub_32_110 sn_32 sn_110 13543506.44261665
Csub_32_110 sn_32 sn_110 7.779730859857231e-19
Rsub_32_169 sn_32 sn_169 98681956.37812047
Csub_32_169 sn_32 sn_169 1.067721383821909e-19
Rsub_32_165 sn_32 sn_165 49340978.18906023
Csub_32_165 sn_32 sn_165 2.135442767643817e-19
Rsub_32_127 sn_32 sn_127 24670489.09453012
Csub_32_127 sn_32 sn_127 4.270885535287635e-19
Rsub_32_86 sn_32 sn_86 9868067.59617608
Csub_32_86 sn_32 sn_86 1.067735237881116e-18
Rsub_32_82 sn_32 sn_82 12983259.95668221
Csub_32_82 sn_32 sn_82 8.115437522921275e-19
Rsub_32_182 sn_32 sn_182 27476617.99861653
Csub_32_182 sn_32 sn_182 3.834709025237576e-19
Rsub_32_100 sn_32 sn_100 46298639.68073571
Csub_32_100 sn_32 sn_100 2.275765243835901e-19
Rsub_32_94 sn_32 sn_94 23149319.84036786
Csub_32_94 sn_32 sn_94 4.551530487671801e-19
Rsub_32_118 sn_32 sn_118 22001287.78411889
Csub_32_118 sn_32 sn_118 4.78903035386661e-19
Rsub_32_150 sn_32 sn_150 25421661.42925874
Csub_32_150 sn_32 sn_150 4.144687211553833e-19
Rsub_32_114 sn_32 sn_114 10913410.96480031
Csub_32_114 sn_32 sn_114 9.654619931581391e-19
Rsub_32_183 sn_32 sn_183 5754683.753145688
Csub_32_183 sn_32 sn_183 1.830940491989753e-18
Rsub_32_146 sn_32 sn_146 2074660.567101693
Csub_32_146 sn_32 sn_146 5.078654151579842e-18
Rsub_32_123 sn_32 sn_123 2948976.160118522
Csub_32_123 sn_32 sn_123 3.572929359254817e-18
Rsub_32_157 sn_32 sn_157 10722190.78376358
Csub_32_157 sn_32 sn_157 9.826800991253774e-19
Rsub_32_164 sn_32 sn_164 1017388.874794288
Csub_32_164 sn_32 sn_164 1.035639740444423e-17
Rsub_32_162 sn_32 sn_162 172650.066288702
Csub_32_162 sn_32 sn_162 6.102797252687469e-17
Rsub_32_184 sn_32 sn_184 1753433.009527614
Csub_32_184 sn_32 sn_184 6.009059624735021e-18
Rsub_32_186 sn_32 sn_186 7458072.836694275
Csub_32_186 sn_32 sn_186 1.412762215245434e-18
Rsub_32_107 sn_32 sn_107 8314198.708948924
Csub_32_107 sn_32 sn_107 1.267287909644154e-18
Rsub_32_36 sn_32 sn_36 156377.3567438023
Csub_32_36 sn_32 sn_36 6.73785752722003e-17
Rsub_32_203 sn_32 sn_203 7879157.439281205
Csub_32_203 sn_32 sn_203 1.337260180853959e-18
Rsub_32_166 sn_32 sn_166 1979705.92821164
Csub_32_166 sn_32 sn_166 5.322246780231696e-18
Rsub_32_134 sn_32 sn_134 17780566.24821405
Csub_32_134 sn_32 sn_134 5.925842492945537e-19
Rsub_32_171 sn_32 sn_171 7460753.166219874
Csub_32_171 sn_32 sn_171 1.412254670203558e-18
Rsub_32_208 sn_32 sn_208 280088.6156270096
Csub_32_208 sn_32 sn_208 3.761839258851313e-17
Rsub_32_141 sn_32 sn_141 1626685.256024092
Csub_32_141 sn_32 sn_141 6.477272393789959e-18
Rsub_32_227 sn_32 sn_227 3865818.434834728
Csub_32_227 sn_32 sn_227 2.725550534729254e-18
Rsub_32_116 sn_32 sn_116 173792.5402167208
Csub_32_116 sn_32 sn_116 6.062678806058602e-17
Rsub_32_57 sn_32 sn_57 782470.9427545361
Csub_32_57 sn_32 sn_57 1.346565466717316e-17
Rsub_32_224 sn_32 sn_224 17875.36888882122
Csub_32_224 sn_32 sn_224 5.894414581183405e-16
Rsub_32_230 sn_32 0 217304.8805982328
Csub_32_230 sn_32 0 4.848710012045487e-17
Rsub_32_200 sn_32 sn_200 13541802.14929733
Csub_32_200 sn_32 sn_200 7.780709972030369e-19
Rsub_32_33 sn_32 sn_33 601135.9213899706
Csub_32_33 sn_32 sn_33 1.752762250152532e-17
Rsub_32_191 sn_32 sn_191 2674509.089917393
Csub_32_191 sn_32 sn_191 3.939595323101122e-18
Rsub_32_112 sn_32 sn_112 22280325.63452265
Csub_32_112 sn_32 sn_112 4.729052741448293e-19
Rsub_32_218 sn_32 sn_218 9418011.156782348
Csub_32_218 sn_32 sn_218 1.118758868175919e-18
Rsub_32_139 sn_32 sn_139 7647704.157946516
Csub_32_139 sn_32 sn_139 1.377731575989617e-18
Rsub_32_181 sn_32 sn_181 4824772.999677174
Csub_32_181 sn_32 sn_181 2.183829892708942e-18
Rsub_32_61 sn_32 sn_61 26026664.54222515
Csub_32_61 sn_32 sn_61 4.048341840014043e-19
Rsub_32_228 sn_32 sn_228 4595998.487252256
Csub_32_228 sn_32 sn_228 2.292534153667509e-18
Rsub_32_216 sn_32 sn_216 1560847.324291259
Csub_32_216 sn_32 sn_216 6.75048951825852e-18
Rsub_32_219 sn_32 sn_219 7052717.60829608
Csub_32_219 sn_32 sn_219 1.49396078042824e-18
Rsub_32_52 sn_32 sn_52 222371.219243386
Csub_32_52 sn_32 sn_52 4.738240649163229e-17
Rsub_32_222 sn_32 sn_222 1504128.064034026
Csub_32_222 sn_32 sn_222 7.005044154266671e-18
Rsub_32_84 sn_32 sn_84 375986.0824564777
Csub_32_84 sn_32 sn_84 2.80235997922866e-17
Rsub_32_158 sn_32 sn_158 3271924.14981607
Csub_32_158 sn_32 sn_158 3.220271320416246e-18
Rsub_32_155 sn_32 sn_155 446083.2155652943
Csub_32_155 sn_32 sn_155 2.361999540574006e-17
Rsub_32_190 sn_32 sn_190 33796716.0648478
Csub_32_190 sn_32 sn_190 3.117605711162296e-19
Rsub_32_128 sn_32 sn_128 5100432.094754416
Csub_32_128 sn_32 sn_128 2.065802133326378e-18
Rsub_32_138 sn_32 sn_138 1399403.043540204
Csub_32_138 sn_32 sn_138 7.529270106183882e-18
Rsub_32_93 sn_32 sn_93 1263792.515501867
Csub_32_93 sn_32 sn_93 8.337194098705229e-18
Rsub_32_221 sn_32 sn_221 26727475.37948099
Csub_32_221 sn_32 sn_221 3.942191827934107e-19
Rsub_32_120 sn_32 sn_120 4474662.401877679
Csub_32_120 sn_32 sn_120 2.354699093681041e-18
Rsub_32_199 sn_32 sn_199 26026664.54222515
Csub_32_199 sn_32 sn_199 4.048341840014043e-19
Rsub_32_204 sn_32 sn_204 24167906.35613155
Csub_32_204 sn_32 sn_204 4.359700566100891e-19
Rsub_32_154 sn_32 sn_154 5995973.719646469
Csub_32_154 sn_32 sn_154 1.757259787131163e-18
Rsub_32_56 sn_32 sn_56 5181858.095211808
Csub_32_56 sn_32 sn_56 2.033340803362799e-18
Rsub_32_214 sn_32 sn_214 6125470.176605137
Csub_32_214 sn_32 sn_214 1.72011016272216e-18
Rsub_32_177 sn_32 sn_177 7078540.297837426
Csub_32_177 sn_32 sn_177 1.488510774664802e-18
Rsub_32_202 sn_32 sn_202 17321184.11768121
Csub_32_202 sn_32 sn_202 6.083004158748313e-19
Rsub_32_35 sn_32 sn_35 3845845.179590837
Csub_32_35 sn_32 sn_35 2.739705581011191e-18
Rsub_32_210 sn_32 sn_210 1816932.498334994
Csub_32_210 sn_32 sn_210 5.799050604183402e-18
Rsub_32_43 sn_32 sn_43 23519939.63023446
Csub_32_43 sn_32 sn_43 4.479808905923187e-19
Rsub_32_197 sn_32 sn_197 8609444.19641736
Csub_32_197 sn_32 sn_197 1.223828537806719e-18
Rsub_32_59 sn_32 sn_59 28008267.59929337
Csub_32_59 sn_32 sn_59 3.761919035112273e-19
Rsub_32_226 sn_32 sn_226 1601164.69291795
Csub_32_226 sn_32 sn_226 6.580512016554896e-18
Rsub_32_38 sn_32 sn_38 26369152.254754
Csub_32_38 sn_32 sn_38 3.995761183536121e-19
Rsub_32_196 sn_32 sn_196 26026664.54222515
Csub_32_196 sn_32 sn_196 4.048341840014043e-19
Rsub_32_45 sn_32 sn_45 28310.36647930315
Csub_32_45 sn_32 sn_45 3.721775735376971e-16
Rsub_32_212 sn_32 sn_212 1417516.561026517
Csub_32_212 sn_32 sn_212 7.433058485468306e-18
Rsub_32_144 sn_32 sn_144 54953050.2496721
Csub_32_144 sn_32 sn_144 1.917360993495147e-19
Rsub_32_74 sn_32 sn_74 5520259.3921733
Csub_32_74 sn_32 sn_74 1.908693551098119e-18
Rsub_32_160 sn_32 sn_160 3845742.727271451
Csub_32_160 sn_32 sn_160 2.739778568002551e-18
Rsub_32_44 sn_32 sn_44 5933.972760848957
Csub_32_44 sn_32 sn_44 1.775620469940036e-15
Rsub_32_132 sn_32 sn_132 7630312.733059935
Csub_32_132 sn_32 sn_132 1.380871776929728e-18
Rsub_32_53 sn_32 sn_53 12678151.41998565
Csub_32_53 sn_32 sn_53 8.310741174474728e-19
Rsub_32_207 sn_32 sn_207 631806.803849658
Csub_32_207 sn_32 sn_207 1.667674902839004e-17
Rsub_32_40 sn_32 sn_40 564781920.6413276
Csub_32_40 sn_32 sn_40 1.865584417126082e-20
Rsub_32_96 sn_32 sn_96 21526187.07720062
Csub_32_96 sn_32 sn_96 4.894728204508488e-19
Rsub_32_156 sn_32 sn_156 6781464.224582692
Csub_32_156 sn_32 sn_156 1.553718069327186e-18
Rsub_32_97 sn_32 sn_97 18499952.40147891
Csub_32_97 sn_32 sn_97 5.695411141375535e-19
Rsub_32_91 sn_32 sn_91 14746251.67961111
Csub_32_91 sn_32 sn_91 7.145194406791701e-19
Rsub_32_215 sn_32 sn_215 10582732.69829567
Csub_32_215 sn_32 sn_215 9.956297491976611e-19
Rsub_32_48 sn_32 sn_48 3488946.690924316
Csub_32_48 sn_32 sn_48 3.01996116181374e-18
Rsub_34_149 sn_34 sn_149 32344707.31965348
Csub_34_149 sn_34 sn_149 3.257560316777936e-19
Rsub_34_193 sn_34 sn_193 23634241.33917939
Csub_34_193 sn_34 sn_193 4.45814331461669e-19
Rsub_34_57 sn_34 sn_57 10286294.90428386
Csub_34_57 sn_34 sn_57 1.024322518484469e-18
Rsub_34_106 sn_34 sn_106 65296237.31949152
Csub_34_106 sn_34 sn_106 1.613643287081837e-19
Rsub_34_197 sn_34 sn_197 23870068.69375714
Csub_34_197 sn_34 sn_197 4.414098525399578e-19
Rsub_34_59 sn_34 sn_59 6318873.867939897
Csub_34_59 sn_34 sn_59 1.667462228624156e-18
Rsub_34_95 sn_34 sn_95 10415338.18621327
Csub_34_95 sn_34 sn_95 1.011631433742314e-18
Rsub_34_120 sn_34 sn_120 4357636.954706801
Csub_34_120 sn_34 sn_120 2.417935135888101e-18
Rsub_34_40 sn_34 sn_40 152496901.3636765
Csub_34_40 sn_34 sn_40 6.909309899420493e-20
Rsub_34_54 sn_34 sn_54 47427621.92074426
Csub_34_54 sn_34 sn_54 2.221592202079496e-19
Rsub_34_113 sn_34 sn_113 18547340.58896856
Csub_34_113 sn_34 sn_113 5.680859448117759e-19
Rsub_34_186 sn_34 sn_186 8621448.286772566
Csub_34_186 sn_34 sn_186 1.222124537752616e-18
Rsub_34_148 sn_34 sn_148 6437573.184029916
Csub_34_148 sn_34 sn_148 1.636716694478675e-18
Rsub_34_201 sn_34 sn_201 11548703.45434304
Csub_34_201 sn_34 sn_201 9.123520699864898e-19
Rsub_34_121 sn_34 sn_121 6434699.373150643
Csub_34_121 sn_34 sn_121 1.637447671012327e-18
Rsub_34_163 sn_34 sn_163 17927990.35079116
Csub_34_163 sn_34 sn_163 5.87711355041254e-19
Rsub_34_51 sn_34 sn_51 2413131.025670716
Csub_34_51 sn_34 sn_51 4.366312226789031e-18
Rsub_34_218 sn_34 sn_218 1889356.39445494
Csub_34_218 sn_34 sn_218 5.576758060656774e-18
Rsub_34_179 sn_34 sn_179 2433461.29799866
Csub_34_179 sn_34 sn_179 4.329834014987406e-18
Rsub_34_115 sn_34 sn_115 2159014.479731246
Csub_34_115 sn_34 sn_115 4.880228271346092e-18
Rsub_34_85 sn_34 sn_85 5007099.811743879
Csub_34_85 sn_34 sn_85 2.104308661376643e-18
Rsub_34_63 sn_34 sn_63 14630300.02489367
Csub_34_63 sn_34 sn_63 7.20182326015326e-19
Rsub_34_230 sn_34 0 25876.99914034501
Csub_34_230 sn_34 0 4.071756328886874e-16
Rsub_34_43 sn_34 sn_43 1564362.656831048
Csub_34_43 sn_34 sn_43 6.735320263636251e-18
Rsub_34_210 sn_34 sn_210 829485.1642561132
Csub_34_210 sn_34 sn_210 1.270243755556397e-17
Rsub_34_77 sn_34 sn_77 1937412.011904588
Csub_34_77 sn_34 sn_77 5.438432010066886e-18
Rsub_34_66 sn_34 sn_66 1988159.862793841
Csub_34_66 sn_34 sn_66 5.299615840460494e-18
Rsub_34_145 sn_34 sn_145 5913729.319644996
Csub_34_145 sn_34 sn_145 1.781698642720853e-18
Rsub_34_129 sn_34 sn_129 813651.0572149081
Csub_34_129 sn_34 sn_129 1.294963413222361e-17
Rsub_34_107 sn_34 sn_107 1541878.73167692
Csub_34_107 sn_34 sn_107 6.833535793551488e-18
Rsub_34_168 sn_34 sn_168 4752474.216392625
Csub_34_168 sn_34 sn_168 2.217052217955585e-18
Rsub_34_60 sn_34 sn_60 8850655.283624055
Csub_34_60 sn_34 sn_60 1.190474960845572e-18
Rsub_34_227 sn_34 sn_227 2128519.417592073
Csub_34_227 sn_34 sn_227 4.950146761709879e-18
Rsub_34_199 sn_34 sn_199 6828334.541874611
Csub_34_199 sn_34 sn_199 1.54305320537757e-18
Rsub_34_172 sn_34 sn_172 6253348.296650237
Csub_34_172 sn_34 sn_172 1.684934694565811e-18
Rsub_34_80 sn_34 sn_80 367284.2042969735
Csub_34_80 sn_34 sn_80 2.868754871285061e-17
Rsub_34_226 sn_34 sn_226 474651.6471018874
Csub_34_226 sn_34 sn_226 2.219835023551128e-17
Rsub_34_68 sn_34 sn_68 389281.3995275976
Csub_34_68 sn_34 sn_68 2.706649615166889e-17
Rsub_34_157 sn_34 sn_157 1737545.904196821
Csub_34_157 sn_34 sn_157 6.064002957723572e-18
Rsub_34_78 sn_34 sn_78 3367994.187808375
Csub_34_78 sn_34 sn_78 3.128414989660749e-18
Rsub_34_178 sn_34 sn_178 1887177.40030049
Csub_34_178 sn_34 sn_178 5.583197160241696e-18
Rsub_34_166 sn_34 sn_166 3062092.766610096
Csub_34_166 sn_34 sn_166 3.440941965286853e-18
Rsub_34_169 sn_34 sn_169 235492.247851714
Csub_34_169 sn_34 sn_169 4.474237941312052e-17
Rsub_34_125 sn_34 sn_125 430455.3800998526
Csub_34_125 sn_34 sn_125 2.447752772839279e-17
Rsub_34_46 sn_34 sn_46 1447631.619288351
Csub_34_46 sn_34 sn_46 7.278428684370465e-18
Rsub_34_213 sn_34 sn_213 16637338.42875986
Csub_34_213 sn_34 sn_213 6.333034305545102e-19
Rsub_34_134 sn_34 sn_134 4293719.525170172
Csub_34_134 sn_34 sn_134 2.453929149415602e-18
Rsub_34_72 sn_34 sn_72 1698982.973423946
Csub_34_72 sn_34 sn_72 6.201641609742512e-18
Rsub_34_151 sn_34 sn_151 1187137.626941142
Csub_34_151 sn_34 sn_151 8.875536637970954e-18
Rsub_34_49 sn_34 sn_49 2628080.87291256
Csub_34_49 sn_34 sn_49 4.009193024015652e-18
Rsub_34_216 sn_34 sn_216 1728933.668952915
Csub_34_216 sn_34 sn_216 6.094209217760883e-18
Rsub_34_128 sn_34 sn_128 3227491.643998187
Csub_34_128 sn_34 sn_128 3.264604424870796e-18
Rsub_34_44 sn_34 sn_44 2859847.516176317
Csub_34_44 sn_34 sn_44 3.684281571878184e-18
Rsub_34_211 sn_34 sn_211 6441133.523206464
Csub_34_211 sn_34 sn_211 1.635811998659644e-18
Rsub_34_202 sn_34 sn_202 799217.3056049391
Csub_34_202 sn_34 sn_202 1.318350269487068e-17
Rsub_34_35 sn_34 sn_35 3359741.054390877
Csub_34_35 sn_34 sn_35 3.13609987545313e-18
Rsub_34_165 sn_34 sn_165 526022.1028779072
Csub_34_165 sn_34 sn_165 2.003049576164973e-17
Rsub_34_96 sn_34 sn_96 4942015.672521206
Csub_34_96 sn_34 sn_96 2.132021466628562e-18
Rsub_34_153 sn_34 sn_153 70092.24857644054
Csub_34_153 sn_34 sn_153 1.503230915860721e-16
Rsub_34_181 sn_34 sn_181 155701.1331085905
Csub_34_181 sn_34 sn_181 6.76712063160231e-17
Rsub_34_37 sn_34 sn_37 536878.4785816723
Csub_34_37 sn_34 sn_37 1.962545328705543e-17
Rsub_34_204 sn_34 sn_204 1324727.645315485
Csub_34_204 sn_34 sn_204 7.953697908765789e-18
Rsub_34_195 sn_34 sn_195 6307.843002620048
Csub_34_195 sn_34 sn_195 1.670378209770524e-15
Rsub_34_79 sn_34 sn_79 1560986.642998458
Csub_34_79 sn_34 sn_79 6.74988703426107e-18
Rsub_34_158 sn_34 sn_158 2544904.392996818
Csub_34_158 sn_34 sn_158 4.140227637322945e-18
Rsub_34_140 sn_34 sn_140 2682066.435764392
Csub_34_140 sn_34 sn_140 3.928494597199301e-18
Rsub_34_219 sn_34 sn_219 126210.4079503082
Csub_34_219 sn_34 sn_219 8.348347551794973e-17
Rsub_34_52 sn_34 sn_52 369726.4083097812
Csub_34_52 sn_34 sn_52 2.849805495473788e-17
Rsub_34_177 sn_34 sn_177 66702.20447501192
Csub_34_177 sn_34 sn_177 1.579630476257677e-16
Rsub_34_160 sn_34 sn_160 2369384.034608006
Csub_34_160 sn_34 sn_160 4.446929391069848e-18
Rsub_34_222 sn_34 sn_222 332539.7432504967
Csub_34_222 sn_34 sn_222 3.168488493807804e-17
Rsub_34_55 sn_34 sn_55 7823089.992972083
Csub_34_55 sn_34 sn_55 1.346844215226402e-18
Rsub_34_143 sn_34 sn_143 48358299.52571332
Csub_34_143 sn_34 sn_143 2.178836643465408e-19
Rsub_34_150 sn_34 sn_150 503536.9969128439
Csub_34_150 sn_34 sn_150 2.092494407924059e-17
Rsub_34_117 sn_34 sn_117 424582.943772185
Csub_34_117 sn_34 sn_117 2.481607812273184e-17
Rsub_34_38 sn_34 sn_38 450784.1477530444
Csub_34_38 sn_34 sn_38 2.337367796704835e-17
Rsub_34_191 sn_34 sn_191 289273.0445074316
Csub_34_191 sn_34 sn_191 3.642400736014418e-17
Rsub_34_112 sn_34 sn_112 95146.93083698912
Csub_34_112 sn_34 sn_112 1.107390791226012e-16
Rsub_34_183 sn_34 sn_183 2518716.217115317
Csub_34_183 sn_34 sn_183 4.183275364898958e-18
Rsub_34_138 sn_34 sn_138 958055.2290081258
Csub_34_138 sn_34 sn_138 1.099778299121484e-17
Rsub_34_137 sn_34 sn_137 420780.5794614237
Csub_34_137 sn_34 sn_137 2.504032746881077e-17
Rsub_34_47 sn_34 sn_47 904578.3570859024
Csub_34_47 sn_34 sn_47 1.164795003074501e-17
Rsub_34_214 sn_34 sn_214 1189500.128416246
Csub_34_214 sn_34 sn_214 8.857908671484344e-18
Rsub_34_126 sn_34 sn_126 223212.9743555301
Csub_34_126 sn_34 sn_126 4.720372340654204e-17
Rsub_34_131 sn_34 sn_131 111213.6172002337
Csub_34_131 sn_34 sn_131 9.474094780371782e-17
Rsub_34_154 sn_34 sn_154 3778281.878126115
Csub_34_154 sn_34 sn_154 2.788697043285637e-18
Rsub_34_97 sn_34 sn_97 68425.52070945191
Csub_34_97 sn_34 sn_97 1.539847032654667e-16
Rsub_34_176 sn_34 sn_176 668378.7816122441
Csub_34_176 sn_34 sn_176 1.576423996706508e-17
Rsub_34_88 sn_34 sn_88 9290639.640643554
Csub_34_88 sn_34 sn_88 1.134096672540853e-18
Rsub_34_220 sn_34 sn_220 1781636.122982311
Csub_34_220 sn_34 sn_220 5.913936839466861e-18
Rsub_34_53 sn_34 sn_53 773416.8372033177
Csub_34_53 sn_34 sn_53 1.362329211803821e-17
Rsub_34_141 sn_34 sn_141 285267.7972509402
Csub_34_141 sn_34 sn_141 3.693541158086422e-17
Rsub_34_215 sn_34 sn_215 502517.0348188294
Csub_34_215 sn_34 sn_215 2.096741557433706e-17
Rsub_34_48 sn_34 sn_48 113723.8856912906
Csub_34_48 sn_34 sn_48 9.264969657149975e-17
Rsub_34_132 sn_34 sn_132 629873.6355876186
Csub_34_132 sn_34 sn_132 1.672793225009387e-17
Rsub_34_127 sn_34 sn_127 516554.2157601752
Csub_34_127 sn_34 sn_127 2.03976333572735e-17
Rsub_34_130 sn_34 sn_130 377040.5204134641
Csub_34_130 sn_34 sn_130 2.794522851463193e-17
Rsub_34_203 sn_34 sn_203 8857921.72124665
Csub_34_203 sn_34 sn_203 1.189498376008127e-18
Rsub_34_185 sn_34 sn_185 6036166.665461799
Csub_34_185 sn_34 sn_185 1.745558743849546e-18
Rsub_34_162 sn_34 sn_162 33614754.29734001
Csub_34_162 sn_34 sn_162 3.134481784108644e-19
Rsub_34_224 sn_34 sn_224 7133608.936576887
Csub_34_224 sn_34 sn_224 1.477020060379986e-18
Rsub_34_174 sn_34 sn_174 7639192.023430615
Csub_34_174 sn_34 sn_174 1.379266743120599e-18
Rsub_34_41 sn_34 sn_41 986261.4964616968
Csub_34_41 sn_34 sn_41 1.06832554449612e-17
Rsub_34_208 sn_34 sn_208 7501852.558050262
Csub_34_208 sn_34 sn_208 1.404517540260541e-18
Rsub_34_110 sn_34 sn_110 2334186.568519923
Csub_34_110 sn_34 sn_110 4.51398514768725e-18
Rsub_34_228 sn_34 sn_228 1379252.56317737
Csub_34_228 sn_34 sn_228 7.639270561119868e-18
Rsub_34_61 sn_34 sn_61 613262.0847849328
Csub_34_61 sn_34 sn_61 1.718104504361309e-17
Rsub_34_101 sn_34 sn_101 1058305.249443727
Csub_34_101 sn_34 sn_101 9.955996634967329e-18
Rsub_34_114 sn_34 sn_114 8499400.45821093
Csub_34_114 sn_34 sn_114 1.239673733933919e-18
Rsub_34_75 sn_34 sn_75 6627194.493574128
Csub_34_75 sn_34 sn_75 1.589885963426364e-18
Rsub_34_99 sn_34 sn_99 13043396.08310419
Csub_34_99 sn_34 sn_99 8.078021578964755e-19
Rsub_34_190 sn_34 sn_190 1457502.657395492
Csub_34_190 sn_34 sn_190 7.229135019937695e-18
Rsub_34_196 sn_34 sn_196 4881809.288671768
Csub_34_196 sn_34 sn_196 2.158315263703541e-18
Rsub_34_50 sn_34 sn_50 2817238.599557019
Csub_34_50 sn_34 sn_50 3.740003954186468e-18
Rsub_34_217 sn_34 sn_217 2108346.902238612
Csub_34_217 sn_34 sn_217 4.997509418892364e-18
Rsub_34_39 sn_34 sn_39 901995.9742012866
Csub_34_39 sn_34 sn_39 1.168129770375085e-17
Rsub_34_206 sn_34 sn_206 1043034.374487597
Csub_34_206 sn_34 sn_206 1.010176055550056e-17
Rsub_34_98 sn_34 sn_98 9712379.942662947
Csub_34_98 sn_34 sn_98 1.084850836193822e-18
Rsub_34_139 sn_34 sn_139 1115357.117068228
Csub_34_139 sn_34 sn_139 9.446735346904567e-18
Rsub_34_45 sn_34 sn_45 3108992.663005813
Csub_34_45 sn_34 sn_45 3.389034534434443e-18
Rsub_34_212 sn_34 sn_212 1754009.36253045
Csub_34_212 sn_34 sn_212 6.007085097327744e-18
Rsub_34_62 sn_34 sn_62 3381752.142133999
Csub_34_62 sn_34 sn_62 3.115687684781395e-18
Rsub_34_229 sn_34 sn_229 1293154.356583206
Csub_34_229 sn_34 sn_229 8.147893133244879e-18
Rsub_34_225 sn_34 sn_225 5107054.156544501
Csub_34_225 sn_34 sn_225 2.063123510982919e-18
Rsub_34_87 sn_34 sn_87 2724502.64625419
Csub_34_87 sn_34 sn_87 3.867305292111274e-18
Rsub_34_184 sn_34 sn_184 13719861.90355018
Csub_34_184 sn_34 sn_184 7.679729997503517e-19
Rsub_34_221 sn_34 sn_221 4430177.782878463
Csub_34_221 sn_34 sn_221 2.378343267159818e-18
Rsub_34_135 sn_34 sn_135 1077218.689550021
Csub_34_135 sn_34 sn_135 9.781192625455959e-18
Rsub_34_76 sn_34 sn_76 670006.4948902552
Csub_34_76 sn_34 sn_76 1.572594233426923e-17
Rsub_34_192 sn_34 sn_192 4973925.505592206
Csub_34_192 sn_34 sn_192 2.118343648368635e-18
Rsub_34_67 sn_34 sn_67 8694425.774538353
Csub_34_67 sn_34 sn_67 1.211866519475745e-18
Rsub_34_209 sn_34 sn_209 17891914.06848143
Csub_34_209 sn_34 sn_209 5.888963842494178e-19
Rsub_34_146 sn_34 sn_146 2543392.782999489
Csub_34_146 sn_34 sn_146 4.142688291268977e-18
Rsub_34_188 sn_34 sn_188 8212766.954231938
Csub_34_188 sn_34 sn_188 1.282939545338089e-18
Rsub_34_89 sn_34 sn_89 4739001.890343416
Csub_34_89 sn_34 sn_89 2.223354990362003e-18
Rsub_34_159 sn_34 sn_159 2185271.946448914
Csub_34_159 sn_34 sn_159 4.821589147909887e-18
Rsub_34_180 sn_34 sn_180 10335529.55863678
Csub_34_180 sn_34 sn_180 1.019443023451595e-18
Rsub_34_93 sn_34 sn_93 2144149.878240702
Csub_34_93 sn_34 sn_93 4.914061096734198e-18
Rsub_34_86 sn_34 sn_86 8757286.028705982
Csub_34_86 sn_34 sn_86 1.203167678626905e-18
Rsub_34_133 sn_34 sn_133 5753515.601022826
Csub_34_133 sn_34 sn_133 1.831312232881908e-18
Rsub_34_91 sn_34 sn_91 6408648.396469106
Csub_34_91 sn_34 sn_91 1.644103850046627e-18
Rsub_34_223 sn_34 sn_223 6863921.98426613
Csub_34_223 sn_34 sn_223 1.535052922568515e-18
Rsub_34_56 sn_34 sn_56 20237929.53461151
Csub_34_56 sn_34 sn_56 5.206305064068038e-19
Rsub_34_144 sn_34 sn_144 7344769.573331079
Csub_34_144 sn_34 sn_144 1.434556032974549e-18
Rsub_34_92 sn_34 sn_92 642451.5553199934
Csub_34_92 sn_34 sn_92 1.640043270964138e-17
Rsub_34_119 sn_34 sn_119 6796643.282692871
Csub_34_119 sn_34 sn_119 1.550248124550003e-18
Rsub_34_69 sn_34 sn_69 4319040.956049528
Csub_34_69 sn_34 sn_69 2.439542391343134e-18
Rsub_34_182 sn_34 sn_182 4614081.709963998
Csub_34_182 sn_34 sn_182 2.283549396075219e-18
Rsub_34_103 sn_34 sn_103 8064663.474103312
Csub_34_103 sn_34 sn_103 1.306500083489414e-18
Rsub_34_111 sn_34 sn_111 1470959.640836692
Csub_34_111 sn_34 sn_111 7.162999724612961e-18
Rsub_34_105 sn_34 sn_105 1725188.04615939
Csub_34_105 sn_34 sn_105 6.107440592164024e-18
Rsub_34_70 sn_34 sn_70 4646746.651372276
Csub_34_70 sn_34 sn_70 2.267496873133458e-18
Rsub_34_198 sn_34 sn_198 639500.8832725787
Csub_34_198 sn_34 sn_198 1.647610469013061e-17
Rsub_34_81 sn_34 sn_81 8180023.077764503
Csub_34_81 sn_34 sn_81 1.288075033782116e-18
Rsub_34_104 sn_34 sn_104 60907491.34948693
Csub_34_104 sn_34 sn_104 1.729915855797065e-19
Rsub_34_71 sn_34 sn_71 3933130.520392898
Csub_34_71 sn_34 sn_71 2.678905123437771e-18
Rsub_34_100 sn_34 sn_100 2999785.848955534
Csub_34_100 sn_34 sn_100 3.512411896302063e-18
Rsub_34_207 sn_34 sn_207 10806177.6326961
Csub_34_207 sn_34 sn_207 9.750425969632323e-19
Rsub_34_147 sn_34 sn_147 6347674.982276465
Csub_34_147 sn_34 sn_147 1.659896502522457e-18
Rsub_34_84 sn_34 sn_84 4244448.510222225
Csub_34_84 sn_34 sn_84 2.482415201139605e-18
Rsub_34_156 sn_34 sn_156 5472171.184192561
Csub_34_156 sn_34 sn_156 1.925466720168897e-18
Rsub_34_173 sn_34 sn_173 317907821.9293499
Csub_34_173 sn_34 sn_173 3.314320307781409e-20
Rsub_34_194 sn_34 sn_194 19403641.08465536
Csub_34_194 sn_34 sn_194 5.430157905034837e-19
Rsub_34_94 sn_34 sn_94 25759598.09204683
Csub_34_94 sn_34 sn_94 4.090313623908246e-19
Rsub_34_189 sn_34 sn_189 4619765.300624589
Csub_34_189 sn_34 sn_189 2.280739997940042e-18
Rsub_34_122 sn_34 sn_122 8678723.544450846
Csub_34_122 sn_34 sn_122 1.214059123817466e-18
Rsub_34_82 sn_34 sn_82 8442945.790104592
Csub_34_82 sn_34 sn_82 1.247962946129431e-18
Rsub_34_109 sn_34 sn_109 2047093.550855534
Csub_34_109 sn_34 sn_109 5.147045428298344e-18
Rsub_34_175 sn_34 sn_175 22256864.82137649
Csub_34_175 sn_34 sn_175 4.734037604483399e-19
Rsub_34_200 sn_34 sn_200 3079819.594792326
Csub_34_200 sn_34 sn_200 3.421136588664533e-18
Rsub_34_118 sn_34 sn_118 3516671.050532506
Csub_34_118 sn_34 sn_118 2.996152711137009e-18
Rsub_112_145 sn_112 sn_145 1968512.0477539
Csub_112_145 sn_112 sn_145 5.352511565398991e-18
Rsub_112_149 sn_112 sn_149 767543.0513050316
Csub_112_149 sn_112 sn_149 1.372754724873754e-17
Rsub_112_136 sn_112 sn_136 4799205.845791027
Csub_112_136 sn_112 sn_136 2.195463966495759e-18
Rsub_112_175 sn_112 sn_175 1176474.251698066
Csub_112_175 sn_112 sn_175 8.955983088471464e-18
Rsub_112_114 sn_112 sn_114 4824072.197323623
Csub_112_114 sn_112 sn_114 2.184147141926193e-18
Rsub_112_171 sn_112 sn_171 14225191.06523247
Csub_112_171 sn_112 sn_171 7.406918792101169e-19
Rsub_112_162 sn_112 sn_162 4132116.058933066
Csub_112_162 sn_112 sn_162 2.54990018478585e-18
Rsub_112_166 sn_112 sn_166 1983780.659947094
Csub_112_166 sn_112 sn_166 5.311314761235248e-18
Rsub_112_185 sn_112 sn_185 936724.4417517061
Csub_112_185 sn_112 sn_185 1.124822096296156e-17
Rsub_112_199 sn_112 sn_199 27778691.66521562
Csub_112_199 sn_112 sn_199 3.793009270995923e-19
Rsub_112_163 sn_112 sn_163 5982104.042304591
Csub_112_163 sn_112 sn_163 1.761334043627039e-18
Rsub_112_133 sn_112 sn_133 18701396.84491386
Csub_112_133 sn_112 sn_133 5.634062305402374e-19
Rsub_112_206 sn_112 sn_206 7753521.65089587
Csub_112_206 sn_112 sn_206 1.358928752202888e-18
Rsub_112_230 sn_112 0 42166.12139275838
Csub_112_230 sn_112 0 2.498803104057738e-16
Rsub_112_216 sn_112 sn_216 511800.5818727253
Csub_112_216 sn_112 sn_216 2.058708777484394e-17
Rsub_112_137 sn_112 sn_137 2856057.213896343
Csub_112_137 sn_112 sn_137 3.68917101904122e-18
Rsub_112_219 sn_112 sn_219 113434.2325387806
Csub_112_219 sn_112 sn_219 9.288627662401488e-17
Rsub_112_140 sn_112 sn_140 708704.9239038927
Csub_112_140 sn_112 sn_140 1.486723620345391e-17
Rsub_112_192 sn_112 sn_192 2154044.089655771
Csub_112_192 sn_112 sn_192 4.891489247053338e-18
Rsub_112_228 sn_112 sn_228 24044.17872602501
Csub_112_228 sn_112 sn_228 4.382134911859349e-16
Rsub_112_150 sn_112 sn_150 104907.7921320453
Csub_112_150 sn_112 sn_150 1.004356615280583e-16
Rsub_112_229 sn_112 sn_229 587473.9982966898
Csub_112_229 sn_112 sn_229 1.793523378528968e-17
Rsub_112_222 sn_112 sn_222 188788.5895753352
Csub_112_222 sn_112 sn_222 5.581101869520279e-17
Rsub_112_198 sn_112 sn_198 424313.1981885107
Csub_112_198 sn_112 sn_198 2.483185426994173e-17
Rsub_112_161 sn_112 sn_161 3307803.189816318
Csub_112_161 sn_112 sn_161 3.18534172004807e-18
Rsub_112_130 sn_112 sn_130 849231.0901392008
Csub_112_130 sn_112 sn_130 1.240708639211846e-17
Rsub_112_209 sn_112 sn_209 5644661.797899291
Csub_112_209 sn_112 sn_209 1.86662795389287e-18
Rsub_112_180 sn_112 sn_180 60387.17943964068
Csub_112_180 sn_112 sn_180 1.744821268355748e-16
Rsub_112_191 sn_112 sn_191 1494017.105034302
Csub_112_191 sn_112 sn_191 7.052451720081272e-18
Rsub_112_123 sn_112 sn_123 21597134.61901443
Csub_112_123 sn_112 sn_123 4.878648806010372e-19
Rsub_112_202 sn_112 sn_202 5624794.354109805
Csub_112_202 sn_112 sn_202 1.873221106213675e-18
Rsub_112_135 sn_112 sn_135 146483.9068943131
Csub_112_135 sn_112 sn_135 7.192929056590485e-17
Rsub_112_214 sn_112 sn_214 11637452.51725493
Csub_112_214 sn_112 sn_214 9.05394328063422e-19
Rsub_112_177 sn_112 sn_177 143009.4813821854
Csub_112_177 sn_112 sn_177 7.367681779134487e-17
Rsub_112_126 sn_112 sn_126 4766.02324191697
Csub_112_126 sn_112 sn_126 2.210749500665897e-15
Rsub_112_205 sn_112 sn_205 2753758.942695767
Csub_112_205 sn_112 sn_205 3.826218533099127e-18
Rsub_112_190 sn_112 sn_190 541684.305265056
Csub_112_190 sn_112 sn_190 1.945133613770535e-17
Rsub_112_227 sn_112 sn_227 1000909.810995105
Csub_112_227 sn_112 sn_227 1.052690600740003e-17
Rsub_112_153 sn_112 sn_153 28365.57026193097
Csub_112_153 sn_112 sn_153 3.714532584726797e-16
Rsub_112_176 sn_112 sn_176 73720.02906966329
Csub_112_176 sn_112 sn_176 1.429256558251399e-16
Rsub_112_139 sn_112 sn_139 60538.33645067829
Csub_112_139 sn_112 sn_139 1.740464657599944e-16
Rsub_112_218 sn_112 sn_218 4761117.601649796
Csub_112_218 sn_112 sn_218 2.213027356975799e-18
Rsub_112_159 sn_112 sn_159 1100820.350697254
Csub_112_159 sn_112 sn_159 9.571483208460173e-18
Rsub_112_210 sn_112 sn_210 90978.53696573747
Csub_112_210 sn_112 sn_210 1.158128483226549e-16
Rsub_112_131 sn_112 sn_131 250402.1854313971
Csub_112_131 sn_112 sn_131 4.207824098690502e-17
Rsub_112_128 sn_112 sn_128 175143.7922265513
Csub_112_128 sn_112 sn_128 6.015904628010388e-17
Rsub_112_165 sn_112 sn_165 467539.4158974581
Csub_112_165 sn_112 sn_165 2.253603256530758e-17
Rsub_112_195 sn_112 sn_195 20617.20229964881
Csub_112_195 sn_112 sn_195 5.11053020147621e-16
Rsub_112_138 sn_112 sn_138 1188348.069606493
Csub_112_138 sn_112 sn_138 8.866496081168402e-18
Rsub_112_181 sn_112 sn_181 17953.28130631295
Csub_112_181 sn_112 sn_181 5.868834405510616e-16
Rsub_112_168 sn_112 sn_168 229382.2046921803
Csub_112_168 sn_112 sn_168 4.593418010071638e-17
Rsub_112_129 sn_112 sn_129 5863358.759209896
Csub_112_129 sn_112 sn_129 1.79700474334438e-18
Rsub_112_182 sn_112 sn_182 9675206.688711477
Csub_112_182 sn_112 sn_182 1.089018957550893e-18
Rsub_112_141 sn_112 sn_141 399125.435495824
Csub_112_141 sn_112 sn_141 2.63989276682925e-17
Rsub_112_179 sn_112 sn_179 2765851.94356283
Csub_112_179 sn_112 sn_179 3.809489342606473e-18
Rsub_112_200 sn_112 sn_200 760486.348992606
Csub_112_200 sn_112 sn_200 1.385492785792588e-17
Rsub_112_186 sn_112 sn_186 5999217.126975846
Csub_112_186 sn_112 sn_186 1.756309744958564e-18
Rsub_112_188 sn_112 sn_188 44924391.25719272
Csub_112_188 sn_112 sn_188 2.345381474822551e-19
Rsub_112_204 sn_112 sn_204 6900064.655806529
Csub_112_204 sn_112 sn_204 1.527012285799867e-18
Rsub_112_125 sn_112 sn_125 1464850.454186841
Csub_112_125 sn_112 sn_125 7.192873151054145e-18
Rsub_112_189 sn_112 sn_189 848942.3733380532
Csub_112_189 sn_112 sn_189 1.241130591797462e-17
Rsub_112_184 sn_112 sn_184 6815627.567409771
Csub_112_184 sn_112 sn_184 1.54593005530587e-18
Rsub_112_118 sn_112 sn_118 1569815.022150276
Csub_112_118 sn_112 sn_118 6.711926789818529e-18
Rsub_112_197 sn_112 sn_197 35963073.06762896
Csub_112_197 sn_112 sn_197 2.929806216063912e-19
Rsub_112_169 sn_112 sn_169 274708.8709354726
Csub_112_169 sn_112 sn_169 3.835509012268103e-17
Rsub_112_226 sn_112 sn_226 1386495.385273566
Csub_112_226 sn_112 sn_226 7.599364277834272e-18
Rsub_112_155 sn_112 sn_155 472298.5079753739
Csub_112_155 sn_112 sn_155 2.230894937059463e-17
Rsub_112_146 sn_112 sn_146 12438742.91526855
Csub_112_146 sn_112 sn_146 8.470698023106879e-19
Rsub_112_225 sn_112 sn_225 3612551.822345206
Csub_112_225 sn_112 sn_225 2.916631793918433e-18
Rsub_112_160 sn_112 sn_160 4452220.600483429
Csub_112_160 sn_112 sn_160 2.366568157266496e-18
Rsub_112_215 sn_112 sn_215 913127.6205367633
Csub_112_215 sn_112 sn_215 1.153889474511388e-17
Rsub_112_221 sn_112 sn_221 5832311.142265971
Csub_112_221 sn_112 sn_221 1.806570885060217e-18
Rsub_112_142 sn_112 sn_142 5420864.634105926
Csub_112_142 sn_112 sn_142 1.943690575842575e-18
Rsub_112_132 sn_112 sn_132 397212.0996805608
Csub_112_132 sn_112 sn_132 2.652608898546514e-17
Rsub_112_211 sn_112 sn_211 3671345.890140884
Csub_112_211 sn_112 sn_211 2.869923950920809e-18
Rsub_112_201 sn_112 sn_201 28056599.38117308
Csub_112_201 sn_112 sn_201 3.755438554431631e-19
Rsub_112_154 sn_112 sn_154 1420260.307441722
Csub_112_154 sn_112 sn_154 7.41869884486816e-18
Rsub_112_152 sn_112 sn_152 2579516.244550027
Csub_112_152 sn_112 sn_152 4.084674219242217e-18
Rsub_112_134 sn_112 sn_134 3396534.907985054
Csub_112_134 sn_112 sn_134 3.102127252530026e-18
Rsub_112_213 sn_112 sn_213 4488277.117722807
Csub_112_213 sn_112 sn_213 2.347556362022459e-18
Rsub_112_203 sn_112 sn_203 5072735.712649583
Csub_112_203 sn_112 sn_203 2.077081105557262e-18
Rsub_112_223 sn_112 sn_223 4048792.956942039
Csub_112_223 sn_112 sn_223 2.602376464858299e-18
Rsub_112_193 sn_112 sn_193 23634241.33917939
Csub_112_193 sn_112 sn_193 4.45814331461669e-19
Rsub_109_168 sn_109 sn_168 20894329.22942923
Csub_109_168 sn_109 sn_168 5.042747908551944e-19
Rsub_109_172 sn_109 sn_172 5399099.398367983
Csub_109_172 sn_109 sn_172 1.951526120340538e-18
Rsub_109_157 sn_109 sn_157 207331.5493353804
Csub_109_157 sn_109 sn_157 5.081948953743716e-17
Rsub_109_163 sn_109 sn_163 3011588.66528133
Csub_109_163 sn_109 sn_163 3.498646287156792e-18
Rsub_109_132 sn_109 sn_132 1471702.756862975
Csub_109_132 sn_109 sn_132 7.159382866611711e-18
Rsub_109_117 sn_109 sn_117 125497.0270007733
Csub_109_117 sn_109 sn_117 8.395803274419461e-17
Rsub_109_124 sn_109 sn_124 7233190.818695405
Csub_109_124 sn_109 sn_124 1.456685405699056e-18
Rsub_109_229 sn_109 sn_229 230556.185853682
Csub_109_229 sn_109 sn_229 4.570028543461755e-17
Rsub_109_200 sn_109 sn_200 315815.4218884388
Csub_109_200 sn_109 sn_200 3.336278969287318e-17
Rsub_109_121 sn_109 sn_121 179045.4808160566
Csub_109_121 sn_109 sn_121 5.884808404103042e-17
Rsub_109_223 sn_109 sn_223 56042.85864296387
Csub_109_223 sn_109 sn_223 1.880076027055563e-16
Rsub_109_119 sn_109 sn_119 278648.2625460157
Csub_109_119 sn_109 sn_119 3.78128447884724e-17
Rsub_109_151 sn_109 sn_151 522593.4963916253
Csub_109_151 sn_109 sn_151 2.016191088289796e-17
Rsub_109_230 sn_109 0 62077.60069946708
Csub_109_230 sn_109 0 1.697308430659186e-16
Rsub_109_193 sn_109 sn_193 399820.6428750252
Csub_109_193 sn_109 sn_193 2.635302526268876e-17
Rsub_109_111 sn_109 sn_111 7868.865865798203
Csub_109_111 sn_109 sn_111 1.339009163700009e-15
Rsub_109_222 sn_109 sn_222 277136.4376214154
Csub_109_222 sn_109 sn_222 3.801912008634336e-17
Rsub_109_217 sn_109 sn_217 218810.424882221
Csub_109_217 sn_109 sn_217 4.815348038331111e-17
Rsub_109_189 sn_109 sn_189 1623851.029843524
Csub_109_189 sn_109 sn_189 6.488577651883071e-18
Rsub_109_177 sn_109 sn_177 920954.706047765
Csub_109_177 sn_109 sn_177 1.144082703854877e-17
Rsub_109_220 sn_109 sn_220 352940.3109517898
Csub_109_220 sn_109 sn_220 2.985344313268099e-17
Rsub_109_154 sn_109 sn_154 332622.7189909419
Csub_109_154 sn_109 sn_154 3.16769808574529e-17
Rsub_109_191 sn_109 sn_191 802500.7531727777
Csub_109_191 sn_109 sn_191 1.31295621350794e-17
Rsub_109_205 sn_109 sn_205 1990.158882339117
Csub_109_205 sn_109 sn_205 5.29429262946385e-15
Rsub_109_187 sn_109 sn_187 79271.77657316157
Csub_109_187 sn_109 sn_187 1.329159501364986e-16
Rsub_109_145 sn_109 sn_145 144960.4116665647
Csub_109_145 sn_109 sn_145 7.268524820739215e-17
Rsub_109_224 sn_109 sn_224 750331.8376658629
Csub_109_224 sn_109 sn_224 1.404243159267634e-17
Rsub_109_210 sn_109 sn_210 14209543.87263546
Csub_109_210 sn_109 sn_210 7.41507510492368e-19
Rsub_109_202 sn_109 sn_202 279531.9854106497
Csub_109_202 sn_109 sn_202 3.769330184791288e-17
Rsub_109_179 sn_109 sn_179 1314020.318627656
Csub_109_179 sn_109 sn_179 8.018508810605117e-18
Rsub_109_204 sn_109 sn_204 2020892.366573015
Csub_109_204 sn_109 sn_204 5.213777673918151e-18
Rsub_109_209 sn_109 sn_209 80835.92304738582
Csub_109_209 sn_109 sn_209 1.303440735878471e-16
Rsub_109_130 sn_109 sn_130 1366581.131372762
Csub_109_130 sn_109 sn_130 7.710104625581843e-18
Rsub_109_139 sn_109 sn_139 2233387.951465051
Csub_109_139 sn_109 sn_139 4.717713058010505e-18
Rsub_109_115 sn_109 sn_115 110093.2836125922
Csub_109_115 sn_109 sn_115 9.570505262888592e-17
Rsub_109_194 sn_109 sn_194 223449.8502042092
Csub_109_194 sn_109 sn_194 4.71536834444095e-17
Rsub_109_213 sn_109 sn_213 1879561.892465587
Csub_109_213 sn_109 sn_213 5.605818858355531e-18
Rsub_109_134 sn_109 sn_134 1116693.975732525
Csub_109_134 sn_109 sn_134 9.43542611602101e-18
Rsub_109_175 sn_109 sn_175 1170672.33331377
Csub_109_175 sn_109 sn_175 9.000369447875178e-18
Rsub_109_201 sn_109 sn_201 1563684.17916691
Csub_109_201 sn_109 sn_201 6.738242697987494e-18
Rsub_109_215 sn_109 sn_215 5477359.310846639
Csub_109_215 sn_109 sn_215 1.923642927964383e-18
Rsub_94_177 sn_94 sn_177 745649.0529918411
Csub_94_177 sn_94 sn_177 1.41306201086871e-17
Rsub_94_219 sn_94 sn_219 6914081.084466254
Csub_94_219 sn_94 sn_219 1.523916681553263e-18
Rsub_94_157 sn_94 sn_157 803530.666366947
Csub_94_157 sn_94 sn_157 1.311273351877068e-17
Rsub_94_119 sn_94 sn_119 2332166.676952661
Csub_94_119 sn_94 sn_119 4.517894714110897e-18
Rsub_94_163 sn_94 sn_163 3785062.032123481
Csub_94_163 sn_94 sn_163 2.78370167062199e-18
Rsub_94_225 sn_94 sn_225 325995.0744178634
Csub_94_225 sn_94 sn_225 3.232098988319143e-17
Rsub_94_176 sn_94 sn_176 4981597.034826862
Csub_94_176 sn_94 sn_176 2.115081454515159e-18
Rsub_94_97 sn_94 sn_97 11441589.7396346
Csub_94_97 sn_94 sn_97 9.208933148276378e-19
Rsub_94_211 sn_94 sn_211 68582798.48731197
Csub_94_211 sn_94 sn_211 1.536315772267485e-19
Rsub_94_152 sn_94 sn_152 1011748.867685389
Csub_94_152 sn_94 sn_152 1.041412927531578e-17
Rsub_94_187 sn_94 sn_187 88137.55488706175
Csub_94_187 sn_94 sn_187 1.195459020360992e-16
Rsub_94_145 sn_94 sn_145 1760557.300221485
Csub_94_145 sn_94 sn_145 5.984743297423193e-18
Rsub_94_106 sn_94 sn_106 51363.98892995113
Csub_94_106 sn_94 sn_106 2.05133668971843e-16
Rsub_94_114 sn_94 sn_114 7183267.968207201
Csub_94_114 sn_94 sn_114 1.466809194486962e-18
Rsub_94_229 sn_94 sn_229 57145.97473930876
Csub_94_229 sn_94 sn_229 1.843784019836189e-16
Rsub_94_139 sn_94 sn_139 11763723.09109945
Csub_94_139 sn_94 sn_139 8.956759199986618e-19
Rsub_94_213 sn_94 sn_213 27880931.93359715
Csub_94_213 sn_94 sn_213 3.779100184787331e-19
Rsub_94_188 sn_94 sn_188 9273793.137754519
Csub_94_188 sn_94 sn_188 1.136156839571388e-18
Rsub_94_109 sn_94 sn_109 101841.2144567069
Csub_94_109 sn_94 sn_109 1.034599160903478e-16
Rsub_94_220 sn_94 sn_220 708795.7961930652
Csub_94_220 sn_94 sn_220 1.486533012585761e-17
Rsub_94_121 sn_94 sn_121 16442.77169424517
Csub_94_121 sn_94 sn_121 6.407972875958426e-16
Rsub_94_195 sn_94 sn_195 4312064.087406037
Csub_94_195 sn_94 sn_195 2.443489542050921e-18
Rsub_94_223 sn_94 sn_223 5843.986141066396
Csub_94_223 sn_94 sn_223 1.802961753825674e-15
Rsub_94_230 sn_94 0 35205.38337987764
Csub_94_230 sn_94 0 2.992861457731589e-16
Rsub_94_205 sn_94 sn_205 334485.5790339772
Csub_94_205 sn_94 sn_205 3.150056134754826e-17
Rsub_94_202 sn_94 sn_202 498951.7906473365
Csub_94_202 sn_94 sn_202 2.111723757631984e-17
Rsub_94_179 sn_94 sn_179 857414.21946789
Csub_94_179 sn_94 sn_179 1.228867362238164e-17
Rsub_94_100 sn_94 sn_100 3822.240821609646
Csub_94_100 sn_94 sn_100 2.756624711520089e-15
Rsub_94_172 sn_94 sn_172 379269.3501008665
Csub_94_172 sn_94 sn_172 2.778100444823138e-17
Rsub_94_115 sn_94 sn_115 536064.5306143542
Csub_94_115 sn_94 sn_115 1.965525212077493e-17
Rsub_94_199 sn_94 sn_199 33763125.91611892
Csub_94_199 sn_94 sn_199 3.120707344576693e-19
Rsub_94_111 sn_94 sn_111 92534.67032511786
Csub_94_111 sn_94 sn_111 1.138652514264154e-16
Rsub_94_148 sn_94 sn_148 28638191.82312562
Csub_94_148 sn_94 sn_148 3.679172053635623e-19
Rsub_94_206 sn_94 sn_206 7972458.664548786
Csub_94_206 sn_94 sn_206 1.321610301861167e-18
Rsub_94_169 sn_94 sn_169 1920607.851608074
Csub_94_169 sn_94 sn_169 5.486015009991802e-18
Rsub_94_122 sn_94 sn_122 1043900.02953709
Csub_94_122 sn_94 sn_122 1.009338366136682e-17
Rsub_94_175 sn_94 sn_175 3512016.999941309
Csub_94_175 sn_94 sn_175 3.000123149291726e-18
Rsub_94_209 sn_94 sn_209 1406159.443223762
Csub_94_209 sn_94 sn_209 7.493093015166229e-18
Rsub_94_130 sn_94 sn_130 880278.6501107424
Csub_94_130 sn_94 sn_130 1.196948659484639e-17
Rsub_108_115 sn_108 sn_115 697790.1299414715
Csub_108_115 sn_108 sn_115 1.509978867587848e-17
Rsub_108_121 sn_108 sn_121 19407785.85925229
Csub_108_121 sn_108 sn_121 5.428998227124882e-19
Rsub_108_205 sn_108 sn_205 22506516.39543274
Csub_108_205 sn_108 sn_205 4.681525704425842e-19
Rsub_108_119 sn_108 sn_119 2097467.319282068
Csub_108_119 sn_108 sn_119 5.02343154783288e-18
Rsub_108_230 sn_108 0 48585.16196406307
Csub_108_230 sn_108 0 2.168662833731728e-16
Rsub_108_193 sn_108 sn_193 6306107.361434552
Csub_108_193 sn_108 sn_193 1.670837950946826e-18
Rsub_108_113 sn_108 sn_113 31865.36545385535
Csub_108_113 sn_108 sn_113 3.30656289427718e-16
Rsub_108_167 sn_108 sn_167 155363.7385608643
Csub_108_167 sn_108 sn_167 6.781816400551085e-17
Rsub_108_202 sn_108 sn_202 161382.1694672475
Csub_108_202 sn_108 sn_202 6.528901883654737e-17
Rsub_108_128 sn_108 sn_128 548263.6229988242
Csub_108_128 sn_108 sn_128 1.921791463128422e-17
Rsub_108_179 sn_108 sn_179 39107.07279363945
Csub_108_179 sn_108 sn_179 2.694265448561954e-16
Rsub_108_111 sn_108 sn_111 23770.68492733383
Csub_108_111 sn_108 sn_111 4.43255359887175e-16
Rsub_108_187 sn_108 sn_187 3723079.402870832
Csub_108_187 sn_108 sn_187 2.830045336692367e-18
Rsub_108_145 sn_108 sn_145 581491.7213623892
Csub_108_145 sn_108 sn_145 1.811974808092513e-17
Rsub_108_143 sn_108 sn_143 1264325.772032203
Csub_108_143 sn_108 sn_143 8.333677708154504e-18
Rsub_108_172 sn_108 sn_172 3743803.210748598
Csub_108_172 sn_108 sn_172 2.814379631915312e-18
Rsub_108_209 sn_108 sn_209 504286.044062843
Csub_108_209 sn_108 sn_209 2.08938629697969e-17
Rsub_108_175 sn_108 sn_175 103854.1821542278
Csub_108_175 sn_108 sn_175 1.01454590308004e-16
Rsub_108_177 sn_108 sn_177 19812710.92101967
Csub_108_177 sn_108 sn_177 5.318042313458302e-19
Rsub_108_132 sn_108 sn_132 25253357.08359611
Csub_108_132 sn_108 sn_132 4.172310028861157e-19
Rsub_108_169 sn_108 sn_169 127992.4112571699
Csub_108_169 sn_108 sn_169 8.232115794005537e-17
Rsub_108_181 sn_108 sn_181 25253357.08359611
Csub_108_181 sn_108 sn_181 4.172310028861157e-19
Rsub_108_112 sn_108 sn_112 5371131.931040734
Csub_108_112 sn_108 sn_112 1.961687710804081e-18
Rsub_108_223 sn_108 sn_223 755307.6694358516
Csub_108_223 sn_108 sn_223 1.394992256612438e-17
Rsub_108_149 sn_108 sn_149 1162983.442724778
Csub_108_149 sn_108 sn_149 9.059874040462566e-18
Rsub_108_206 sn_108 sn_206 10105870.27538285
Csub_108_206 sn_108 sn_206 1.042610207247177e-18
Rsub_108_127 sn_108 sn_127 830702.535644609
Csub_108_127 sn_108 sn_127 1.268382248773792e-17
Rsub_108_122 sn_108 sn_122 698070.7165867275
Csub_108_122 sn_108 sn_122 1.509371937810109e-17
Rsub_108_226 sn_108 sn_226 1232955.20804074
Csub_108_226 sn_108 sn_226 8.545714745771893e-18
Rsub_108_152 sn_108 sn_152 2325966.885449557
Csub_108_152 sn_108 sn_152 4.529937020231283e-18
Rsub_121_155 sn_121 sn_155 634296.9889147643
Csub_121_155 sn_121 sn_155 1.661127781838781e-17
Rsub_121_156 sn_121 sn_156 14088714.41793618
Csub_121_156 sn_121 sn_156 7.478669231037948e-19
Rsub_121_186 sn_121 sn_186 11151032.2773884
Csub_121_186 sn_121 sn_186 9.44888620185904e-19
Rsub_121_227 sn_121 sn_227 13581230.7081992
Csub_121_227 sn_121 sn_227 7.758121284155023e-19
Rsub_121_195 sn_121 sn_195 6790615.3540996
Csub_121_195 sn_121 sn_195 1.551624256831005e-18
Rsub_121_198 sn_121 sn_198 10838719.3166051
Csub_121_198 sn_121 sn_198 9.72115172877291e-19
Rsub_121_169 sn_121 sn_169 5394435.322837479
Csub_121_169 sn_121 sn_169 1.953213426736907e-18
Rsub_121_161 sn_121 sn_161 25470849.05060846
Csub_121_161 sn_121 sn_161 4.136683265365392e-19
Rsub_121_159 sn_121 sn_159 4905884.248328154
Csub_121_159 sn_121 sn_159 2.147723625118278e-18
Rsub_121_219 sn_121 sn_219 11445853.79863435
Csub_121_219 sn_121 sn_219 9.205502435726685e-19
Rsub_121_215 sn_121 sn_215 13750391.94477819
Csub_121_215 sn_121 sn_215 7.662678667302502e-19
Rsub_121_136 sn_121 sn_136 6468634.982425451
Csub_121_136 sn_121 sn_136 1.628857329383469e-18
Rsub_121_170 sn_121 sn_170 5070813.366435914
Csub_121_170 sn_121 sn_170 2.077868527359291e-18
Rsub_121_131 sn_121 sn_131 4842251.866873226
Csub_121_131 sn_121 sn_131 2.175947016368997e-18
Rsub_121_210 sn_121 sn_210 12735424.52530423
Csub_121_210 sn_121 sn_210 8.273366530730785e-19
Rsub_121_152 sn_121 sn_152 6684415.424886464
Csub_121_152 sn_121 sn_152 1.576275984134987e-18
Rsub_121_204 sn_121 sn_204 12735424.52530423
Csub_121_204 sn_121 sn_204 8.273366530730785e-19
Rsub_121_160 sn_121 sn_160 3498945.384267204
Csub_121_160 sn_121 sn_160 3.011331228434334e-18
Rsub_121_220 sn_121 sn_220 6776705.888868472
Csub_121_220 sn_121 sn_220 1.554809028902582e-18
Rsub_121_209 sn_121 sn_209 1356989.423644166
Csub_121_209 sn_121 sn_209 7.764602522792329e-18
Rsub_121_130 sn_121 sn_130 1357922.54116727
Csub_121_130 sn_121 sn_130 7.759266955810928e-18
Rsub_121_167 sn_121 sn_167 6812638.878821384
Csub_121_167 sn_121 sn_167 1.546608251170486e-18
Rsub_121_139 sn_121 sn_139 3427879.977974373
Csub_121_139 sn_121 sn_139 3.073760916348155e-18
Rsub_121_128 sn_121 sn_128 1396982.795204581
Csub_121_128 sn_121 sn_128 7.542314435366387e-18
Rsub_121_202 sn_121 sn_202 2560408.865389953
Csub_121_202 sn_121 sn_202 4.115156623871977e-18
Rsub_121_187 sn_121 sn_187 2242468.234976808
Csub_121_187 sn_121 sn_187 4.698609923604547e-18
Rsub_121_224 sn_121 sn_224 6720458.867995513
Csub_121_224 sn_121 sn_224 1.567822035546909e-18
Rsub_121_194 sn_121 sn_194 118344.8595961383
Csub_121_194 sn_121 sn_194 8.9032033484062e-17
Rsub_121_157 sn_121 sn_157 1687798.149326074
Csub_121_157 sn_121 sn_157 6.242739101495725e-18
Rsub_121_230 sn_121 0 83710.53824847811
Csub_121_230 sn_121 0 1.258680653916541e-16
Rsub_121_151 sn_121 sn_151 2104010.46394944
Csub_121_151 sn_121 sn_151 5.007809458538509e-18
Rsub_121_225 sn_121 sn_225 177154.0863947809
Csub_121_225 sn_121 sn_225 5.947637853947021e-17
Rsub_121_150 sn_121 sn_150 3927622.4194814
Csub_121_150 sn_121 sn_150 2.682662022186243e-18
Rsub_121_229 sn_121 sn_229 123934.4543531564
Csub_121_229 sn_121 sn_229 8.501658039503567e-17
Rsub_121_192 sn_121 sn_192 8221359.624617566
Csub_121_192 sn_121 sn_192 1.281598662912174e-18
Rsub_121_158 sn_121 sn_158 13464563.31363561
Csub_121_158 sn_121 sn_158 7.825343649696883e-19
Rsub_121_217 sn_121 sn_217 108015.2469986224
Csub_121_217 sn_121 sn_217 9.754626124554785e-17
Rsub_121_138 sn_121 sn_138 12856253.98000351
Csub_121_138 sn_121 sn_138 8.195609326494591e-19
Rsub_121_223 sn_121 sn_223 12805.36158834203
Csub_121_223 sn_121 sn_223 8.22818116422608e-16
Rsub_121_172 sn_121 sn_172 182305.5876856838
Csub_121_172 sn_121 sn_172 5.779572439872845e-17
Rsub_121_205 sn_121 sn_205 9325417.301351938
Csub_121_205 sn_121 sn_205 1.129867239367668e-18
Rsub_121_177 sn_121 sn_177 552514.3622471446
Csub_121_177 sn_121 sn_177 1.907006264846549e-17
Rsub_121_199 sn_121 sn_199 28569453.31959732
Csub_121_199 sn_121 sn_199 3.68802419295943e-19
Rsub_121_185 sn_121 sn_185 13871221.39947747
Csub_121_185 sn_121 sn_185 7.595930595287671e-19
Rsub_121_222 sn_121 sn_222 3274509.856168853
Csub_121_222 sn_121 sn_222 3.217728443351699e-18
Rsub_121_124 sn_121 sn_124 1068650.603521145
Csub_121_124 sn_121 sn_124 9.859614983150587e-18
Rsub_121_189 sn_121 sn_189 6067139.360972038
Csub_121_189 sn_121 sn_189 1.736647681114401e-18
Rsub_121_153 sn_121 sn_153 3187383.14757518
Csub_121_153 sn_121 sn_153 3.305684636704468e-18
Rsub_121_181 sn_121 sn_181 13387903.58068035
Csub_121_181 sn_121 sn_181 7.870151916417189e-19
Rsub_121_163 sn_121 sn_163 8020444.966770911
Csub_121_163 sn_121 sn_163 1.313703110723053e-18
Rsub_121_179 sn_121 sn_179 16040889.93354182
Csub_121_179 sn_121 sn_179 6.568515553615267e-19
Rsub_121_127 sn_121 sn_127 5462974.040658297
Csub_121_127 sn_121 sn_127 1.928708323307415e-18
Rsub_121_206 sn_121 sn_206 9708365.572672037
Csub_121_206 sn_121 sn_206 1.0852994176372e-18
Rsub_49_186 sn_49 sn_186 9430016.488217309
Csub_49_186 sn_49 sn_186 1.117334578936867e-18
Rsub_49_104 sn_49 sn_104 115706285.8200316
Csub_49_104 sn_49 sn_104 9.106232584993992e-20
Rsub_49_171 sn_49 sn_171 37888284.88624676
Csub_49_171 sn_49 sn_171 2.780934405942109e-19
Rsub_49_136 sn_49 sn_136 9971294.504538123
Csub_49_136 sn_49 sn_136 1.056681607130814e-18
Rsub_49_189 sn_49 sn_189 32749651.73093362
Csub_49_189 sn_49 sn_189 3.217281084023799e-19
Rsub_49_223 sn_49 sn_223 44693084.87722979
Csub_49_223 sn_49 sn_223 2.357519855962801e-19
Rsub_49_78 sn_49 sn_78 13093962.59523435
Csub_49_78 sn_49 sn_78 8.046825722615735e-19
Rsub_49_84 sn_49 sn_84 10080543.58093751
Csub_49_84 sn_49 sn_84 1.045229695961504e-18
Rsub_49_194 sn_49 sn_194 54131595.70527794
Csub_49_194 sn_49 sn_194 1.946457215042466e-19
Rsub_49_111 sn_49 sn_111 12157619.24137964
Csub_49_111 sn_49 sn_111 8.666568094490128e-19
Rsub_49_165 sn_49 sn_165 37285975.48024008
Csub_49_165 sn_49 sn_165 2.825857005622362e-19
Rsub_49_159 sn_49 sn_159 31784960.02873537
Csub_49_159 sn_49 sn_159 3.314927403622479e-19
Rsub_49_208 sn_49 sn_208 14998969.45318717
Csub_49_208 sn_49 sn_208 7.02480496084421e-19
Rsub_49_162 sn_49 sn_162 14519327.95440593
Csub_49_162 sn_49 sn_162 7.256867215422787e-19
Rsub_49_65 sn_49 sn_65 35518306.58985376
Csub_49_65 sn_49 sn_65 2.966493764440863e-19
Rsub_49_118 sn_49 sn_118 43857984.66900753
Csub_49_118 sn_49 sn_118 2.402409408856321e-19
Rsub_49_50 sn_49 sn_50 11734799.77180951
Csub_49_50 sn_49 sn_50 8.978835350511712e-19
Rsub_49_175 sn_49 sn_175 13130368.01997605
Csub_49_175 sn_49 sn_175 8.024514991659173e-19
Rsub_49_154 sn_49 sn_154 14979398.41761993
Csub_49_154 sn_49 sn_154 7.033983080279228e-19
Rsub_49_228 sn_49 sn_228 12037846.35274714
Csub_49_228 sn_49 sn_228 8.752797795783036e-19
Rsub_49_61 sn_49 sn_61 4702002.51503568
Csub_49_61 sn_49 sn_61 2.240850248067136e-18
Rsub_49_103 sn_49 sn_103 10934700.8349528
Csub_49_103 sn_49 sn_103 9.635822379840613e-19
Rsub_49_169 sn_49 sn_169 26955664.86468246
Csub_49_169 sn_49 sn_169 3.908819743502225e-19
Rsub_49_105 sn_49 sn_105 21480369.12036101
Csub_49_105 sn_49 sn_105 4.905168734853156e-19
Rsub_49_185 sn_49 sn_185 20717208.31020076
Csub_49_185 sn_49 sn_185 5.085860674115073e-19
Rsub_49_207 sn_49 sn_207 1381411.574569653
Csub_49_207 sn_49 sn_207 7.627331127229337e-18
Rsub_49_57 sn_49 sn_57 59907243.63990359
Csub_49_57 sn_49 sn_57 1.758799581159791e-19
Rsub_49_224 sn_49 sn_224 6007955.516042765
Csub_49_224 sn_49 sn_224 1.753755245706283e-18
Rsub_49_168 sn_49 sn_168 66948596.06184688
Csub_49_168 sn_49 sn_168 1.573816946437e-19
Rsub_49_86 sn_49 sn_86 10002358.53970292
Csub_49_86 sn_49 sn_86 1.053399901673885e-18
Rsub_49_135 sn_49 sn_135 11376414.98007768
Csub_49_135 sn_49 sn_135 9.261690541951431e-19
Rsub_49_229 sn_49 sn_229 7386545.632402007
Csub_49_229 sn_49 sn_229 1.426442619674669e-18
Rsub_49_62 sn_49 sn_62 11283072.72430262
Csub_49_62 sn_49 sn_62 9.33831036959946e-19
Rsub_49_202 sn_49 sn_202 55925815.56245553
Csub_49_202 sn_49 sn_202 1.884010701723842e-19
Rsub_49_95 sn_49 sn_95 23317464.86243624
Csub_49_95 sn_49 sn_95 4.518708858098879e-19
Rsub_49_149 sn_49 sn_149 37633991.37075543
Csub_49_149 sn_49 sn_149 2.79972522670494e-19
Rsub_49_71 sn_49 sn_71 42904788.59594572
Csub_49_71 sn_49 sn_71 2.455782640361418e-19
Rsub_49_172 sn_49 sn_172 60318063.78588114
Csub_49_172 sn_49 sn_172 1.746820577602213e-19
Rsub_49_150 sn_49 sn_150 4785628.548018204
Csub_49_150 sn_49 sn_150 2.201692713195074e-18
Rsub_49_134 sn_49 sn_134 16174203.21829734
Csub_49_134 sn_49 sn_134 6.514375614070699e-19
Rsub_49_67 sn_49 sn_67 4634364.252662529
Csub_49_67 sn_49 sn_67 2.273555320166428e-18
Rsub_49_87 sn_49 sn_87 17016799.09552754
Csub_49_87 sn_49 sn_87 6.191812833354342e-19
Rsub_49_123 sn_49 sn_123 11528614.37237714
Csub_49_123 sn_49 sn_123 9.139418807758621e-19
Rsub_49_176 sn_49 sn_176 5283670.614818398
Csub_49_176 sn_49 sn_176 1.994159793511683e-18
Rsub_49_196 sn_49 sn_196 5556019.713842168
Csub_49_196 sn_49 sn_196 1.896408588324407e-18
Rsub_49_145 sn_49 sn_145 67256034.68855441
Csub_49_145 sn_49 sn_145 1.566622764934296e-19
Rsub_49_127 sn_49 sn_127 8200295.484121548
Csub_49_127 sn_49 sn_127 1.284890711881307e-18
Rsub_49_181 sn_49 sn_181 2464088.187132145
Csub_49_181 sn_49 sn_181 4.276017212879462e-18
Rsub_49_140 sn_49 sn_140 24597487.67817947
Csub_49_140 sn_49 sn_140 4.283560841693992e-19
Rsub_49_83 sn_49 sn_83 17097920.02425358
Csub_49_83 sn_49 sn_83 6.162435832711751e-19
Rsub_49_141 sn_49 sn_141 3205913.938958049
Csub_49_141 sn_49 sn_141 3.286577151741775e-18
Rsub_49_195 sn_49 sn_195 2892918.314288046
Csub_49_195 sn_49 sn_195 3.642164194609503e-18
Rsub_49_80 sn_49 sn_80 58052197.09266228
Csub_49_80 sn_49 sn_80 1.815001676062627e-19
Rsub_49_126 sn_49 sn_126 27131004.38794343
Csub_49_126 sn_49 sn_126 3.883558216854014e-19
Rsub_49_100 sn_49 sn_100 356901.4031878964
Csub_49_100 sn_49 sn_100 2.952211285278389e-17
Rsub_49_183 sn_49 sn_183 7789152.877699655
Csub_49_183 sn_49 sn_183 1.352712376771542e-18
Rsub_49_58 sn_49 sn_58 19140054.66414143
Csub_49_58 sn_49 sn_58 5.50493908565994e-19
Rsub_49_225 sn_49 sn_225 12131872.09933349
Csub_49_225 sn_49 sn_225 8.684960916138297e-19
Rsub_49_137 sn_49 sn_137 6242586.704549347
Csub_49_137 sn_49 sn_137 1.687839352643902e-18
Rsub_49_76 sn_49 sn_76 651639.5202562625
Csub_49_76 sn_49 sn_76 1.616919044149815e-17
Rsub_49_155 sn_49 sn_155 3595544.819930387
Csub_49_155 sn_49 sn_155 2.930427523480015e-18
Rsub_49_59 sn_49 sn_59 4520919.72705311
Csub_49_59 sn_49 sn_59 2.330606190412949e-18
Rsub_49_226 sn_49 sn_226 928608.4107307111
Csub_49_226 sn_49 sn_226 1.13465303355792e-17
Rsub_49_216 sn_49 sn_216 1251111.392413872
Csub_49_216 sn_49 sn_216 8.421698951922335e-18
Rsub_49_128 sn_49 sn_128 4336435.119818582
Csub_49_128 sn_49 sn_128 2.429756980353669e-18
Rsub_49_177 sn_49 sn_177 2768103.46876906
Csub_49_177 sn_49 sn_177 3.806390772999336e-18
Rsub_49_214 sn_49 sn_214 1450483.551465809
Csub_49_214 sn_49 sn_214 7.264117880952317e-18
Rsub_49_182 sn_49 sn_182 4081483.720475066
Csub_49_182 sn_49 sn_182 2.581532654258291e-18
Rsub_49_139 sn_49 sn_139 4389803.30205656
Csub_49_139 sn_49 sn_139 2.400217681118835e-18
Rsub_49_166 sn_49 sn_166 2216386.059842494
Csub_49_166 sn_49 sn_166 4.753902622442395e-18
Rsub_49_203 sn_49 sn_203 1107612.663895601
Csub_49_203 sn_49 sn_203 9.512787137312042e-18
Rsub_49_190 sn_49 sn_190 20820073.35379412
Csub_49_190 sn_49 sn_190 5.060733131523718e-19
Rsub_49_60 sn_49 sn_60 3578920.479795344
Csub_49_60 sn_49 sn_60 2.944039567716944e-18
Rsub_49_227 sn_49 sn_227 2398694.782589329
Csub_49_227 sn_49 sn_227 4.392590328168446e-18
Rsub_49_148 sn_49 sn_148 305638.4604279584
Csub_49_148 sn_49 sn_148 3.447368334298209e-17
Rsub_49_213 sn_49 sn_213 632226.3498544217
Csub_49_213 sn_49 sn_213 1.666568232193449e-17
Rsub_49_199 sn_49 sn_199 1341907.307503665
Csub_49_199 sn_49 sn_199 7.851871320256018e-18
Rsub_49_198 sn_49 sn_198 66706.61777028581
Csub_49_198 sn_49 sn_198 1.5795259682501e-16
Rsub_49_119 sn_49 sn_119 1450470.702490267
Csub_49_119 sn_49 sn_119 7.264182230044526e-18
Rsub_49_121 sn_49 sn_121 10841779.7895969
Csub_49_121 sn_49 sn_121 9.718407592395625e-19
Rsub_49_200 sn_49 sn_200 1879203.304782097
Csub_49_200 sn_49 sn_200 5.606888555068691e-18
Rsub_49_212 sn_49 sn_212 650657.9630469931
Csub_49_212 sn_49 sn_212 1.619358265114941e-17
Rsub_49_133 sn_49 sn_133 119638.8912627028
Csub_49_133 sn_49 sn_133 8.806905004739651e-17
Rsub_49_138 sn_49 sn_138 13543.04599701163
Csub_49_138 sn_49 sn_138 7.779995360390085e-16
Rsub_49_206 sn_49 sn_206 789339.1662684402
Csub_49_206 sn_49 sn_206 1.334848687673852e-17
Rsub_49_110 sn_49 sn_110 4474679.124696847
Csub_49_110 sn_49 sn_110 2.354690293674149e-18
Rsub_49_204 sn_49 sn_204 5118741.284224578
Csub_49_204 sn_49 sn_204 2.058412980296999e-18
Rsub_49_125 sn_49 sn_125 19010068.75426275
Csub_49_125 sn_49 sn_125 5.542580428525457e-19
Rsub_49_93 sn_49 sn_93 4825164.22615993
Csub_49_93 sn_49 sn_93 2.183652826800339e-18
Rsub_49_215 sn_49 sn_215 93125.94748611297
Csub_49_215 sn_49 sn_215 1.131422958547746e-16
Rsub_49_178 sn_49 sn_178 533669.7498102733
Csub_49_178 sn_49 sn_178 1.974345277388471e-17
Rsub_49_99 sn_49 sn_99 2019057.53042007
Csub_49_99 sn_49 sn_99 5.218515739884766e-18
Rsub_49_219 sn_49 sn_219 2009959.938403554
Csub_49_219 sn_49 sn_219 5.242136074910423e-18
Rsub_49_52 sn_49 sn_52 32430.07529537758
Csub_49_52 sn_49 sn_52 3.248985210876713e-16
Rsub_49_131 sn_49 sn_131 758496.475972604
Csub_49_131 sn_49 sn_131 1.389127548512245e-17
Rsub_49_210 sn_49 sn_210 4019047.784814211
Csub_49_210 sn_49 sn_210 2.621636782235241e-18
Rsub_49_222 sn_49 sn_222 46265.85046259176
Csub_49_222 sn_49 sn_222 2.277378108665542e-16
Rsub_49_74 sn_49 sn_74 9803503.748391211
Csub_49_74 sn_49 sn_74 1.074767121291617e-18
Rsub_49_153 sn_49 sn_153 1768258.048764064
Csub_49_153 sn_49 sn_153 5.958679792010307e-18
Rsub_49_156 sn_49 sn_156 13803465.522217
Csub_49_156 sn_49 sn_156 7.633216082781012e-19
Rsub_49_77 sn_49 sn_77 7331931.390567104
Csub_49_77 sn_49 sn_77 1.437067934894442e-18
Rsub_49_170 sn_49 sn_170 92839.5220728703
Csub_49_170 sn_49 sn_170 1.13491358712078e-16
Rsub_49_142 sn_49 sn_142 4225469.657436384
Csub_49_142 sn_49 sn_142 2.493565060557681e-18
Rsub_49_54 sn_49 sn_54 3531741.60199347
Csub_49_54 sn_49 sn_54 2.983367609986741e-18
Rsub_49_221 sn_49 sn_221 1824943.994242096
Csub_49_221 sn_49 sn_221 5.773592798175612e-18
Rsub_49_122 sn_49 sn_122 18171370.41224071
Csub_49_122 sn_49 sn_122 5.798397844079142e-19
Rsub_49_201 sn_49 sn_201 3361407.814523964
Csub_49_201 sn_49 sn_201 3.134544834668375e-18
Rsub_49_79 sn_49 sn_79 4172128.553778176
Csub_49_79 sn_49 sn_79 2.525445552891323e-18
Rsub_49_81 sn_49 sn_81 30410507.25211227
Csub_49_81 sn_49 sn_81 3.464750987176695e-19
Rsub_49_160 sn_49 sn_160 12945197.20390197
Csub_49_160 sn_49 sn_160 8.139299337250781e-19
Rsub_49_96 sn_49 sn_96 13021399.87133781
Csub_49_96 sn_49 sn_96 8.09166726030931e-19
Rsub_49_132 sn_49 sn_132 3524040.425941885
Csub_49_132 sn_49 sn_132 2.98988723984739e-18
Rsub_49_220 sn_49 sn_220 20645987.58194147
Csub_49_220 sn_49 sn_220 5.103404940263552e-19
Rsub_49_53 sn_49 sn_53 59903205.56929275
Csub_49_53 sn_49 sn_53 1.758918141708122e-19
Rsub_49_211 sn_49 sn_211 1826693.264710841
Csub_49_211 sn_49 sn_211 5.768063914057233e-18
Rsub_49_130 sn_49 sn_130 7251664.316205473
Csub_49_130 sn_49 sn_130 1.452974523197918e-18
Rsub_49_209 sn_49 sn_209 7863779.342590468
Csub_49_209 sn_49 sn_209 1.339875274114583e-18
Rsub_49_218 sn_49 sn_218 1857406.671662852
Csub_49_218 sn_49 sn_218 5.672685289106433e-18
Rsub_49_51 sn_49 sn_51 2353216.081500695
Csub_49_51 sn_49 sn_51 4.477482363417585e-18
Rsub_49_179 sn_49 sn_179 9397058.269587964
Csub_49_179 sn_49 sn_179 1.121253396536829e-18
Rsub_49_97 sn_49 sn_97 1710639.353602215
Csub_49_97 sn_49 sn_97 6.159383320652933e-18
Rsub_49_230 sn_49 0 55515.77476517815
Csub_49_230 sn_49 0 1.897926048370477e-16
Rsub_49_151 sn_49 sn_151 28188956.8686182
Csub_49_151 sn_49 sn_151 3.73780539355818e-19
Rsub_49_174 sn_49 sn_174 1661535.636225795
Csub_49_174 sn_49 sn_174 6.341412890886768e-18
Rsub_49_192 sn_49 sn_192 5702088.816321691
Csub_49_192 sn_49 sn_192 1.84782872411077e-18
Rsub_49_157 sn_49 sn_157 4385329.913555552
Csub_49_157 sn_49 sn_157 2.402666095807418e-18
Rsub_49_184 sn_49 sn_184 24337513.23907769
Csub_49_184 sn_49 sn_184 4.329318036204301e-19
Rsub_49_188 sn_49 sn_188 546007.3443320018
Csub_49_188 sn_49 sn_188 1.929732926050763e-17
Rsub_49_107 sn_49 sn_107 15844839.21042262
Csub_49_107 sn_49 sn_107 6.649788844369707e-19
Rsub_49_191 sn_49 sn_191 32820424.11509992
Csub_49_191 sn_49 sn_191 3.210343493819268e-19
Rsub_49_66 sn_49 sn_66 31868487.62752077
Csub_49_66 sn_49 sn_66 3.306238948449809e-19
Rsub_49_129 sn_49 sn_129 6309555.751869956
Csub_49_129 sn_49 sn_129 1.669924780220432e-18
Rsub_49_144 sn_49 sn_144 3279328.586043159
Csub_49_144 sn_49 sn_144 3.213000230313405e-18
Rsub_49_88 sn_49 sn_88 5322650.472790874
Csub_49_88 sn_49 sn_88 1.979555778853409e-18
Rsub_49_114 sn_49 sn_114 7432141.960164947
Csub_49_114 sn_49 sn_114 1.417691367939931e-18
Rsub_216_221 sn_216 sn_221 2754396.483796685
Csub_216_221 sn_216 sn_221 3.825332904762649e-18
Rsub_216_218 sn_216 sn_218 5129550.015662841
Csub_216_218 sn_216 sn_218 2.054075595336305e-18
Rsub_216_224 sn_216 sn_224 840254.4586475285
Csub_216_224 sn_216 sn_224 1.253963414748135e-17
Rsub_216_228 sn_216 sn_228 2547862.671351049
Csub_216_228 sn_216 sn_228 4.135420492126778e-18
Rsub_216_230 sn_216 0 14051.78589761668
Csub_216_230 sn_216 0 7.498323401025553e-16
Rsub_216_222 sn_216 sn_222 25353.1334769391
Csub_216_222 sn_216 sn_222 4.155890044839569e-16
Rsub_216_226 sn_216 sn_226 329936.2972304231
Csub_216_226 sn_216 sn_226 3.193490255748206e-17
Rsub_216_219 sn_216 sn_219 444268.8094334618
Csub_216_219 sn_216 sn_219 2.371646012166887e-17
Rsub_216_227 sn_216 sn_227 361620.0702878155
Csub_216_227 sn_216 sn_227 2.913688804342069e-17
Rsub_131_167 sn_131 sn_167 968689.6187288165
Csub_131_167 sn_131 sn_167 1.087704802293301e-17
Rsub_131_163 sn_131 sn_163 5048711.173004286
Csub_131_163 sn_131 sn_163 2.08696499783333e-18
Rsub_131_196 sn_131 sn_196 6506948.219905344
Csub_131_196 sn_131 sn_196 1.619266535731442e-18
Rsub_131_200 sn_131 sn_200 3187712.89422038
Csub_131_200 sn_131 sn_200 3.30534268670608e-18
Rsub_131_207 sn_131 sn_207 4494879.569038124
Csub_131_207 sn_131 sn_207 2.344108076845481e-18
Rsub_131_217 sn_131 sn_217 778374.0466714924
Csub_131_217 sn_131 sn_217 1.353652983072399e-17
Rsub_131_151 sn_131 sn_151 4805560.029892062
Csub_131_151 sn_131 sn_151 2.192560999485977e-18
Rsub_131_201 sn_131 sn_201 1527619.811647149
Csub_131_201 sn_131 sn_201 6.897320538720356e-18
Rsub_131_133 sn_131 sn_133 2706589.041626375
Csub_131_133 sn_131 sn_133 3.892901116565035e-18
Rsub_131_212 sn_131 sn_212 42412202.26802972
Csub_131_212 sn_131 sn_212 2.484304737500602e-19
Rsub_131_202 sn_131 sn_202 2238600.678005738
Csub_131_202 sn_131 sn_202 4.706727557867289e-18
Rsub_131_188 sn_131 sn_188 818397.8912432551
Csub_131_188 sn_131 sn_188 1.287452425643923e-17
Rsub_131_150 sn_131 sn_150 14516.89923287124
Csub_131_150 sn_131 sn_150 7.258081311449616e-16
Rsub_131_229 sn_131 sn_229 1036262.153816793
Csub_131_229 sn_131 sn_229 1.016777797338415e-17
Rsub_131_226 sn_131 sn_226 334749.1127220311
Csub_131_226 sn_131 sn_226 3.147576230016563e-17
Rsub_131_199 sn_131 sn_199 6397039.831993372
Csub_131_199 sn_131 sn_199 1.647087368369058e-18
Rsub_131_168 sn_131 sn_168 188141.1947967651
Csub_131_168 sn_131 sn_168 5.60030646856037e-17
Rsub_131_210 sn_131 sn_210 147137.0913525522
Csub_131_210 sn_131 sn_210 7.160997546827772e-17
Rsub_131_216 sn_131 sn_216 281615.7645035738
Csub_131_216 sn_131 sn_216 3.74143951806231e-17
Rsub_131_137 sn_131 sn_137 3007225.503225422
Csub_131_137 sn_131 sn_137 3.503722448126693e-18
Rsub_131_154 sn_131 sn_154 10094199.91376815
Csub_131_154 sn_131 sn_154 1.043815616120163e-18
Rsub_131_191 sn_131 sn_191 80364.5093950876
Csub_131_191 sn_131 sn_191 1.311086645279024e-16
Rsub_131_215 sn_131 sn_215 200451.0678144477
Csub_131_215 sn_131 sn_215 5.256386816548838e-17
Rsub_131_136 sn_131 sn_136 2253436.747442003
Csub_131_136 sn_131 sn_136 4.675739629341951e-18
Rsub_131_141 sn_131 sn_141 272308.4927313022
Csub_131_141 sn_131 sn_141 3.869318726179714e-17
Rsub_131_220 sn_131 sn_220 1142467.307983292
Csub_131_220 sn_131 sn_220 9.222568933573452e-18
Rsub_131_178 sn_131 sn_178 365383.6106370428
Csub_131_178 sn_131 sn_178 2.883677098668915e-17
Rsub_131_218 sn_131 sn_218 1405754.307254531
Csub_131_218 sn_131 sn_218 7.49525251166257e-18
Rsub_131_139 sn_131 sn_139 844539.2944039534
Csub_131_139 sn_131 sn_139 1.247601333892497e-17
Rsub_131_190 sn_131 sn_190 612506.3044668367
Csub_131_190 sn_131 sn_190 1.720224498162775e-17
Rsub_131_153 sn_131 sn_153 15249.92774448421
Csub_131_153 sn_131 sn_153 6.909202245919473e-16
Rsub_131_227 sn_131 sn_227 936459.6051770897
Csub_131_227 sn_131 sn_227 1.125140202949544e-17
Rsub_131_148 sn_131 sn_148 1283422.19764464
Csub_131_148 sn_131 sn_148 8.209678406347305e-18
Rsub_131_132 sn_131 sn_132 3298730.484585034
Csub_131_132 sn_131 sn_132 3.19410256505252e-18
Rsub_131_211 sn_131 sn_211 8364422.456567969
Csub_131_211 sn_131 sn_211 1.259678544088417e-18
Rsub_131_206 sn_131 sn_206 902607.3096429218
Csub_131_206 sn_131 sn_206 1.167338596714701e-17
Rsub_131_169 sn_131 sn_169 200530.3954119604
Csub_131_169 sn_131 sn_169 5.25430744829697e-17
Rsub_131_219 sn_131 sn_219 3022.447644393906
Csub_131_219 sn_131 sn_219 3.486076432712829e-15
Rsub_131_140 sn_131 sn_140 174550365.7357312
Csub_131_140 sn_131 sn_140 6.036357161337728e-20
Rsub_131_138 sn_131 sn_138 189889.3601889147
Csub_131_138 sn_131 sn_138 5.548748751245251e-17
Rsub_131_185 sn_131 sn_185 549882.3844172526
Csub_131_185 sn_131 sn_185 1.916134031715932e-17
Rsub_131_222 sn_131 sn_222 26489.44093645362
Csub_131_222 sn_131 sn_222 3.977616412330601e-16
Rsub_131_230 sn_131 0 11586.88244883539
Csub_131_230 sn_131 0 9.093458528431892e-16
Rsub_131_195 sn_131 sn_195 17896.19291300006
Csub_131_195 sn_131 sn_195 5.88755583573093e-16
Rsub_131_158 sn_131 sn_158 268946.8885984026
Csub_131_158 sn_131 sn_158 3.91768187285606e-17
Rsub_131_214 sn_131 sn_214 412500.6619009003
Csub_131_214 sn_131 sn_214 2.554294932200933e-17
Rsub_131_135 sn_131 sn_135 223443.2849178415
Csub_131_135 sn_131 sn_135 4.71550689299264e-17
Rsub_131_177 sn_131 sn_177 117573.1517293135
Csub_131_177 sn_131 sn_177 8.961640771940822e-17
Rsub_131_180 sn_131 sn_180 443838.9294665787
Csub_131_180 sn_131 sn_180 2.373943068692311e-17
Rsub_131_223 sn_131 sn_223 228434.3271897653
Csub_131_223 sn_131 sn_223 4.612478182176672e-17
Rsub_131_144 sn_131 sn_144 82512538.51654339
Csub_131_144 sn_131 sn_144 1.276955441156072e-19
Rsub_131_156 sn_131 sn_156 1693365.405545544
Csub_131_156 sn_131 sn_156 6.222214926397123e-18
Rsub_131_183 sn_131 sn_183 1742930.015939551
Csub_131_183 sn_131 sn_183 6.045270553534051e-18
Rsub_131_225 sn_131 sn_225 4129778.150688491
Csub_131_225 sn_131 sn_225 2.551343708492773e-18
Rsub_131_146 sn_131 sn_146 8898988.19279686
Csub_131_146 sn_131 sn_146 1.184009156317185e-18
Rsub_131_209 sn_131 sn_209 2882384.5931633
Csub_131_209 sn_131 sn_209 3.655474542578872e-18
Rsub_131_134 sn_131 sn_134 1247721.83316147
Csub_131_134 sn_131 sn_134 8.444577326608709e-18
Rsub_131_213 sn_131 sn_213 6856704.860318161
Csub_131_213 sn_131 sn_213 1.536668664741258e-18
Rsub_131_203 sn_131 sn_203 5726698.269294679
Csub_131_203 sn_131 sn_203 1.83988801343426e-18
Rsub_131_186 sn_131 sn_186 2025639.771656552
Csub_131_186 sn_131 sn_186 5.201558366724479e-18
Rsub_131_184 sn_131 sn_184 3833933.676606456
Csub_131_184 sn_131 sn_184 2.748217468267787e-18
Rsub_131_204 sn_131 sn_204 450662.0274466412
Csub_131_204 sn_131 sn_204 2.338001176164666e-17
Rsub_131_165 sn_131 sn_165 1182458.643186592
Csub_131_165 sn_131 sn_165 8.910657098192776e-18
Rsub_131_228 sn_131 sn_228 579037.8141127919
Csub_131_228 sn_131 sn_228 1.819653785197797e-17
Rsub_131_170 sn_131 sn_170 208847.2995116166
Csub_131_170 sn_131 sn_170 5.045065713978236e-17
Rsub_131_145 sn_131 sn_145 2358643.293695393
Csub_131_145 sn_131 sn_145 4.467179725901671e-18
Rsub_131_197 sn_131 sn_197 2032257.350379092
Csub_131_197 sn_131 sn_197 5.18462068805634e-18
Rsub_131_162 sn_131 sn_162 490344.3816570808
Csub_131_162 sn_131 sn_162 2.148792541809651e-17
Rsub_131_174 sn_131 sn_174 32196975.89655617
Csub_131_174 sn_131 sn_174 3.272507187035848e-19
Rsub_131_182 sn_131 sn_182 4228409.567880132
Csub_131_182 sn_131 sn_182 2.491831345351996e-18
Rsub_131_155 sn_131 sn_155 384447.5617450411
Csub_131_155 sn_131 sn_155 2.740681578107553e-17
Rsub_131_192 sn_131 sn_192 5388234.160168005
Csub_131_192 sn_131 sn_192 1.955461323511129e-18
Rsub_131_160 sn_131 sn_160 4852879.550764824
Csub_131_160 sn_131 sn_160 2.171181747251367e-18
Rsub_131_179 sn_131 sn_179 363496.6198880175
Csub_131_179 sn_131 sn_179 2.898646899516143e-17
Rsub_131_221 sn_131 sn_221 3240157.693094586
Csub_131_221 sn_131 sn_221 3.25184281144258e-18
Rsub_131_208 sn_131 sn_208 1051736.512612921
Csub_131_208 sn_131 sn_208 1.001817791421284e-17
Rsub_131_172 sn_131 sn_172 11948313.72093827
Csub_131_172 sn_131 sn_172 8.818385379156748e-19
Rsub_131_176 sn_131 sn_176 785487.2355699027
Csub_131_176 sn_131 sn_176 1.341394617900488e-17
Rsub_131_166 sn_131 sn_166 1653987.930640993
Csub_131_166 sn_131 sn_166 6.370350899807746e-18
Rsub_138_185 sn_138 sn_185 5271700.702367934
Csub_138_185 sn_138 sn_185 1.998687728515627e-18
Rsub_138_161 sn_138 sn_161 767979.6223080078
Csub_138_161 sn_138 sn_161 1.371974359236867e-17
Rsub_138_196 sn_138 sn_196 610006.523114281
Csub_138_196 sn_138 sn_196 1.727273906586743e-17
Rsub_138_168 sn_138 sn_168 1933038.841210787
Csub_138_168 sn_138 sn_168 5.450735534951962e-18
Rsub_138_201 sn_138 sn_201 815078.3510287198
Csub_138_201 sn_138 sn_201 1.292695786721827e-17
Rsub_138_142 sn_138 sn_142 2134367.903981129
Csub_138_142 sn_138 sn_142 4.936582621288873e-18
Rsub_138_221 sn_138 sn_221 215971.5053693332
Csub_138_221 sn_138 sn_221 4.878645210261207e-17
Rsub_138_179 sn_138 sn_179 342130.9059830697
Csub_138_179 sn_138 sn_179 3.079664338407182e-17
Rsub_138_182 sn_138 sn_182 84637.79759069522
Csub_138_182 sn_138 sn_182 1.244891030031758e-16
Rsub_138_195 sn_138 sn_195 173855.0526541008
Csub_138_195 sn_138 sn_195 6.060498870397063e-17
Rsub_138_174 sn_138 sn_174 2798878.127689725
Csub_138_174 sn_138 sn_174 3.764538154766717e-18
Rsub_138_177 sn_138 sn_177 500947.6295635023
Csub_138_177 sn_138 sn_177 2.103310382247123e-17
Rsub_138_214 sn_138 sn_214 82055.37229270866
Csub_138_214 sn_138 sn_214 1.284069916183448e-16
Rsub_138_139 sn_138 sn_139 802453.425022123
Csub_138_139 sn_138 sn_139 1.313033650761665e-17
Rsub_138_218 sn_138 sn_218 366633.8323777395
Csub_138_218 sn_138 sn_218 2.8738437568343e-17
Rsub_138_213 sn_138 sn_213 23584.85176403831
Csub_138_213 sn_138 sn_213 4.467479214050356e-16
Rsub_138_188 sn_138 sn_188 75768.33399391474
Csub_138_188 sn_138 sn_188 1.390618342364005e-16
Rsub_138_160 sn_138 sn_160 486639.1939195595
Csub_138_160 sn_138 sn_160 2.165153081354903e-17
Rsub_138_206 sn_138 sn_206 164107.1066117095
Csub_138_206 sn_138 sn_206 6.420491909079941e-17
Rsub_138_155 sn_138 sn_155 945727.4164300376
Csub_138_155 sn_138 sn_155 1.114114206607593e-17
Rsub_138_210 sn_138 sn_210 656029.0172699277
Csub_138_210 sn_138 sn_210 1.60610022191971e-17
Rsub_138_227 sn_138 sn_227 285127.1336940352
Csub_138_227 sn_138 sn_227 3.695363315908234e-17
Rsub_138_148 sn_138 sn_148 16553.09984666989
Csub_138_148 sn_138 sn_148 6.365263062404414e-16
Rsub_138_226 sn_138 sn_226 239932.4248639004
Csub_138_226 sn_138 sn_226 4.391437925993842e-17
Rsub_138_198 sn_138 sn_198 2777.007892197752
Csub_138_198 sn_138 sn_198 3.794185652778726e-15
Rsub_138_217 sn_138 sn_217 332094.6386046484
Csub_138_217 sn_138 sn_217 3.17273520177887e-17
Rsub_138_212 sn_138 sn_212 121071.2823965388
Csub_138_212 sn_138 sn_212 8.702710744997628e-17
Rsub_138_215 sn_138 sn_215 16701.78580356077
Csub_138_215 sn_138 sn_215 6.308596952538845e-16
Rsub_138_178 sn_138 sn_178 176418.7362483429
Csub_138_178 sn_138 sn_178 5.972428850979806e-17
Rsub_138_199 sn_138 sn_199 175646.7423225708
Csub_138_199 sn_138 sn_199 5.998678576617158e-17
Rsub_138_222 sn_138 sn_222 18618.08848374943
Csub_138_222 sn_138 sn_222 5.659272438965277e-16
Rsub_138_230 sn_138 0 14428.70313300836
Csub_138_230 sn_138 0 7.302446661422967e-16
Rsub_138_151 sn_138 sn_151 59434165.56590418
Csub_138_151 sn_138 sn_151 1.772799096598154e-19
Rsub_138_203 sn_138 sn_203 427626.252692579
Csub_138_203 sn_138 sn_203 2.463946831113919e-17
Rsub_138_166 sn_138 sn_166 413605.1360190741
Csub_138_166 sn_138 sn_166 2.547474048229443e-17
Rsub_138_170 sn_138 sn_170 13220.42046566886
Csub_138_170 sn_138 sn_170 7.969855065949996e-16
Rsub_138_158 sn_138 sn_158 665197.3294660256
Csub_138_158 sn_138 sn_158 1.58396359027598e-17
Rsub_138_150 sn_138 sn_150 849343.5700690564
Csub_138_150 sn_138 sn_150 1.240544330178814e-17
Rsub_138_229 sn_138 sn_229 494431.1692637803
Csub_138_229 sn_138 sn_229 2.131031406842549e-17
Rsub_138_159 sn_138 sn_159 229105.082125213
Csub_138_159 sn_138 sn_159 4.598974149543958e-17
Rsub_138_216 sn_138 sn_216 746663.4855347482
Csub_138_216 sn_138 sn_216 1.411142195427428e-17
Rsub_138_208 sn_138 sn_208 1343911.036660367
Csub_138_208 sn_138 sn_208 7.840164426667164e-18
Rsub_138_162 sn_138 sn_162 2164178.372132741
Csub_138_162 sn_138 sn_162 4.868583679563607e-18
Rsub_138_141 sn_138 sn_141 156684.6268687071
Csub_138_141 sn_138 sn_141 6.724644090998781e-17
Rsub_138_220 sn_138 sn_220 555391.7914754825
Csub_138_220 sn_138 sn_220 1.897126256446505e-17
Rsub_138_181 sn_138 sn_181 3102424.661393682
Csub_138_181 sn_138 sn_181 3.396209304723862e-18
Rsub_138_186 sn_138 sn_186 3842856.730271193
Csub_138_186 sn_138 sn_186 2.741836149974405e-18
Rsub_138_207 sn_138 sn_207 831182.75552366
Csub_138_207 sn_138 sn_207 1.267649434761412e-17
Rsub_138_204 sn_138 sn_204 1939879.366795534
Csub_138_204 sn_138 sn_204 5.431514805807282e-18
Rsub_138_154 sn_138 sn_154 4612738.114571943
Csub_138_154 sn_138 sn_154 2.284214546875002e-18
Rsub_138_144 sn_138 sn_144 502517.3419135877
Csub_138_144 sn_138 sn_144 2.096740276088192e-17
Rsub_138_219 sn_138 sn_219 503989.7691305091
Csub_138_219 sn_138 sn_219 2.090614561562967e-17
Rsub_138_200 sn_138 sn_200 226272.0196604604
Csub_138_200 sn_138 sn_200 4.656556085918556e-17
Rsub_138_153 sn_138 sn_153 733342.7761530582
Csub_138_153 sn_138 sn_153 1.436774704116115e-17
Rsub_138_165 sn_138 sn_165 200501.8260307193
Csub_138_165 sn_138 sn_165 5.255056131317072e-17
Rsub_138_176 sn_138 sn_176 1283212.264234873
Csub_138_176 sn_138 sn_176 8.211021508988209e-18
Rsub_138_172 sn_138 sn_172 63260408.42841522
Csub_138_172 sn_138 sn_172 1.665573107096356e-19
Rsub_138_211 sn_138 sn_211 374304.647060862
Csub_138_211 sn_138 sn_211 2.814948621387746e-17
Rsub_138_191 sn_138 sn_191 4320247.821291765
Csub_138_191 sn_138 sn_191 2.438860902909863e-18
Rsub_138_157 sn_138 sn_157 2878959.993582157
Csub_138_157 sn_138 sn_157 3.659822826895188e-18
Rsub_138_225 sn_138 sn_225 63260408.42841522
Csub_138_225 sn_138 sn_225 1.665573107096356e-19
Rsub_138_228 sn_138 sn_228 52415817.44854816
Csub_138_228 sn_138 sn_228 2.010172504239338e-19
Rsub_138_171 sn_138 sn_171 8110076.367289147
Csub_138_171 sn_138 sn_171 1.299184252410671e-18
Rsub_138_190 sn_138 sn_190 1016813.475892054
Csub_138_190 sn_138 sn_190 1.03622579283642e-17
Rsub_138_167 sn_138 sn_167 3921687.773630168
Csub_138_167 sn_138 sn_167 2.686721664350334e-18
Rsub_138_169 sn_138 sn_169 2900762.013219507
Csub_138_169 sn_138 sn_169 3.632315734352758e-18
Rsub_138_180 sn_138 sn_180 6623543.96253331
Csub_138_180 sn_138 sn_180 1.590762220622464e-18
Rsub_138_156 sn_138 sn_156 62829548.27485631
Csub_138_156 sn_138 sn_156 1.67699494768556e-19
Rsub_138_197 sn_138 sn_197 17621509.40059279
Csub_138_197 sn_138 sn_197 5.979330863606698e-19
Rsub_138_205 sn_138 sn_205 1674393.303436641
Csub_138_205 sn_138 sn_205 6.292717177382513e-18
Rsub_138_183 sn_138 sn_183 8612346.959924007
Csub_138_183 sn_138 sn_183 1.223416050382041e-18
Rsub_138_175 sn_138 sn_175 1137166.98224479
Csub_138_175 sn_138 sn_175 9.26555524979346e-18
Rsub_138_163 sn_138 sn_163 2681832.294644668
Csub_138_163 sn_138 sn_163 3.928837579915132e-18
Rsub_203_228 sn_203 sn_228 7474345.140501082
Csub_203_228 sn_203 sn_228 1.409686508204735e-18
Rsub_203_217 sn_203 sn_217 4089791.031996975
Csub_203_217 sn_203 sn_217 2.576288964349657e-18
Rsub_203_210 sn_203 sn_210 7622729.066151287
Csub_203_210 sn_203 sn_210 1.382245572523e-18
Rsub_203_205 sn_203 sn_205 4901842.781135006
Csub_203_205 sn_203 sn_205 2.149494378477457e-18
Rsub_203_216 sn_203 sn_216 2287637.535127567
Csub_203_216 sn_203 sn_216 4.605836082175688e-18
Rsub_203_204 sn_203 sn_204 1358697.46009742
Csub_203_204 sn_203 sn_204 7.754841538803295e-18
Rsub_203_224 sn_203 sn_224 4779665.765610286
Csub_203_224 sn_203 sn_224 2.204439393658034e-18
Rsub_203_218 sn_203 sn_218 36784.05162585516
Csub_203_218 sn_203 sn_218 2.864416244681434e-16
Rsub_203_221 sn_203 sn_221 6951.679287029677
Csub_203_221 sn_203 sn_221 1.515674568285794e-15
Rsub_203_206 sn_203 sn_206 2022103.784281247
Csub_203_206 sn_203 sn_206 5.210654163319898e-18
Rsub_203_212 sn_203 sn_212 45575.53959683239
Csub_203_212 sn_203 sn_212 2.311872463921922e-16
Rsub_203_222 sn_203 sn_222 62129.54953649158
Csub_203_222 sn_203 sn_222 1.695889247682608e-16
Rsub_203_227 sn_203 sn_227 65996.3741429364
Csub_203_227 sn_203 sn_227 1.596524602913768e-16
Rsub_203_214 sn_203 sn_214 280807.9891154434
Csub_203_214 sn_203 sn_214 3.752202184638818e-17
Rsub_203_213 sn_203 sn_213 315162.438190075
Csub_203_213 sn_203 sn_213 3.343191391315302e-17
Rsub_203_230 sn_203 0 34800.53133116578
Csub_203_230 sn_203 0 3.027678917302623e-16
Rsub_203_226 sn_203 sn_226 30282.75454419649
Csub_203_226 sn_203 sn_226 3.479367600742006e-16
Rsub_203_208 sn_203 sn_208 2421587.79087893
Csub_203_208 sn_203 sn_208 4.351064017549295e-18
Rsub_203_215 sn_203 sn_215 250912.0409410321
Csub_203_215 sn_203 sn_215 4.199273762515935e-17
Rsub_203_207 sn_203 sn_207 983702.7299359564
Csub_203_207 sn_203 sn_207 1.071104428358756e-17
Rsub_203_211 sn_203 sn_211 83564.41511181138
Csub_203_211 sn_203 sn_211 1.260881619063798e-16
Rsub_203_219 sn_203 sn_219 1214759.170839158
Csub_203_219 sn_203 sn_219 8.673722129589996e-18
Rsub_36_100 sn_36 sn_100 56451521.23550414
Csub_36_100 sn_36 sn_100 1.86646582264346e-19
Rsub_36_170 sn_36 sn_170 42841468.76949669
Csub_36_170 sn_36 sn_170 2.459412294877253e-19
Rsub_36_199 sn_36 sn_199 21596687.16244883
Csub_36_199 sn_36 sn_199 4.878749885561282e-19
Rsub_36_176 sn_36 sn_176 1109509.31055349
Csub_36_176 sn_36 sn_176 9.496525537918893e-18
Rsub_36_153 sn_36 sn_153 14810582.81286766
Csub_36_153 sn_36 sn_153 7.11415859548467e-19
Rsub_36_127 sn_36 sn_127 268679236.3201585
Csub_36_127 sn_36 sn_127 3.921584580385927e-20
Rsub_36_83 sn_36 sn_83 56572350.69020343
Csub_36_83 sn_36 sn_83 1.862479351428929e-19
Rsub_36_168 sn_36 sn_168 12003407.68039858
Csub_36_168 sn_36 sn_168 8.777910225806922e-19
Rsub_36_163 sn_36 sn_163 20143784.78805354
Csub_36_163 sn_36 sn_163 5.230637446285051e-19
Rsub_36_159 sn_36 sn_159 18868130.30036406
Csub_36_159 sn_36 sn_159 5.584275354525563e-19
Rsub_36_229 sn_36 sn_229 51120547.54648899
Csub_36_229 sn_36 sn_229 2.061105369156723e-19
Rsub_36_62 sn_36 sn_62 36185644.05412246
Csub_36_62 sn_36 sn_62 2.911785537510594e-19
Rsub_36_174 sn_36 sn_174 56741511.92678241
Csub_36_174 sn_36 sn_174 1.856926815031994e-19
Rsub_36_117 sn_36 sn_117 23678319.4500096
Csub_36_117 sn_36 sn_117 4.449844307774862e-19
Rsub_36_130 sn_36 sn_130 19629419.98706917
Csub_36_130 sn_36 sn_130 5.367699865391278e-19
Rsub_36_87 sn_36 sn_87 19168465.32170818
Csub_36_87 sn_36 sn_87 5.496779906682196e-19
Rsub_36_115 sn_36 sn_115 55812333.13876603
Csub_36_115 sn_36 sn_115 1.887841433905509e-19
Rsub_36_175 sn_36 sn_175 21482578.35550486
Csub_36_175 sn_36 sn_175 4.904664294884349e-19
Rsub_36_82 sn_36 sn_82 12665267.66435503
Csub_36_82 sn_36 sn_82 8.319195283873668e-19
Rsub_36_133 sn_36 sn_133 30913157.55625441
Csub_36_133 sn_36 sn_133 3.408413871360818e-19
Rsub_36_98 sn_36 sn_98 34792621.20409033
Csub_36_98 sn_36 sn_98 3.02836726224907e-19
Rsub_36_106 sn_36 sn_106 56644848.36302299
Csub_36_106 sn_36 sn_106 1.860095632122493e-19
Rsub_36_99 sn_36 sn_99 8485279.679024069
Csub_36_99 sn_36 sn_99 1.241736737125658e-18
Rsub_36_183 sn_36 sn_183 62672599.0575729
Csub_36_183 sn_36 sn_183 1.681194598703474e-19
Rsub_36_92 sn_36 sn_92 40368195.9087848
Csub_36_92 sn_36 sn_92 2.610095216055242e-19
Rsub_36_156 sn_36 sn_156 2224408.089956989
Csub_36_156 sn_36 sn_156 4.736758308783949e-18
Rsub_36_65 sn_36 sn_65 18201567.08416511
Csub_36_65 sn_36 sn_65 5.788778215363921e-19
Rsub_36_197 sn_36 sn_197 103128438.5819096
Csub_36_197 sn_36 sn_197 1.021685545433854e-19
Rsub_36_195 sn_36 sn_195 25912367.16104191
Csub_36_195 sn_36 sn_195 4.066198752413148e-19
Rsub_36_180 sn_36 sn_180 1898704.943150433
Csub_36_180 sn_36 sn_180 5.549300084902767e-18
Rsub_36_126 sn_36 sn_126 3117175.668174003
Csub_36_126 sn_36 sn_126 3.380137863196566e-18
Rsub_36_80 sn_36 sn_80 8888022.866414772
Csub_36_80 sn_36 sn_80 1.185469891402314e-18
Rsub_36_94 sn_36 sn_94 36168785.59652584
Csub_36_94 sn_36 sn_94 2.913142735774372e-19
Rsub_36_209 sn_36 sn_209 52176348.85363466
Csub_36_209 sn_36 sn_209 2.019398392897708e-19
Rsub_36_42 sn_36 sn_42 27602089.24991288
Csub_36_42 sn_36 sn_42 3.817277528099891e-19
Rsub_36_228 sn_36 sn_228 5168761.218842322
Csub_36_228 sn_36 sn_228 2.038492988188361e-18
Rsub_36_39 sn_36 sn_39 61008632.64916275
Csub_36_39 sn_36 sn_39 1.727047967591943e-19
Rsub_36_196 sn_36 sn_196 24781645.93552722
Csub_36_196 sn_36 sn_196 4.251728690516393e-19
Rsub_36_77 sn_36 sn_77 18540926.26666927
Csub_36_77 sn_36 sn_77 5.682824768669335e-19
Rsub_36_37 sn_36 sn_37 17011761.7623747
Csub_36_37 sn_36 sn_37 6.193646283910337e-19
Rsub_36_91 sn_36 sn_91 18519339.93844691
Csub_36_91 sn_36 sn_91 5.689448726169677e-19
Rsub_36_220 sn_36 sn_220 40097718.59893112
Csub_36_220 sn_36 sn_220 2.627701492850237e-19
Rsub_36_53 sn_36 sn_53 8149934.640435637
Csub_36_53 sn_36 sn_53 1.292830429578365e-18
Rsub_36_213 sn_36 sn_213 11340201.09424436
Csub_36_213 sn_36 sn_213 9.291266896120315e-19
Rsub_36_58 sn_36 sn_58 17592360.6483039
Csub_36_58 sn_36 sn_58 5.98923800669459e-19
Rsub_36_128 sn_36 sn_128 3127874.597175044
Csub_36_128 sn_36 sn_128 3.368576064956721e-18
Rsub_36_200 sn_36 sn_200 15101984.11257879
Csub_36_200 sn_36 sn_200 6.976886893592955e-19
Rsub_36_81 sn_36 sn_81 21279774.37014536
Csub_36_81 sn_36 sn_81 4.951407528555495e-19
Rsub_36_148 sn_36 sn_148 51065979.34165563
Csub_36_148 sn_36 sn_148 2.063307830000856e-19
Rsub_36_151 sn_36 sn_151 11474221.26592051
Csub_36_151 sn_36 sn_151 9.182743872583601e-19
Rsub_36_141 sn_36 sn_141 630212.4594118308
Csub_36_141 sn_36 sn_141 1.671893874022035e-17
Rsub_36_172 sn_36 sn_172 10857623.90224434
Csub_36_172 sn_36 sn_172 9.704225894260382e-19
Rsub_36_93 sn_36 sn_93 578276.1519215537
Csub_36_93 sn_36 sn_93 1.822050497365026e-17
Rsub_36_132 sn_36 sn_132 1658876.544956578
Csub_36_132 sn_36 sn_132 6.351577839992787e-18
Rsub_36_169 sn_36 sn_169 3924216.171158548
Csub_36_169 sn_36 sn_169 2.684990592431943e-18
Rsub_36_139 sn_36 sn_139 3747475.592607196
Csub_36_139 sn_36 sn_139 2.811621648187854e-18
Rsub_36_218 sn_36 sn_218 3393532.137165845
Csub_36_218 sn_36 sn_218 3.104872173401513e-18
Rsub_36_223 sn_36 sn_223 17810023.46396978
Csub_36_223 sn_36 sn_223 5.916041336804316e-19
Rsub_36_56 sn_36 sn_56 3590688.301006216
Csub_36_56 sn_36 sn_56 2.934391018924525e-18
Rsub_36_135 sn_36 sn_135 5176467.945602658
Csub_36_135 sn_36 sn_135 2.035458079322332e-18
Rsub_36_45 sn_36 sn_45 164450.6825866244
Csub_36_45 sn_36 sn_45 6.407077998402292e-17
Rsub_36_212 sn_36 sn_212 2435276.592109269
Csub_36_212 sn_36 sn_212 4.326606487480759e-18
Rsub_36_64 sn_36 sn_64 6330103.326706504
Csub_36_64 sn_36 sn_64 1.664504188703669e-18
Rsub_36_131 sn_36 sn_131 6598954.807550188
Csub_36_131 sn_36 sn_131 1.596689750045673e-18
Rsub_36_210 sn_36 sn_210 4650579.31887876
Csub_36_210 sn_36 sn_210 2.265628167969903e-18
Rsub_36_57 sn_36 sn_57 26901469.84771049
Csub_36_57 sn_36 sn_57 3.916694352344741e-19
Rsub_36_224 sn_36 sn_224 216056.3058070736
Csub_36_224 sn_36 sn_224 4.876730379551386e-17
Rsub_36_66 sn_36 sn_66 21735722.65038266
Csub_36_66 sn_36 sn_66 4.847542302461476e-19
Rsub_36_74 sn_36 sn_74 1445450.267198994
Csub_36_74 sn_36 sn_74 7.289412677371248e-18
Rsub_36_158 sn_36 sn_158 235650.697615717
Csub_36_158 sn_36 sn_158 4.471229497233307e-17
Rsub_36_79 sn_36 sn_79 12525085.6666451
Csub_36_79 sn_36 sn_79 8.412304540390617e-19
Rsub_36_162 sn_36 sn_162 23068.24923948688
Csub_36_162 sn_36 sn_162 4.567526296791637e-16
Rsub_36_116 sn_36 sn_116 299023.8742499912
Csub_36_116 sn_36 sn_116 3.523626174885704e-17
Rsub_36_203 sn_36 sn_203 10380649.78033141
Csub_36_203 sn_36 sn_203 1.015011942912654e-18
Rsub_36_184 sn_36 sn_184 267490.7947847505
Csub_36_184 sn_36 sn_184 3.939007886498934e-17
Rsub_36_201 sn_36 sn_201 51073152.7237489
Csub_36_201 sn_36 sn_201 2.063018032041433e-19
Rsub_36_164 sn_36 sn_164 861998.0675701457
Csub_36_164 sn_36 sn_164 1.222332612871268e-17
Rsub_36_146 sn_36 sn_146 844071.4232595841
Csub_36_146 sn_36 sn_146 1.248292882791938e-17
Rsub_36_222 sn_36 sn_222 1208802.087058058
Csub_36_222 sn_36 sn_222 8.716467000709228e-18
Rsub_36_55 sn_36 sn_55 79669372.79747763
Csub_36_55 sn_36 sn_55 1.32252622711291e-19
Rsub_36_134 sn_36 sn_134 32001598.75404216
Csub_36_134 sn_36 sn_134 3.292486598313819e-19
Rsub_36_129 sn_36 sn_129 39218031.35635532
Csub_36_129 sn_36 sn_129 2.68664263294862e-19
Rsub_36_41 sn_36 sn_41 19351887.11748588
Csub_36_41 sn_36 sn_41 5.444680117377027e-19
Rsub_36_208 sn_36 sn_208 765068.3153437433
Csub_36_208 sn_36 sn_208 1.377195119823513e-17
Rsub_36_59 sn_36 sn_59 16791767.68379653
Csub_36_59 sn_36 sn_59 6.274791136133535e-19
Rsub_36_226 sn_36 sn_226 1586376.198265378
Csub_36_226 sn_36 sn_226 6.641856776312648e-18
Rsub_36_68 sn_36 sn_68 14497366.55522657
Csub_36_68 sn_36 sn_68 7.267860312486478e-19
Rsub_36_171 sn_36 sn_171 1418280.444055324
Csub_36_171 sn_36 sn_171 7.429055054938767e-18
Rsub_36_86 sn_36 sn_86 9986198.22974248
Csub_36_86 sn_36 sn_86 1.055104581325912e-18
Rsub_36_165 sn_36 sn_165 9598819.837293658
Csub_36_165 sn_36 sn_165 1.097685307238844e-18
Rsub_36_123 sn_36 sn_123 10902620.79678401
Csub_36_123 sn_36 sn_123 9.664174970973944e-19
Rsub_36_211 sn_36 sn_211 13990052.92816387
Csub_36_211 sn_36 sn_211 7.531410750432998e-19
Rsub_36_44 sn_36 sn_44 38624.83558745796
Csub_36_44 sn_36 sn_44 2.727903780553916e-16
Rsub_36_202 sn_36 sn_202 12905901.67900287
Csub_36_202 sn_36 sn_202 8.164081645974595e-19
Rsub_36_160 sn_36 sn_160 2490621.888883417
Csub_36_160 sn_36 sn_160 4.230462901357405e-18
Rsub_36_186 sn_36 sn_186 97345732.62708792
Csub_36_186 sn_36 sn_186 1.082377544231257e-19
Rsub_36_107 sn_36 sn_107 17561157.75748682
Csub_36_107 sn_36 sn_107 5.99987976176457e-19
Rsub_36_155 sn_36 sn_155 85266.66367742042
Csub_36_155 sn_36 sn_155 1.2357096018312e-16
Rsub_36_118 sn_36 sn_118 2996838.228442947
Csub_36_118 sn_36 sn_118 3.515866623105776e-18
Rsub_36_207 sn_36 sn_207 5386529.825483017
Csub_36_207 sn_36 sn_207 1.956080044778213e-18
Rsub_36_137 sn_36 sn_137 5505537.40186805
Csub_36_137 sn_36 sn_137 1.91379746119878e-18
Rsub_36_216 sn_36 sn_216 859222.5174506711
Csub_36_216 sn_36 sn_216 1.226281119062375e-17
Rsub_36_214 sn_36 sn_214 457536391.5086272
Csub_36_214 sn_36 sn_214 2.302873322816623e-20
Rsub_36_47 sn_36 sn_47 10667536.97270131
Csub_36_47 sn_36 sn_47 9.877147395123468e-19
Rsub_36_190 sn_36 sn_190 533649.0376401017
Csub_36_190 sn_36 sn_190 1.974421906357098e-17
Rsub_36_217 sn_36 sn_217 22007574.36679108
Csub_36_217 sn_36 sn_217 4.787662341438822e-19
Rsub_36_138 sn_36 sn_138 38670369.50507038
Csub_36_138 sn_36 sn_138 2.724691705065937e-19
Rsub_36_215 sn_36 sn_215 2464681.83547902
Csub_36_215 sn_36 sn_215 4.274987282560224e-18
Rsub_36_48 sn_36 sn_48 5353383.222308009
Csub_36_48 sn_36 sn_48 1.968191527616324e-18
Rsub_36_185 sn_36 sn_185 6471834.266891276
Csub_36_185 sn_36 sn_185 1.628052120576191e-18
Rsub_36_189 sn_36 sn_189 7656322.487599286
Csub_36_189 sn_36 sn_189 1.376180734196558e-18
Rsub_36_63 sn_36 sn_63 58583922.66183084
Csub_36_63 sn_36 sn_63 1.798528166686733e-19
Rsub_36_230 sn_36 0 86727.70658092141
Csub_36_230 sn_36 0 1.214892439522648e-16
Rsub_36_157 sn_36 sn_157 14095773.57368045
Csub_36_157 sn_36 sn_157 7.474923917551898e-19
Rsub_36_227 sn_36 sn_227 5324260.011344729
Csub_36_227 sn_36 sn_227 1.97895735365652e-18
Rsub_36_177 sn_36 sn_177 3415203.934112034
Csub_36_177 sn_36 sn_177 3.085169643015631e-18
Rsub_36_205 sn_36 sn_205 11979563.04600094
Csub_36_205 sn_36 sn_205 8.795382153564718e-19
Rsub_36_38 sn_36 sn_38 26721810.16020803
Csub_36_38 sn_36 sn_38 3.943027601445985e-19
Rsub_36_161 sn_36 sn_161 41843235.27130219
Csub_36_161 sn_36 sn_161 2.518085285211289e-19
Rsub_36_84 sn_36 sn_84 65934603.40264309
Csub_36_84 sn_36 sn_84 1.598020304738442e-19
Rsub_36_182 sn_36 sn_182 21280645.14974796
Csub_36_182 sn_36 sn_182 4.951204922635905e-19
Rsub_36_136 sn_36 sn_136 21774931.2245986
Csub_36_136 sn_36 sn_136 4.838813676861213e-19
Rsub_36_150 sn_36 sn_150 12260011.70225681
Csub_36_150 sn_36 sn_150 8.594187149340529e-19
Rsub_36_52 sn_36 sn_52 180147.7918649551
Csub_36_52 sn_36 sn_52 5.848799695601325e-17
Rsub_36_219 sn_36 sn_219 9201752.323054537
Csub_36_219 sn_36 sn_219 1.145051847986754e-18
Rsub_36_140 sn_36 sn_140 8539320.154658441
Csub_36_140 sn_36 sn_140 1.23387849517295e-18
Rsub_36_125 sn_36 sn_125 13491736.97259443
Csub_36_125 sn_36 sn_125 7.809582653169575e-19
Rsub_36_191 sn_36 sn_191 93297755.27881132
Csub_36_191 sn_36 sn_191 1.129339443456355e-19
Rsub_36_166 sn_36 sn_166 2210654.205960959
Csub_36_166 sn_36 sn_166 4.766228690954338e-18
Rsub_36_152 sn_36 sn_152 68461969.0326127
Csub_36_152 sn_36 sn_152 1.539027236743778e-19
Rsub_36_198 sn_36 sn_198 4355174.043578963
Csub_36_198 sn_36 sn_198 2.419302511633131e-18
Rsub_36_142 sn_36 sn_142 5900501.045050314
Csub_36_142 sn_36 sn_142 1.785693015183621e-18
Rsub_36_54 sn_36 sn_54 39534462.23515855
Csub_36_54 sn_36 sn_54 2.665138946258326e-19
Rsub_36_221 sn_36 sn_221 1031362.781925956
Csub_36_221 sn_36 sn_221 1.021607884914587e-17
Rsub_192_202 sn_192 sn_202 5568383.204660973
Csub_192_202 sn_192 sn_202 1.892197989069883e-18
Rsub_192_199 sn_192 sn_199 14363789.1020218
Csub_192_199 sn_192 sn_199 7.335448486045316e-19
Rsub_192_204 sn_192 sn_204 7151966.136131778
Csub_192_204 sn_192 sn_204 1.473228941759053e-18
Rsub_192_207 sn_192 sn_207 1537462.63225113
Csub_192_207 sn_192 sn_207 6.853163960676323e-18
Rsub_192_209 sn_192 sn_209 16985137.03991246
Csub_192_209 sn_192 sn_209 6.203355014134349e-19
Rsub_192_216 sn_192 sn_216 1129495.57738493
Csub_192_216 sn_192 sn_216 9.328485841993863e-18
Rsub_192_197 sn_192 sn_197 2633284.03783342
Csub_192_197 sn_192 sn_197 4.001271169706051e-18
Rsub_192_210 sn_192 sn_210 6097558.64846692
Csub_192_210 sn_192 sn_210 1.727983953853259e-18
Rsub_192_195 sn_192 sn_195 10659127.1107658
Csub_192_195 sn_192 sn_195 9.884940288954875e-19
Rsub_192_228 sn_192 sn_228 8609917.007602451
Csub_192_228 sn_192 sn_228 1.223761331604755e-18
Rsub_192_198 sn_192 sn_198 458494.5553231254
Csub_192_198 sn_192 sn_198 2.298060768639746e-17
Rsub_192_213 sn_192 sn_213 190649.5068368017
Csub_192_213 sn_192 sn_213 5.526625102287496e-17
Rsub_192_206 sn_192 sn_206 825411.1524207058
Csub_192_206 sn_192 sn_206 1.276513343844382e-17
Rsub_192_196 sn_192 sn_196 180372.1505054317
Csub_192_196 sn_192 sn_196 5.841524577217205e-17
Rsub_192_201 sn_192 sn_201 1967684.027876024
Csub_192_201 sn_192 sn_201 5.354763952423495e-18
Rsub_192_214 sn_192 sn_214 511909.5067238098
Csub_192_214 sn_192 sn_214 2.058270722429608e-17
Rsub_192_224 sn_192 sn_224 1390083.610181369
Csub_192_224 sn_192 sn_224 7.579748027426402e-18
Rsub_192_203 sn_192 sn_203 39156.28520091421
Csub_192_203 sn_192 sn_203 2.690879241523146e-16
Rsub_192_226 sn_192 sn_226 80425.05713178695
Csub_192_226 sn_192 sn_226 1.310099598059918e-16
Rsub_192_229 sn_192 sn_229 2215477.168391592
Csub_192_229 sn_192 sn_229 4.755852893703866e-18
Rsub_192_212 sn_192 sn_212 94200.41339141718
Csub_192_212 sn_192 sn_212 1.118517756227809e-16
Rsub_192_222 sn_192 sn_222 18800.65501050133
Csub_192_222 sn_192 sn_222 5.604317241258202e-16
Rsub_192_215 sn_192 sn_215 566978.1955974104
Csub_192_215 sn_192 sn_215 1.858357796480688e-17
Rsub_192_230 sn_192 0 51172.90257479686
Csub_192_230 sn_192 0 2.05899665097741e-16
Rsub_192_218 sn_192 sn_218 102978.6959182325
Csub_192_218 sn_192 sn_218 1.023171191699321e-16
Rsub_192_227 sn_192 sn_227 154557.8322633156
Csub_192_227 sn_192 sn_227 6.817178623648985e-17
Rsub_192_219 sn_192 sn_219 4417823.661788109
Csub_192_219 sn_192 sn_219 2.384994130337329e-18
Rsub_192_208 sn_192 sn_208 2170268.270161825
Csub_192_208 sn_192 sn_208 4.854922152755039e-18
Rsub_192_221 sn_192 sn_221 108860.4247456744
Csub_192_221 sn_192 sn_221 9.678892514746199e-17
Rsub_192_211 sn_192 sn_211 487082.9929025869
Csub_192_211 sn_192 sn_211 2.163180331844848e-17
Rsub_192_200 sn_192 sn_200 360193.1441136778
Csub_192_200 sn_192 sn_200 2.925231552687372e-17
Rsub_25_80 sn_25 sn_80 43836926.16489919
Csub_25_80 sn_25 sn_80 2.403563484947698e-19
Rsub_25_134 sn_25 sn_134 9545918.694691194
Csub_25_134 sn_25 sn_134 1.103768410272517e-18
Rsub_25_161 sn_25 sn_161 24878761.79810957
Csub_25_161 sn_25 sn_161 4.235131791418423e-19
Rsub_25_78 sn_25 sn_78 27210793.19827811
Csub_25_78 sn_25 sn_78 3.872170658699044e-19
Rsub_25_183 sn_25 sn_183 20867684.3303926
Csub_25_183 sn_25 sn_183 5.049186740324708e-19
Rsub_25_185 sn_25 sn_185 45045220.71189201
Csub_25_185 sn_25 sn_185 2.339090215501675e-19
Rsub_25_126 sn_25 sn_126 42961059.90289026
Csub_25_126 sn_25 sn_126 2.452566004201667e-19
Rsub_25_129 sn_25 sn_129 8791521.548769994
Csub_25_129 sn_25 sn_129 1.198482360963347e-18
Rsub_25_97 sn_25 sn_97 17662496.27642194
Csub_25_97 sn_25 sn_97 5.965455469788484e-19
Rsub_25_163 sn_25 sn_163 45407709.07598985
Csub_25_163 sn_25 sn_163 2.320417329268293e-19
Rsub_25_120 sn_25 sn_120 2749070.437096162
Csub_25_120 sn_25 sn_120 3.832744101442403e-18
Rsub_25_82 sn_25 sn_82 32999635.42632225
Csub_25_82 sn_25 sn_82 3.192909062815144e-19
Rsub_25_188 sn_25 sn_188 42739397.44205445
Csub_25_188 sn_25 sn_188 2.465285926530723e-19
Rsub_25_79 sn_25 sn_79 14895798.99399739
Csub_25_79 sn_25 sn_79 7.073459776461755e-19
Rsub_25_112 sn_25 sn_112 44658566.45685431
Csub_25_112 sn_25 sn_112 2.359342078839353e-19
Rsub_25_123 sn_25 sn_123 15293018.57979398
Csub_25_123 sn_25 sn_123 6.889734323707299e-19
Rsub_25_100 sn_25 sn_100 45069386.60283186
Csub_25_100 sn_25 sn_100 2.337836011632774e-19
Rsub_25_83 sn_25 sn_83 14380247.89188276
Csub_25_83 sn_25 sn_83 7.327052761154101e-19
Rsub_25_131 sn_25 sn_131 7503026.670583206
Csub_25_131 sn_25 sn_131 1.404297754070359e-18
Rsub_25_95 sn_25 sn_95 2225855.215405289
Csub_25_95 sn_25 sn_95 4.733678735843335e-18
Rsub_25_66 sn_25 sn_66 9416231.425856737
Csub_25_66 sn_25 sn_66 1.118970321109258e-18
Rsub_25_62 sn_25 sn_62 27133730.91418497
Csub_25_62 sn_25 sn_62 3.883167978466884e-19
Rsub_25_229 sn_25 sn_229 9621530.32564125
Csub_25_229 sn_25 sn_229 1.095094350443444e-18
Rsub_25_127 sn_25 sn_127 44458671.13088565
Csub_25_127 sn_25 sn_127 2.369950165899191e-19
Rsub_25_91 sn_25 sn_91 45069386.60283186
Csub_25_91 sn_25 sn_91 2.337836011632774e-19
Rsub_25_34 sn_25 sn_34 4481881.54124253
Csub_25_34 sn_25 sn_34 2.350906289082538e-18
Rsub_25_74 sn_25 sn_74 42876149.02031263
Csub_25_74 sn_25 sn_74 2.457423006258871e-19
Rsub_25_58 sn_25 sn_58 6727853.142531495
Csub_25_58 sn_25 sn_58 1.566098914321044e-18
Rsub_25_195 sn_25 sn_195 731085.9384943587
Csub_25_195 sn_25 sn_195 1.441209979216596e-17
Rsub_25_149 sn_25 sn_149 27134396.45645257
Csub_25_149 sn_25 sn_149 3.883072733583659e-19
Rsub_25_164 sn_25 sn_164 9112498.151580464
Csub_25_164 sn_25 sn_164 1.156267285541513e-18
Rsub_25_169 sn_25 sn_169 22144521.51891595
Csub_25_169 sn_25 sn_169 4.758054263321828e-19
Rsub_25_165 sn_25 sn_165 44851893.58437315
Csub_25_165 sn_25 sn_165 2.349172500913321e-19
Rsub_25_42 sn_25 sn_42 914711.0280174986
Csub_25_42 sn_25 sn_42 1.151892037976876e-17
Rsub_25_64 sn_25 sn_64 505250.3848859178
Csub_25_64 sn_25 sn_64 2.085398411840709e-17
Rsub_25_197 sn_25 sn_197 2650703.600403106
Csub_25_197 sn_25 sn_197 3.974976116012241e-18
Rsub_25_30 sn_25 sn_30 6274504.05807766
Csub_25_30 sn_25 sn_30 1.679253595934098e-18
Rsub_25_76 sn_25 sn_76 12830501.95709526
Csub_25_76 sn_25 sn_76 8.212058684425307e-19
Rsub_25_217 sn_25 sn_217 45431874.9669297
Csub_25_217 sn_25 sn_217 2.319183064731449e-19
Rsub_25_50 sn_25 sn_50 30153818.65801857
Csub_25_50 sn_25 sn_50 3.494245164012789e-19
Rsub_25_167 sn_25 sn_167 39864341.89656002
Csub_25_167 sn_25 sn_167 2.643084772243341e-19
Rsub_25_92 sn_25 sn_92 96180245.94062778
Csub_25_92 sn_25 sn_92 1.095493507963599e-19
Rsub_25_213 sn_25 sn_213 1378832.587142656
Csub_25_213 sn_25 sn_213 7.64159739222923e-18
Rsub_25_122 sn_25 sn_122 1070279.399693037
Csub_25_122 sn_25 sn_122 9.844610206691759e-18
Rsub_25_27 sn_25 sn_27 370050655.7287081
Csub_25_27 sn_25 sn_27 2.847308426323806e-20
Rsub_25_199 sn_25 sn_199 21778075.57376797
Csub_25_199 sn_25 sn_199 4.838115042139608e-19
Rsub_25_32 sn_25 sn_32 7038659.043736452
Csub_25_32 sn_25 sn_32 1.496944721538428e-18
Rsub_25_117 sn_25 sn_117 4805279.360017962
Csub_25_117 sn_25 sn_117 2.192689064011175e-18
Rsub_25_132 sn_25 sn_132 6083013.732802825
Csub_25_132 sn_25 sn_132 1.732115685587181e-18
Rsub_25_146 sn_25 sn_146 4859767.04293077
Csub_25_146 sn_25 sn_146 2.168104645583132e-18
Rsub_25_77 sn_25 sn_77 93741871.78958894
Csub_25_77 sn_25 sn_77 1.123989024443631e-19
Rsub_25_140 sn_25 sn_140 5549170.002093341
Csub_25_140 sn_25 sn_140 1.898749452306429e-18
Rsub_25_103 sn_25 sn_103 1433353.388998004
Csub_25_103 sn_25 sn_103 7.350932144930152e-18
Rsub_25_182 sn_25 sn_182 4358980.591687456
Csub_25_182 sn_25 sn_182 2.417189817803502e-18
Rsub_25_142 sn_25 sn_142 535397.9787201508
Csub_25_142 sn_25 sn_142 1.967972222722446e-17
Rsub_25_137 sn_25 sn_137 57368332.91865904
Csub_25_137 sn_25 sn_137 1.836637560510846e-19
Rsub_25_138 sn_25 sn_138 1422692.328901279
Csub_25_138 sn_25 sn_138 7.406016949825787e-18
Rsub_25_221 sn_25 sn_221 603973.6304228362
Csub_25_221 sn_25 sn_221 1.744527073947502e-17
Rsub_25_54 sn_25 sn_54 4300810.76241696
Csub_25_54 sn_25 sn_54 2.449883076536186e-18
Rsub_25_133 sn_25 sn_133 8363152.84026005
Csub_25_133 sn_25 sn_133 1.259869776803262e-18
Rsub_25_227 sn_25 sn_227 1183706.013280394
Csub_25_227 sn_25 sn_227 8.901267193051028e-18
Rsub_25_148 sn_25 sn_148 1904227.959765113
Csub_25_148 sn_25 sn_148 5.533204912887468e-18
Rsub_25_144 sn_25 sn_144 1970671.458633199
Csub_25_144 sn_25 sn_144 5.346646421488139e-18
Rsub_25_181 sn_25 sn_181 3291408.70565202
Csub_25_181 sn_25 sn_181 3.201207885285322e-18
Rsub_25_51 sn_25 sn_51 30190028.47121874
Csub_25_51 sn_25 sn_51 3.49005417874144e-19
Rsub_25_218 sn_25 sn_218 296318.2323435261
Csub_25_218 sn_25 sn_218 3.555799931343711e-17
Rsub_25_139 sn_25 sn_139 8503255.319251271
Csub_25_139 sn_25 sn_139 1.239111740932384e-18
Rsub_25_186 sn_25 sn_186 826683.8736775827
Csub_25_186 sn_25 sn_186 1.274548087572755e-17
Rsub_25_107 sn_25 sn_107 5815171.825783949
Csub_25_107 sn_25 sn_107 1.811895472376617e-18
Rsub_25_52 sn_25 sn_52 12407.23284086123
Csub_25_52 sn_25 sn_52 8.492210662420864e-16
Rsub_25_222 sn_25 sn_222 58413.72683654718
Csub_25_222 sn_25 sn_222 1.803768407332253e-16
Rsub_25_170 sn_25 sn_170 2089449.778314697
Csub_25_170 sn_25 sn_170 5.042707229234527e-18
Rsub_25_36 sn_25 sn_36 3996108.991208887
Csub_25_36 sn_25 sn_36 2.636685717383936e-18
Rsub_25_203 sn_25 sn_203 626064.6691421489
Csub_25_203 sn_25 sn_203 1.682970469594999e-17
Rsub_25_212 sn_25 sn_212 684810.1194956691
Csub_25_212 sn_25 sn_212 1.538599270406464e-17
Rsub_25_45 sn_25 sn_45 308910.9891653326
Csub_25_45 sn_25 sn_45 3.410847743131197e-17
Rsub_25_166 sn_25 sn_166 93783.61585724716
Csub_25_166 sn_25 sn_166 1.123488725180753e-16
Rsub_25_57 sn_25 sn_57 4706355.089297135
Csub_25_57 sn_25 sn_57 2.238777844491874e-18
Rsub_25_224 sn_25 sn_224 685952.7482330333
Csub_25_224 sn_25 sn_224 1.536036342061644e-17
Rsub_25_158 sn_25 sn_158 3222933.351453339
Csub_25_158 sn_25 sn_158 3.269221654080658e-18
Rsub_25_211 sn_25 sn_211 4535067.105776411
Csub_25_211 sn_25 sn_211 2.323335742663975e-18
Rsub_25_44 sn_25 sn_44 412319.9823246871
Csub_25_44 sn_25 sn_44 2.555414230187103e-17
Rsub_25_35 sn_25 sn_35 426417.2522929349
Csub_25_35 sn_25 sn_35 2.470932741481055e-17
Rsub_25_202 sn_25 sn_202 89510460.04122747
Csub_25_202 sn_25 sn_202 1.177123153805379e-19
Rsub_25_192 sn_25 sn_192 51641.64227614037
Csub_25_192 sn_25 sn_192 2.04030759631711e-16
Rsub_25_59 sn_25 sn_59 598878.3056030254
Csub_25_59 sn_25 sn_59 1.75936970894622e-17
Rsub_25_226 sn_25 sn_226 174000.3831498044
Csub_25_226 sn_25 sn_226 6.055436954502963e-17
Rsub_25_160 sn_25 sn_160 16715.53259497646
Csub_25_160 sn_25 sn_160 6.30340878602728e-16
Rsub_25_39 sn_25 sn_39 4532408.867648521
Csub_25_39 sn_25 sn_39 2.324698368992575e-18
Rsub_25_206 sn_25 sn_206 80928819.31421828
Csub_25_206 sn_25 sn_206 1.301944547259552e-19
Rsub_25_215 sn_25 sn_215 799054.8087817652
Csub_25_215 sn_25 sn_215 1.318618370909233e-17
Rsub_25_48 sn_25 sn_48 482145.4681877719
Csub_25_48 sn_25 sn_48 2.185332891716937e-17
Rsub_25_162 sn_25 sn_162 2665240.610223597
Csub_25_162 sn_25 sn_162 3.953295421739074e-18
Rsub_25_196 sn_25 sn_196 3514303.166630446
Csub_25_196 sn_25 sn_196 2.998171473160781e-18
Rsub_25_38 sn_25 sn_38 20532945.50541276
Csub_25_38 sn_25 sn_38 5.131501225409887e-19
Rsub_25_155 sn_25 sn_155 581165.5084784559
Csub_25_155 sn_25 sn_155 1.812991884156283e-17
Rsub_25_63 sn_25 sn_63 7794472.81931597
Csub_25_63 sn_25 sn_63 1.351789113449582e-18
Rsub_25_230 sn_25 0 91659.56217379187
Csub_25_230 sn_25 0 1.149523656053715e-16
Rsub_25_40 sn_25 sn_40 228543543.1143977
Csub_25_40 sn_25 sn_40 4.610273980462427e-20
Rsub_25_207 sn_25 sn_207 3948025.992625359
Csub_25_207 sn_25 sn_207 2.668797906070382e-18
Rsub_25_216 sn_25 sn_216 2544082.263336541
Csub_25_216 sn_25 sn_216 4.141565567306577e-18
Rsub_25_49 sn_25 sn_49 3445085.010621686
Csub_25_49 sn_25 sn_49 3.058410306202757e-18
Rsub_25_157 sn_25 sn_157 16022500.82979245
Csub_25_157 sn_25 sn_157 6.576054271526904e-19
Rsub_25_115 sn_25 sn_115 44731064.12967388
Csub_25_115 sn_25 sn_115 2.35551818568078e-19
Rsub_25_31 sn_25 sn_31 6932413.980762784
Csub_25_31 sn_25 sn_31 1.519886655855866e-18
Rsub_25_198 sn_25 sn_198 2513707.432278537
Csub_25_198 sn_25 sn_198 4.191610911807369e-18
Rsub_25_37 sn_25 sn_37 21987153.11832174
Csub_25_37 sn_25 sn_37 4.792109030909519e-19
Rsub_25_204 sn_25 sn_204 20654242.21456473
Csub_25_204 sn_25 sn_204 5.101365323778376e-19
Rsub_25_125 sn_25 sn_125 7805466.873652484
Csub_25_125 sn_25 sn_125 1.349885109088877e-18
Rsub_25_214 sn_25 sn_214 4930257.466563109
Csub_25_214 sn_25 sn_214 2.137106139727628e-18
Rsub_25_135 sn_25 sn_135 6988177.156983235
Csub_25_135 sn_25 sn_135 1.50775849918186e-18
Rsub_25_56 sn_25 sn_56 2025686.133463834
Csub_25_56 sn_25 sn_56 5.201439318841106e-18
Rsub_25_180 sn_25 sn_180 5282794.571135329
Csub_25_180 sn_25 sn_180 1.994490484222179e-18
Rsub_25_200 sn_25 sn_200 3593725.361863694
Csub_25_200 sn_25 sn_200 2.931911162172341e-18
Rsub_25_33 sn_25 sn_33 4807410.463019994
Csub_25_33 sn_25 sn_33 2.191717055009076e-18
Rsub_25_191 sn_25 sn_191 6443869.556896829
Csub_25_191 sn_25 sn_191 1.635117441344367e-18
Rsub_25_174 sn_25 sn_174 26750463.43621198
Csub_25_174 sn_25 sn_174 3.938804098611171e-19
Rsub_25_220 sn_25 sn_220 101342168.2561855
Csub_25_220 sn_25 sn_220 1.039693908620008e-19
Rsub_25_53 sn_25 sn_53 7239974.595261457
Csub_25_53 sn_25 sn_53 1.455320507495441e-18
Rsub_25_177 sn_25 sn_177 4968270.34797461
Csub_25_177 sn_25 sn_177 2.120754863214189e-18
Rsub_25_153 sn_25 sn_153 44755230.02061374
Csub_25_153 sn_25 sn_153 2.354246307610758e-19
Rsub_25_85 sn_25 sn_85 44755230.02061374
Csub_25_85 sn_25 sn_85 2.354246307610758e-19
Rsub_25_141 sn_25 sn_141 1496700.720930627
Csub_25_141 sn_25 sn_141 7.03980652570179e-18
Rsub_25_84 sn_25 sn_84 2569036.978856995
Csub_25_84 sn_25 sn_84 4.101335865907951e-18
Rsub_25_93 sn_25 sn_93 185653.0061574194
Csub_25_93 sn_25 sn_93 5.675363798470291e-17
Rsub_25_150 sn_25 sn_150 1210276.850354442
Csub_25_150 sn_25 sn_150 8.705845690714716e-18
Rsub_25_208 sn_25 sn_208 864027.6598258114
Csub_25_208 sn_25 sn_208 1.219461365895875e-17
Rsub_25_41 sn_25 sn_41 6311222.352589327
Csub_25_41 sn_25 sn_41 1.669483804180527e-18
Rsub_25_190 sn_25 sn_190 402398.6267256067
Csub_25_190 sn_25 sn_190 2.618419348984203e-17
Rsub_25_116 sn_25 sn_116 11405123.74465251
Csub_25_116 sn_25 sn_116 9.238377187420011e-19
Rsub_25_89 sn_25 sn_89 23181391.91593476
Csub_25_89 sn_25 sn_89 4.545233323537955e-19
Rsub_25_96 sn_25 sn_96 24601624.29127964
Csub_25_96 sn_25 sn_96 4.282840587060258e-19
Rsub_25_43 sn_25 sn_43 1838265.611023996
Csub_25_43 sn_25 sn_43 5.73175249487516e-18
Rsub_25_184 sn_25 sn_184 7849872.094892939
Csub_25_184 sn_25 sn_184 1.342249067865061e-18
Rsub_196_224 sn_196 sn_224 13625937.59018157
Csub_196_224 sn_196 sn_224 7.732666785309704e-19
Rsub_196_229 sn_196 sn_229 12433350.87372248
Csub_196_229 sn_196 sn_229 8.474371558594512e-19
Rsub_196_219 sn_196 sn_219 7012502.167519155
Csub_196_219 sn_196 sn_219 1.502528377250761e-18
Rsub_196_228 sn_196 sn_228 50361716.71866038
Csub_196_228 sn_196 sn_228 2.092161305995741e-19
Rsub_196_216 sn_196 sn_216 871723.3845940216
Csub_196_216 sn_196 sn_216 1.208695750101627e-17
Rsub_196_202 sn_196 sn_202 13194576.43741977
Csub_196_202 sn_196 sn_202 7.985465507137137e-19
Rsub_196_204 sn_196 sn_204 4046387.207840052
Csub_196_204 sn_196 sn_204 2.603923688226155e-18
Rsub_196_210 sn_196 sn_210 3951427.013436942
Csub_196_210 sn_196 sn_210 2.666500853084312e-18
Rsub_196_197 sn_196 sn_197 4045792.489980103
Csub_196_197 sn_196 sn_197 2.604306456231971e-18
Rsub_196_213 sn_196 sn_213 366123.088194994
Csub_196_213 sn_196 sn_213 2.877852788300082e-17
Rsub_196_208 sn_196 sn_208 2497494.22965783
Csub_196_208 sn_196 sn_208 4.218821960470978e-18
Rsub_196_230 sn_196 0 47328.04850764544
Csub_196_230 sn_196 0 2.22626620671417e-16
Rsub_196_221 sn_196 sn_221 15240.6727644872
Csub_196_221 sn_196 sn_221 6.913397895912716e-16
Rsub_196_203 sn_196 sn_203 27962.09287449577
Csub_196_203 sn_196 sn_203 3.768131215900627e-16
Rsub_196_212 sn_196 sn_212 4001.626902142268
Csub_196_212 sn_196 sn_212 2.63304994690767e-15
Rsub_196_227 sn_196 sn_227 22237.24496297038
Csub_196_227 sn_196 sn_227 4.73821443248722e-16
Rsub_196_211 sn_196 sn_211 83329.59496544572
Csub_196_211 sn_196 sn_211 1.264434743334486e-16
Rsub_196_226 sn_196 sn_226 198001.4130624434
Csub_196_226 sn_196 sn_226 5.321418337003041e-17
Rsub_196_218 sn_196 sn_218 558162.1531747145
Csub_196_218 sn_196 sn_218 1.88771012909073e-17
Rsub_196_198 sn_196 sn_198 879600.1455777978
Csub_196_198 sn_196 sn_198 1.19787195979927e-17
Rsub_196_215 sn_196 sn_215 317417.7258051845
Csub_196_215 sn_196 sn_215 3.319437651285039e-17
Rsub_196_206 sn_196 sn_206 1225711.807692386
Csub_196_206 sn_196 sn_206 8.596216040430217e-18
Rsub_196_214 sn_196 sn_214 283113.0024607154
Csub_196_214 sn_196 sn_214 3.721652983314335e-17
Rsub_196_200 sn_196 sn_200 51827.81747847628
Csub_196_200 sn_196 sn_200 2.03297843028133e-16
Rsub_196_222 sn_196 sn_222 172580.4346759195
Csub_196_222 sn_196 sn_222 6.105259568974868e-17
Rsub_196_207 sn_196 sn_207 1596081.60626342
Csub_196_207 sn_196 sn_207 6.601469161026746e-18
Rsub_29_118 sn_29 sn_118 87528856.98415926
Csub_29_118 sn_29 sn_118 1.203772546022949e-19
Rsub_29_139 sn_29 sn_139 87528856.98415926
Csub_29_139 sn_29 sn_139 1.203772546022949e-19
Rsub_29_117 sn_29 sn_117 32791611.45778684
Csub_29_117 sn_29 sn_117 3.2131642922745e-19
Rsub_29_68 sn_29 sn_68 69842362.68389094
Csub_29_68 sn_29 sn_68 1.508609259099453e-19
Rsub_29_122 sn_29 sn_122 51593747.84265804
Csub_29_122 sn_29 sn_122 2.042201612172545e-19
Rsub_29_175 sn_29 sn_175 48541121.04991721
Csub_29_175 sn_29 sn_175 2.170630441640361e-19
Rsub_29_130 sn_29 sn_130 87528856.98415926
Csub_29_130 sn_29 sn_130 1.203772546022949e-19
Rsub_29_92 sn_29 sn_92 13735645.67591167
Csub_29_92 sn_29 sn_92 7.670905140417195e-19
Rsub_29_112 sn_29 sn_112 1628977.298549121
Csub_29_112 sn_29 sn_112 6.468158587363074e-18
Rsub_29_169 sn_29 sn_169 73302908.57973401
Csub_29_169 sn_29 sn_169 1.43738955334482e-19
Rsub_29_126 sn_29 sn_126 85160599.67205334
Csub_29_126 sn_29 sn_126 1.237248627041749e-19
Rsub_29_157 sn_29 sn_157 18671461478.09786
Rsub_29_176 sn_29 sn_176 84773945.41701564
Csub_29_176 sn_29 sn_176 1.242891722262008e-19
Rsub_29_115 sn_29 sn_115 95756437.45402452
Csub_29_115 sn_29 sn_115 1.100342053482188e-19
Rsub_29_210 sn_29 sn_210 10310559.63992625
Csub_29_210 sn_29 sn_210 1.021911891322455e-18
Rsub_29_144 sn_29 sn_144 34718063.16139594
Csub_29_144 sn_29 sn_144 3.034870768351454e-19
Rsub_29_95 sn_29 sn_95 23091780.6316418
Csub_29_95 sn_29 sn_95 4.562871815866921e-19
Rsub_29_120 sn_29 sn_120 9100717.758428518
Csub_29_120 sn_29 sn_120 1.157764011796956e-18
Rsub_29_186 sn_29 sn_186 5216627.215410471
Csub_29_186 sn_29 sn_186 2.019788470049021e-18
Rsub_29_127 sn_29 sn_127 83547705.8720244
Csub_29_127 sn_29 sn_127 1.261133790839145e-19
Rsub_29_128 sn_29 sn_128 36292905.74784064
Csub_29_128 sn_29 sn_128 2.90317991494988e-19
Rsub_29_64 sn_29 sn_64 5551624.199132259
Csub_29_64 sn_29 sn_64 1.89791007537522e-18
Rsub_29_222 sn_29 sn_222 380598.5164116857
Csub_29_222 sn_29 sn_222 2.768398469223906e-17
Rsub_29_132 sn_29 sn_132 28743461.82200984
Csub_29_132 sn_29 sn_132 3.665697461035072e-19
Rsub_29_71 sn_29 sn_71 42935903.573063
Csub_29_71 sn_29 sn_71 2.454002973129544e-19
Rsub_29_150 sn_29 sn_150 84798111.3079555
Csub_29_150 sn_29 sn_150 1.242537521144236e-19
Rsub_29_40 sn_29 sn_40 568489125.8346671
Csub_29_40 sn_29 sn_40 1.853418653656765e-20
Rsub_29_156 sn_29 sn_156 40761671.43219339
Csub_29_156 sn_29 sn_156 2.584899767851112e-19
Rsub_29_141 sn_29 sn_141 6764974.129149034
Csub_29_141 sn_29 sn_141 1.55750536529478e-18
Rsub_29_53 sn_29 sn_53 84798111.3079555
Csub_29_53 sn_29 sn_53 1.242537521144236e-19
Rsub_29_215 sn_29 sn_215 30854340.65852371
Csub_29_215 sn_29 sn_215 3.41491124987603e-19
Rsub_29_227 sn_29 sn_227 9372190.858513897
Csub_29_227 sn_29 sn_227 1.124228439357745e-18
Rsub_29_79 sn_29 sn_79 32389400.64573922
Csub_29_79 sn_29 sn_79 3.253065290547777e-19
Rsub_29_168 sn_29 sn_168 4507173.656723781
Csub_29_168 sn_29 sn_168 2.337714120802008e-18
Rsub_29_123 sn_29 sn_123 2336389.452886724
Csub_29_123 sn_29 sn_123 4.509729098978622e-18
Rsub_29_44 sn_29 sn_44 2900248.92964696
Csub_29_44 sn_29 sn_44 3.632958327998618e-18
Rsub_29_74 sn_29 sn_74 281252.6474574103
Csub_29_74 sn_29 sn_74 3.746269980916545e-17
Rsub_29_52 sn_29 sn_52 20067.86508220851
Csub_29_52 sn_29 sn_52 5.250425722450811e-16
Rsub_29_131 sn_29 sn_131 27414474.72990765
Csub_29_131 sn_29 sn_131 3.843401562874115e-19
Rsub_29_171 sn_29 sn_171 94858.14743403006
Csub_29_171 sn_29 sn_171 1.110762099750861e-16
Rsub_29_137 sn_29 sn_137 37809781.626982
Csub_29_137 sn_29 sn_137 2.786708372499804e-19
Rsub_29_216 sn_29 sn_216 62687.99967592769
Csub_29_216 sn_29 sn_216 1.680781578085037e-16
Rsub_29_93 sn_29 sn_93 43852.60942596221
Csub_29_93 sn_29 sn_93 2.402703884707041e-16
Rsub_29_164 sn_29 sn_164 3444618.043367685
Csub_29_164 sn_29 sn_164 3.058824917472952e-18
Rsub_29_84 sn_29 sn_84 2241659.262271757
Csub_29_84 sn_29 sn_84 4.70030556363506e-18
Rsub_29_107 sn_29 sn_107 7639620.439263575
Csub_29_107 sn_29 sn_107 1.379189396383896e-18
Rsub_29_191 sn_29 sn_191 37385562.27114044
Csub_29_191 sn_29 sn_191 2.818329553482087e-19
Rsub_29_146 sn_29 sn_146 2039204.959754164
Csub_29_146 sn_29 sn_146 5.166956588561959e-18
Rsub_29_225 sn_29 sn_225 85216658.93734604
Csub_29_225 sn_29 sn_225 1.236434710492083e-19
Rsub_29_192 sn_29 sn_192 6049425.301194414
Csub_29_192 sn_29 sn_192 1.741732970923643e-18
Rsub_29_155 sn_29 sn_155 2377711.248581876
Csub_29_155 sn_29 sn_155 4.431355366852982e-18
Rsub_29_177 sn_29 sn_177 5393718.4459389
Csub_29_177 sn_29 sn_177 1.953473027529505e-18
Rsub_29_31 sn_29 sn_31 6261561.434405016
Csub_29_31 sn_29 sn_31 1.682724606730812e-18
Rsub_29_203 sn_29 sn_203 86973041.49254256
Csub_29_203 sn_29 sn_203 1.211465451985308e-19
Rsub_29_36 sn_29 sn_36 13274757.11491324
Csub_29_36 sn_29 sn_36 7.93723260698534e-19
Rsub_29_184 sn_29 sn_184 21350750.27542274
Csub_29_184 sn_29 sn_184 4.934947655848305e-19
Rsub_29_224 sn_29 sn_224 1198368.397349209
Csub_29_224 sn_29 sn_224 8.792357613515762e-18
Rsub_29_66 sn_29 sn_66 52464755.99219904
Csub_29_66 sn_29 sn_66 2.008297437578222e-19
Rsub_29_162 sn_29 sn_162 3648442.198696723
Csub_29_162 sn_29 sn_162 2.887940366985611e-18
Rsub_29_103 sn_29 sn_103 84798111.3079555
Csub_29_103 sn_29 sn_103 1.242537521144236e-19
Rsub_29_208 sn_29 sn_208 1319419.205906644
Csub_29_208 sn_29 sn_208 7.985698142835368e-18
Rsub_29_170 sn_29 sn_170 33986840.20205826
Csub_29_170 sn_29 sn_170 3.100165664000711e-19
Rsub_29_230 sn_29 0 583030.7195705086
Csub_29_230 sn_29 0 1.807191825156612e-17
Rsub_29_72 sn_29 sn_72 64882566.60244432
Csub_29_72 sn_29 sn_72 1.623931366154227e-19
Rsub_29_160 sn_29 sn_160 10722439.68834431
Csub_29_160 sn_29 sn_160 9.826572877517368e-19
Rsub_29_80 sn_29 sn_80 15283293.18899015
Csub_29_80 sn_29 sn_80 6.894118546270069e-19
Rsub_29_86 sn_29 sn_86 69691706.65453775
Csub_29_86 sn_29 sn_86 1.511870494786334e-19
Rsub_29_47 sn_29 sn_47 18382810.09870539
Csub_29_47 sn_29 sn_47 5.73170448133609e-19
Rsub_29_214 sn_29 sn_214 17723565.84383612
Csub_29_214 sn_29 sn_214 5.9449004760486e-19
Rsub_29_223 sn_29 sn_223 139684725.3677819
Csub_29_223 sn_29 sn_223 7.543046295497266e-20
Rsub_29_56 sn_29 sn_56 5343131.068936299
Csub_29_56 sn_29 sn_56 1.971968002710363e-18
Rsub_29_135 sn_29 sn_135 14324100.93623882
Csub_29_135 sn_29 sn_135 7.355773007416855e-19
Rsub_29_166 sn_29 sn_166 12571166.66909097
Csub_29_166 sn_29 sn_166 8.38146830726245e-19
Rsub_29_59 sn_29 sn_59 28300813.1536153
Csub_29_59 sn_29 sn_59 3.723032071565765e-19
Rsub_29_226 sn_29 sn_226 32212095.9698089
Csub_29_226 sn_29 sn_226 3.27097110107502e-19
Rsub_29_180 sn_29 sn_180 42930794.75239905
Csub_29_180 sn_29 sn_180 2.454295002689463e-19
Rsub_29_116 sn_29 sn_116 17491836.49476391
Csub_29_116 sn_29 sn_116 6.023657667612e-19
Rsub_29_35 sn_29 sn_35 50344675.11387912
Csub_29_35 sn_29 sn_35 2.092869499782566e-19
Rsub_29_181 sn_29 sn_181 36424265.77958851
Csub_29_181 sn_29 sn_181 2.892709922003274e-19
Rsub_29_42 sn_29 sn_42 10329814.50944635
Csub_29_42 sn_29 sn_42 1.020007038131677e-18
Rsub_29_33 sn_29 sn_33 53038309.12961104
Csub_29_33 sn_29 sn_33 1.986579827890391e-19
Rsub_29_200 sn_29 sn_200 44443619.16627029
Csub_29_200 sn_29 sn_200 2.370752809939133e-19
Rsub_29_179 sn_29 sn_179 42444275.00211252
Csub_29_179 sn_29 sn_179 2.482427489150323e-19
Rsub_29_125 sn_29 sn_125 11913125.82230711
Csub_29_125 sn_29 sn_125 8.84443231725181e-19
Rsub_29_30 sn_29 sn_30 700561.6497109471
Csub_29_30 sn_29 sn_30 1.504005180211816e-17
Rsub_29_197 sn_29 sn_197 14127507.34999312
Csub_29_197 sn_29 sn_197 7.458133442227608e-19
Rsub_29_45 sn_29 sn_45 4994484.369459991
Csub_29_45 sn_29 sn_45 2.109623881627888e-18
Rsub_29_212 sn_29 sn_212 18357710.92036162
Csub_29_212 sn_29 sn_212 5.73954102880189e-19
Rsub_162_228 sn_162 sn_228 16168328.94433525
Csub_162_228 sn_162 sn_228 6.516742415685187e-19
Rsub_162_183 sn_162 sn_183 1678826.047605735
Csub_162_183 sn_162 sn_183 6.27610199237536e-18
Rsub_162_210 sn_162 sn_210 4470420.314612065
Csub_162_210 sn_162 sn_210 2.356933523183567e-18
Rsub_162_178 sn_162 sn_178 4683215.29680171
Csub_162_178 sn_162 sn_178 2.24983965811387e-18
Rsub_162_225 sn_162 sn_225 4331020.534719122
Csub_162_225 sn_162 sn_225 2.432794630680116e-18
Rsub_162_213 sn_162 sn_213 5146709.696697883
Csub_162_213 sn_162 sn_213 2.047227087432225e-18
Rsub_162_185 sn_162 sn_185 17889218.71583249
Csub_162_185 sn_162 sn_185 5.889851127430679e-19
Rsub_162_194 sn_162 sn_194 56536396.55978072
Csub_162_194 sn_162 sn_194 1.86366378888136e-19
Rsub_162_211 sn_162 sn_211 9148340.06460939
Csub_162_211 sn_162 sn_211 1.151737192519841e-18
Rsub_162_229 sn_162 sn_229 14834320.56522687
Csub_162_229 sn_162 sn_229 7.102774580002386e-19
Rsub_162_200 sn_162 sn_200 2009748.798108647
Csub_162_200 sn_162 sn_200 5.24268680351782e-18
Rsub_162_189 sn_162 sn_189 23139461.58112603
Csub_162_189 sn_162 sn_189 4.553469606580736e-19
Rsub_162_182 sn_162 sn_182 73471381.40085265
Csub_162_182 sn_162 sn_182 1.434093561511248e-19
Rsub_162_221 sn_162 sn_221 647925.4248564645
Csub_162_221 sn_162 sn_221 1.626187690437392e-17
Rsub_162_184 sn_162 sn_184 16374.69532345973
Csub_162_184 sn_162 sn_184 6.434613465530913e-16
Rsub_162_192 sn_162 sn_192 33228659.0445434
Csub_162_192 sn_162 sn_192 3.170902409304488e-19
Rsub_162_166 sn_162 sn_166 1538637.085080749
Csub_162_166 sn_162 sn_166 6.847932890995563e-18
Rsub_162_203 sn_162 sn_203 2329275.649336821
Csub_162_203 sn_162 sn_203 4.52350219057581e-18
Rsub_162_216 sn_162 sn_216 160764.9517898577
Csub_162_216 sn_162 sn_216 6.553968004172116e-17
Rsub_162_191 sn_162 sn_191 2116483.978019292
Csub_162_191 sn_162 sn_191 4.978295896239455e-18
Rsub_162_208 sn_162 sn_208 178733.1366887426
Csub_162_208 sn_162 sn_208 5.895092369233642e-17
Rsub_162_171 sn_162 sn_171 330791.9690171077
Csub_162_171 sn_162 sn_171 3.185229536719823e-17
Rsub_162_230 sn_162 0 50659.85467273189
Csub_162_230 sn_162 0 2.079848742223368e-16
Rsub_162_222 sn_162 sn_222 320998.3719515389
Csub_162_222 sn_162 sn_222 3.282410262136996e-17
Rsub_162_190 sn_162 sn_190 192224.940662764
Csub_162_190 sn_162 sn_190 5.481330084380165e-17
Rsub_162_227 sn_162 sn_227 1686014.019576415
Csub_162_227 sn_162 sn_227 6.249345129927883e-18
Rsub_162_224 sn_162 sn_224 112347.0138695493
Csub_162_224 sn_162 sn_224 9.378516739629901e-17
Rsub_162_164 sn_162 sn_164 70657.30919078547
Csub_162_164 sn_162 sn_164 1.491209277978573e-16
Rsub_162_214 sn_162 sn_214 6723927.461548628
Csub_162_214 sn_162 sn_214 1.567013261592099e-18
Rsub_162_177 sn_162 sn_177 3226795.988977971
Csub_162_177 sn_162 sn_177 3.265308230895391e-18
Rsub_162_218 sn_162 sn_218 742362.2475579235
Csub_162_218 sn_162 sn_218 1.419318336417408e-17
Rsub_162_181 sn_162 sn_181 215872.3495406976
Csub_162_181 sn_162 sn_181 4.880886099886358e-17
Rsub_162_207 sn_162 sn_207 2294510.972621662
Csub_162_207 sn_162 sn_207 4.592038838755793e-18
Rsub_162_170 sn_162 sn_170 3392226.928492423
Csub_162_170 sn_162 sn_170 3.106066818151412e-18
Rsub_162_215 sn_162 sn_215 841947.7192993701
Csub_162_215 sn_162 sn_215 1.251441539742869e-17
Rsub_162_180 sn_162 sn_180 10078787.54389014
Csub_162_180 sn_162 sn_180 1.045411807357455e-18
Rsub_162_165 sn_162 sn_165 3676150.653289883
Csub_162_165 sn_162 sn_165 2.866172933582204e-18
Rsub_162_169 sn_162 sn_169 4332542.507110478
Csub_162_169 sn_162 sn_169 2.431940017885052e-18
Rsub_162_219 sn_162 sn_219 2202239.328329488
Csub_162_219 sn_162 sn_219 4.784440713000284e-18
Rsub_162_197 sn_162 sn_197 2314087.727073048
Csub_162_197 sn_162 sn_197 4.553191038939985e-18
Rsub_162_195 sn_162 sn_195 3978811.750028567
Csub_162_195 sn_162 sn_195 2.64814828250026e-18
Rsub_162_174 sn_162 sn_174 14289703.90111889
Csub_162_174 sn_162 sn_174 7.373479237316451e-19
Rsub_162_188 sn_162 sn_188 1635535673.100452
Rsub_166_225 sn_166 sn_225 2597196.815398779
Csub_166_225 sn_166 sn_225 4.056867558037647e-18
Rsub_166_189 sn_166 sn_189 5013939.05220137
Csub_166_189 sn_166 sn_189 2.101438288844767e-18
Rsub_166_179 sn_166 sn_179 1281440.882098883
Csub_166_179 sn_166 sn_179 8.22237190136482e-18
Rsub_166_184 sn_166 sn_184 2122468.557614347
Csub_166_184 sn_166 sn_184 4.964258935394077e-18
Rsub_166_167 sn_166 sn_167 5335345.401701458
Csub_166_167 sn_166 sn_167 1.974845620842071e-18
Rsub_166_183 sn_166 sn_183 4142474.767428942
Csub_166_183 sn_166 sn_183 2.543523882167072e-18
Rsub_166_228 sn_166 sn_228 3870714.553929017
Csub_166_228 sn_166 sn_228 2.722102949062677e-18
Rsub_166_229 sn_166 sn_229 1722345.29484421
Csub_166_229 sn_166 sn_229 6.117520995221258e-18
Rsub_166_182 sn_166 sn_182 573433.5639718642
Csub_166_182 sn_166 sn_182 1.837437527941245e-17
Rsub_166_201 sn_166 sn_201 7276237.524871101
Csub_166_201 sn_166 sn_201 1.448067557747389e-18
Rsub_166_210 sn_166 sn_210 6863230.37247502
Csub_166_210 sn_166 sn_210 1.535207610761043e-18
Rsub_166_191 sn_166 sn_191 1670764.900115503
Csub_166_191 sn_166 sn_191 6.30638308328215e-18
Rsub_166_217 sn_166 sn_217 894264.4641666883
Csub_166_217 sn_166 sn_217 1.17822902781319e-17
Rsub_166_227 sn_166 sn_227 282760.3238667048
Csub_166_227 sn_166 sn_227 3.726294891074242e-17
Rsub_166_214 sn_166 sn_214 695411.0857639856
Csub_166_214 sn_166 sn_214 1.515144598342794e-17
Rsub_166_219 sn_166 sn_219 1732006.52268665
Csub_166_219 sn_166 sn_219 6.083397125945022e-18
Rsub_166_224 sn_166 sn_224 311327.4998983823
Csub_166_224 sn_166 sn_224 3.384372888893247e-17
Rsub_166_207 sn_166 sn_207 113286.6058939053
Csub_166_207 sn_166 sn_207 9.300731908322493e-17
Rsub_166_170 sn_166 sn_170 3809727.388656586
Csub_166_170 sn_166 sn_170 2.765679122764071e-18
Rsub_166_197 sn_166 sn_197 71859.15519061472
Csub_166_197 sn_166 sn_197 1.466268768994119e-16
Rsub_166_186 sn_166 sn_186 94150.45219387373
Csub_166_186 sn_166 sn_186 1.119111300765011e-16
Rsub_166_203 sn_166 sn_203 47354.06870644155
Csub_166_203 sn_166 sn_203 2.225042913956986e-16
Rsub_166_209 sn_166 sn_209 1020434.908665243
Csub_166_209 sn_166 sn_209 1.032548319619133e-17
Rsub_166_226 sn_166 sn_226 10719.32902703529
Csub_166_226 sn_166 sn_226 9.829424468318746e-16
Rsub_166_208 sn_166 sn_208 512806.0770790917
Csub_166_208 sn_166 sn_208 2.054672121329975e-17
Rsub_166_171 sn_166 sn_171 652975.4861057934
Csub_166_171 sn_166 sn_171 1.613610882250319e-17
Rsub_166_222 sn_166 sn_222 69350.82270942259
Csub_166_222 sn_166 sn_222 1.519301875678891e-16
Rsub_166_195 sn_166 sn_195 343647.7410441248
Csub_166_195 sn_166 sn_195 3.06607093363e-17
Rsub_166_212 sn_166 sn_212 109622.9133631549
Csub_166_212 sn_166 sn_212 9.611570408939151e-17
Rsub_166_218 sn_166 sn_218 2722.299879609936
Csub_166_218 sn_166 sn_218 3.870434547328312e-15
Rsub_166_181 sn_166 sn_181 1360341.962102881
Csub_166_181 sn_166 sn_181 7.745466798614522e-18
Rsub_166_230 sn_166 0 22428.58349981695
Csub_166_230 sn_166 0 4.697792663685601e-16
Rsub_166_199 sn_166 sn_199 3212106.63192489
Csub_166_199 sn_166 sn_199 3.280240885376803e-18
Rsub_166_192 sn_166 sn_192 49284.78482745116
Csub_166_192 sn_166 sn_192 2.137877549657329e-16
Rsub_166_190 sn_166 sn_190 2140740.239208675
Csub_166_190 sn_166 sn_190 4.921887910195409e-18
Rsub_166_168 sn_166 sn_168 615179.4417888188
Csub_166_168 sn_166 sn_168 1.712749611981833e-17
Rsub_166_221 sn_166 sn_221 108765.3499923311
Csub_166_221 sn_166 sn_221 9.687353098181469e-17
Rsub_166_177 sn_166 sn_177 1006130.810246845
Csub_166_177 sn_166 sn_177 1.047227994105952e-17
Rsub_166_215 sn_166 sn_215 862742.4103419004
Csub_166_215 sn_166 sn_215 1.221278028751878e-17
Rsub_166_174 sn_166 sn_174 7039992.728290047
Csub_166_174 sn_166 sn_174 1.496661134306203e-18
Rsub_166_211 sn_166 sn_211 303237.5243201146
Csub_166_211 sn_166 sn_211 3.474663475720471e-17
Rsub_166_188 sn_166 sn_188 18643111.20232468
Csub_166_188 sn_166 sn_188 5.651676583314146e-19
Rsub_166_216 sn_166 sn_216 616288.4090340302
Csub_166_216 sn_166 sn_216 1.709667640633527e-17
Rsub_166_206 sn_166 sn_206 1903464.328318056
Csub_166_206 sn_166 sn_206 5.535424722952529e-18
Rsub_166_196 sn_166 sn_196 820431.0106411244
Csub_166_196 sn_166 sn_196 1.284261975177692e-17
Rsub_166_198 sn_166 sn_198 357501.9892252642
Csub_166_198 sn_166 sn_198 2.947251713217993e-17
Rsub_166_204 sn_166 sn_204 1781322.718367792
Csub_166_204 sn_166 sn_204 5.914977333183328e-18
Rsub_166_213 sn_166 sn_213 824391.6897876154
Csub_166_213 sn_166 sn_213 1.278091911011921e-17
Rsub_166_200 sn_166 sn_200 379566.0167963495
Csub_166_200 sn_166 sn_200 2.77592909690943e-17
Rsub_166_180 sn_166 sn_180 1339620.755455107
Csub_166_180 sn_166 sn_180 7.865273406166702e-18
Rsub_76_194 sn_76 sn_194 5499416.72019963
Csub_76_194 sn_76 sn_194 1.915927458911956e-18
Rsub_76_209 sn_76 sn_209 14771573.4232416
Csub_76_209 sn_76 sn_209 7.132945963394731e-19
Rsub_76_163 sn_76 sn_163 10851446.35314814
Csub_76_163 sn_76 sn_163 9.70975034970637e-19
Rsub_76_134 sn_76 sn_134 15270081.22970978
Csub_76_134 sn_76 sn_134 6.90008346630796e-19
Rsub_76_174 sn_76 sn_174 53481796.41739661
Csub_76_174 sn_76 sn_174 1.970106505024331e-19
Rsub_76_118 sn_76 sn_118 13150028.69591665
Csub_76_118 sn_76 sn_118 8.012517497776863e-19
Rsub_76_80 sn_76 sn_80 4320382.605903716
Csub_76_80 sn_76 sn_80 2.438784816842867e-18
Rsub_76_180 sn_76 sn_180 7677370.358529867
Csub_76_180 sn_76 sn_180 1.372407870166579e-18
Rsub_76_179 sn_76 sn_179 4171515.103456561
Csub_76_179 sn_76 sn_179 2.525816937232076e-18
Rsub_76_225 sn_76 sn_225 11551741.22005397
Csub_76_225 sn_76 sn_225 9.121121484212722e-19
Rsub_76_127 sn_76 sn_127 7273659.965415562
Csub_76_127 sn_76 sn_127 1.448580707969351e-18
Rsub_76_186 sn_76 sn_186 3498432.74350389
Csub_76_186 sn_76 sn_186 3.01177249206657e-18
Rsub_76_148 sn_76 sn_148 1253646.51034592
Csub_76_148 sn_76 sn_148 8.404668632884923e-18
Rsub_76_140 sn_76 sn_140 4957433.617665298
Csub_76_140 sn_76 sn_140 2.12539073941088e-18
Rsub_76_164 sn_76 sn_164 14881779.33398442
Csub_76_164 sn_76 sn_164 7.08012346223184e-19
Rsub_76_112 sn_76 sn_112 13931981.32813728
Csub_76_112 sn_76 sn_112 7.562803347252792e-19
Rsub_76_182 sn_76 sn_182 14430489.13460547
Csub_76_182 sn_76 sn_182 7.301542867984059e-19
Rsub_76_77 sn_76 sn_77 14430489.13460547
Csub_76_77 sn_76 sn_77 7.301542867984059e-19
Rsub_76_117 sn_76 sn_117 16820332.60845918
Csub_76_117 sn_76 sn_117 6.264135048632187e-19
Rsub_76_177 sn_76 sn_177 7574367.696309585
Csub_76_177 sn_76 sn_177 1.391071033871729e-18
Rsub_76_172 sn_76 sn_172 4237341.682962343
Csub_76_172 sn_76 sn_172 2.486578683186082e-18
Rsub_76_226 sn_76 sn_226 2613317.601531777
Csub_76_226 sn_76 sn_226 4.031841937640537e-18
Rsub_76_78 sn_76 sn_78 351943.0013453509
Csub_76_78 sn_76 sn_78 2.993803957445618e-17
Rsub_76_157 sn_76 sn_157 195531.7864648028
Csub_76_157 sn_76 sn_157 5.388629487168649e-17
Rsub_76_129 sn_76 sn_129 100565.6060188162
Csub_76_129 sn_76 sn_129 1.047722369440958e-16
Rsub_76_141 sn_76 sn_141 1679113.920233017
Csub_76_141 sn_76 sn_141 6.27502599750219e-18
Rsub_76_215 sn_76 sn_215 290106.6020103066
Csub_76_215 sn_76 sn_215 3.631935098759205e-17
Rsub_76_136 sn_76 sn_136 1104280.001673723
Csub_76_136 sn_76 sn_136 9.541496256619862e-18
Rsub_76_178 sn_76 sn_178 356910.4833111706
Csub_76_178 sn_76 sn_178 2.952136178371601e-17
Rsub_76_99 sn_76 sn_99 21796.22990900847
Csub_76_99 sn_76 sn_99 4.83408531944106e-16
Rsub_76_201 sn_76 sn_201 109196.5176553578
Csub_76_201 sn_76 sn_201 9.649102121997036e-17
Rsub_76_206 sn_76 sn_206 500586.1423523424
Csub_76_206 sn_76 sn_206 2.104829241320427e-17
Rsub_76_169 sn_76 sn_169 5836628.230328178
Csub_76_169 sn_76 sn_169 1.80523464686007e-18
Rsub_76_90 sn_76 sn_90 19402553.85607849
Csub_76_90 sn_76 sn_90 5.430462185744225e-19
Rsub_76_84 sn_76 sn_84 5707718.407966706
Csub_76_84 sn_76 sn_84 1.846006188308696e-18
Rsub_76_195 sn_76 sn_195 266410.7269994149
Csub_76_195 sn_76 sn_195 3.954977196640112e-17
Rsub_76_230 sn_76 0 47403.55752460889
Csub_76_230 sn_76 0 2.222719992430976e-16
Rsub_76_204 sn_76 sn_204 256136.0963111538
Csub_76_204 sn_76 sn_204 4.113626956128157e-17
Rsub_76_125 sn_76 sn_125 14181235.3970711
Csub_76_125 sn_76 sn_125 7.429877022143036e-19
Rsub_76_86 sn_76 sn_86 7267867.965006712
Csub_76_86 sn_76 sn_86 1.449735129058618e-18
Rsub_76_165 sn_76 sn_165 3579633.022382739
Csub_76_165 sn_76 sn_165 2.943453542960256e-18
Rsub_76_81 sn_76 sn_81 11914334.59688132
Csub_76_81 sn_76 sn_81 8.843535001096927e-19
Rsub_76_184 sn_76 sn_184 23097504.18251522
Csub_76_184 sn_76 sn_184 4.56174113833741e-19
Rsub_76_105 sn_76 sn_105 739278.4789673313
Csub_76_105 sn_76 sn_105 1.425238770232835e-17
Rsub_76_221 sn_76 sn_221 1886513.119799384
Csub_76_221 sn_76 sn_221 5.585163120069091e-18
Rsub_76_142 sn_76 sn_142 6782611.874773833
Csub_76_142 sn_76 sn_142 1.553455172839496e-18
Rsub_76_110 sn_76 sn_110 627718.7366235806
Csub_76_110 sn_76 sn_110 1.67853576570048e-17
Rsub_76_155 sn_76 sn_155 3157529.226996991
Csub_76_155 sn_76 sn_155 3.336939342363858e-18
Rsub_76_161 sn_76 sn_161 1481331.327639122
Csub_76_161 sn_76 sn_161 7.112847278415807e-18
Rsub_76_198 sn_76 sn_198 382788.619675355
Csub_76_198 sn_76 sn_198 2.752559235216044e-17
Rsub_76_181 sn_76 sn_181 2451643.530714481
Csub_76_181 sn_76 sn_181 4.297722474832775e-18
Rsub_76_128 sn_76 sn_128 203429.1754293956
Csub_76_128 sn_76 sn_128 5.179435781514491e-17
Rsub_76_207 sn_76 sn_207 2586065.242582035
Csub_76_207 sn_76 sn_207 4.074330116942425e-18
Rsub_76_153 sn_76 sn_153 551052.0909373394
Csub_76_153 sn_76 sn_153 1.912066694875878e-17
Rsub_76_199 sn_76 sn_199 308130.1004025757
Csub_76_199 sn_76 sn_199 3.419491795337086e-17
Rsub_76_131 sn_76 sn_131 214471.9326208455
Csub_76_131 sn_76 sn_131 4.91275635626268e-17
Rsub_76_210 sn_76 sn_210 6244086.051169371
Csub_76_210 sn_76 sn_210 1.687434064150472e-18
Rsub_76_188 sn_76 sn_188 25056.44209970531
Csub_76_188 sn_76 sn_188 4.205099614822777e-16
Rsub_76_222 sn_76 sn_222 213411.9569148285
Csub_76_222 sn_76 sn_222 4.937157062120493e-17
Rsub_76_101 sn_76 sn_101 134643.1390135457
Csub_76_101 sn_76 sn_101 7.82548860597344e-17
Rsub_76_138 sn_76 sn_138 203941.7591181095
Csub_76_138 sn_76 sn_138 5.166417877237183e-17
Rsub_76_219 sn_76 sn_219 378475.5348867578
Csub_76_219 sn_76 sn_219 2.783927237300182e-17
Rsub_76_227 sn_76 sn_227 2570139.373622187
Csub_76_227 sn_76 sn_227 4.099576704037091e-18
Rsub_76_133 sn_76 sn_133 189119.3079955846
Csub_76_133 sn_76 sn_133 5.571342034773094e-17
Rsub_76_212 sn_76 sn_212 2031319.257107603
Csub_76_212 sn_76 sn_212 5.187015022558743e-18
Rsub_76_213 sn_76 sn_213 2315043.145212851
Csub_76_213 sn_76 sn_213 4.551311937325148e-18
Rsub_76_114 sn_76 sn_114 843382.3924370519
Csub_76_114 sn_76 sn_114 1.249312719439589e-17
Rsub_76_130 sn_76 sn_130 7385216.336556189
Csub_76_130 sn_76 sn_130 1.426699371022526e-18
Rsub_76_96 sn_76 sn_96 7446034.929361079
Csub_76_96 sn_76 sn_96 1.415046209450713e-18
Rsub_76_146 sn_76 sn_146 24285790.87156555
Csub_76_146 sn_76 sn_146 4.338538348597243e-19
Rsub_76_135 sn_76 sn_135 3754606.859746978
Csub_76_135 sn_76 sn_135 2.806281428607429e-18
Rsub_76_166 sn_76 sn_166 7152388.283556757
Csub_76_166 sn_76 sn_166 1.47314198901271e-18
Rsub_76_216 sn_76 sn_216 1026688.636772562
Csub_76_216 sn_76 sn_216 1.026258899226923e-17
Rsub_76_170 sn_76 sn_170 393710.2167197887
Csub_76_170 sn_76 sn_170 2.676202713258271e-17
Rsub_76_139 sn_76 sn_139 923697.8262017199
Csub_76_139 sn_76 sn_139 1.140685103217836e-17
Rsub_76_218 sn_76 sn_218 2111525.727157794
Csub_76_218 sn_76 sn_218 4.989985850853243e-18
Rsub_76_150 sn_76 sn_150 3941035.251639349
Csub_76_150 sn_76 sn_150 2.67353190962886e-18
Rsub_76_229 sn_76 sn_229 3741056.734402668
Csub_76_229 sn_76 sn_229 2.816445793333406e-18
Rsub_76_211 sn_76 sn_211 5982948.182039727
Csub_76_211 sn_76 sn_211 1.761085535365253e-18
Rsub_76_197 sn_76 sn_197 662527277.7191099
Csub_76_197 sn_76 sn_197 1.5903471232919e-20
Rsub_76_203 sn_76 sn_203 2411727.71103011
Csub_76_203 sn_76 sn_203 4.368852857659292e-18
Rsub_76_162 sn_76 sn_162 7906183.318613186
Csub_76_162 sn_76 sn_162 1.332688995134278e-18
Rsub_76_191 sn_76 sn_191 11421657.39049011
Csub_76_191 sn_76 sn_191 9.225003991980074e-19
Rsub_76_224 sn_76 sn_224 41271531.22898509
Csub_76_224 sn_76 sn_224 2.552966461014222e-19
Rsub_76_190 sn_76 sn_190 10383495.12145292
Csub_76_190 sn_76 sn_190 1.014733803886612e-18
Rsub_76_97 sn_76 sn_97 2335025.793165414
Csub_76_97 sn_76 sn_97 4.512362789768803e-18
Rsub_76_156 sn_76 sn_156 14048555.83665936
Csub_76_156 sn_76 sn_156 7.500047424615213e-19
Rsub_107_174 sn_107 sn_174 58988939.78418905
Csub_107_174 sn_107 sn_174 1.786179500899272e-19
Rsub_107_182 sn_107 sn_182 15591393.45455997
Csub_107_182 sn_107 sn_182 6.757884427032034e-19
Rsub_107_161 sn_107 sn_161 21386813.48177276
Csub_107_161 sn_107 sn_161 4.926626171406918e-19
Rsub_107_200 sn_107 sn_200 14553878.90477656
Csub_107_200 sn_107 sn_200 7.239639391785748e-19
Rsub_107_214 sn_107 sn_214 13723139.93861745
Csub_107_214 sn_107 sn_214 7.677895546761808e-19
Rsub_107_170 sn_107 sn_170 13307910.11300467
Csub_107_170 sn_107 sn_170 7.917459174850909e-19
Rsub_107_227 sn_107 sn_227 3629522.152950682
Csub_107_227 sn_107 sn_227 2.902994680350466e-18
Rsub_107_115 sn_107 sn_115 13746073.10885771
Csub_107_115 sn_107 sn_115 7.665086180460141e-19
Rsub_107_183 sn_107 sn_183 5003053.157036014
Csub_107_183 sn_107 sn_183 2.106010704166131e-18
Rsub_107_211 sn_107 sn_211 7478675.476077497
Csub_107_211 sn_107 sn_211 1.408870265320872e-18
Rsub_107_219 sn_107 sn_219 3096929.714020513
Csub_107_219 sn_107 sn_219 3.402235270154475e-18
Rsub_107_122 sn_107 sn_122 2655450.725039731
Csub_107_122 sn_107 sn_122 3.967870088070399e-18
Rsub_107_202 sn_107 sn_202 13208718.40999957
Csub_107_202 sn_107 sn_202 7.976915833297976e-19
Rsub_107_127 sn_107 sn_127 4993019.852650144
Csub_107_127 sn_107 sn_127 2.110242661390091e-18
Rsub_107_206 sn_107 sn_206 6950989.605177695
Csub_107_206 sn_107 sn_206 1.515824954533311e-18
Rsub_107_137 sn_107 sn_137 6158026.52288494
Csub_107_137 sn_107 sn_137 1.711016258711049e-18
Rsub_107_216 sn_107 sn_216 17568.49260135825
Csub_107_216 sn_107 sn_216 5.997374812575216e-16
Rsub_107_126 sn_107 sn_126 2062224.929069472
Csub_107_126 sn_107 sn_126 5.109279474661538e-18
Rsub_107_205 sn_107 sn_205 4836952.384368429
Csub_107_205 sn_107 sn_205 2.178331036766196e-18
Rsub_107_162 sn_107 sn_162 939292.8067509234
Csub_107_162 sn_107 sn_162 1.121746427365541e-17
Rsub_107_180 sn_107 sn_180 2614357.288383549
Csub_107_180 sn_107 sn_180 4.030238540480703e-18
Rsub_107_176 sn_107 sn_176 262255.8103429636
Csub_107_176 sn_107 sn_176 4.017635867991246e-17
Rsub_107_221 sn_107 sn_221 2831142.011411981
Csub_107_221 sn_107 sn_221 3.72163722616483e-18
Rsub_107_150 sn_107 sn_150 466167.6508445966
Csub_107_150 sn_107 sn_150 2.260234806756783e-17
Rsub_107_229 sn_107 sn_229 8498086.585818816
Csub_107_229 sn_107 sn_229 1.23986539744285e-18
Rsub_107_224 sn_107 sn_224 4021594.850741815
Csub_107_224 sn_107 sn_224 2.619976375861548e-18
Rsub_107_191 sn_107 sn_191 789916.8483917875
Csub_107_191 sn_107 sn_191 1.333872485905511e-17
Rsub_107_112 sn_107 sn_112 1304177.356280823
Csub_107_112 sn_107 sn_112 8.079026561446621e-18
Rsub_107_208 sn_107 sn_208 3440335.732873027
Csub_107_208 sn_107 sn_208 3.062632347637472e-18
Rsub_107_129 sn_107 sn_129 30609280.04080186
Csub_107_129 sn_107 sn_129 3.442251332989531e-19
Rsub_107_185 sn_107 sn_185 5182192.66488599
Csub_107_185 sn_107 sn_185 2.033209528010053e-18
Rsub_107_222 sn_107 sn_222 58264.55498654092
Csub_107_222 sn_107 sn_222 1.808386506112322e-16
Rsub_107_177 sn_107 sn_177 2062052.557314308
Csub_107_177 sn_107 sn_177 5.10970657118124e-18
Rsub_107_140 sn_107 sn_140 62617.94160695317
Csub_107_140 sn_107 sn_140 1.682662066467547e-16
Rsub_107_195 sn_107 sn_195 673187.7498705594
Csub_107_195 sn_107 sn_195 1.565162691129771e-17
Rsub_107_158 sn_107 sn_158 105058.820812944
Csub_107_158 sn_107 sn_158 1.002912789302108e-16
Rsub_107_121 sn_107 sn_121 3057585.019301195
Csub_107_121 sn_107 sn_121 3.446014889436531e-18
Rsub_107_110 sn_107 sn_110 11066961.75112163
Csub_107_110 sn_107 sn_110 9.520664965849492e-19
Rsub_107_155 sn_107 sn_155 124211.292702455
Csub_107_155 sn_107 sn_155 8.482709802779267e-17
Rsub_107_118 sn_107 sn_118 8429.859739318395
Csub_107_118 sn_107 sn_118 1.249900215194083e-15
Rsub_107_135 sn_107 sn_135 96702.78507040799
Csub_107_135 sn_107 sn_135 1.089573945006706e-16
Rsub_107_186 sn_107 sn_186 13377178.52131078
Csub_107_186 sn_107 sn_186 7.87646175570181e-19
Rsub_107_181 sn_107 sn_181 391385.4016575973
Csub_107_181 sn_107 sn_181 2.692099260116968e-17
Rsub_107_210 sn_107 sn_210 107583.3952838638
Csub_107_210 sn_107 sn_210 9.793782278788465e-17
Rsub_107_131 sn_107 sn_131 317449.7746836774
Csub_107_131 sn_107 sn_131 3.319102529755793e-17
Rsub_107_168 sn_107 sn_168 48641.70769123531
Csub_107_168 sn_107 sn_168 2.166141774691138e-16
Rsub_107_190 sn_107 sn_190 47150.55614241904
Csub_107_190 sn_107 sn_190 2.23464670711505e-16
Rsub_107_153 sn_107 sn_153 842235.5860321752
Csub_107_153 sn_107 sn_153 1.251013810977524e-17
Rsub_107_230 sn_107 0 66219.57965304305
Csub_107_230 sn_107 0 1.591143217374049e-16
Rsub_107_151 sn_107 sn_151 2112440.886322633
Csub_107_151 sn_107 sn_151 4.987824071409667e-18
Rsub_107_141 sn_107 sn_141 51225.53757548195
Csub_107_141 sn_107 sn_141 2.056881001337324e-16
Rsub_107_220 sn_107 sn_220 20291422.43842594
Csub_107_220 sn_107 sn_220 5.192580034348418e-19
Rsub_107_178 sn_107 sn_178 16287810.4934631
Csub_107_178 sn_107 sn_178 6.468937925363685e-19
Rsub_107_128 sn_107 sn_128 3519030.706171715
Csub_107_128 sn_107 sn_128 2.994143666820242e-18
Rsub_107_171 sn_107 sn_171 3555082.053313498
Csub_107_171 sn_107 sn_171 2.963780679101209e-18
Rsub_107_188 sn_107 sn_188 28687162.95495898
Csub_107_188 sn_107 sn_188 3.672891431882992e-19
Rsub_107_109 sn_107 sn_109 28840053.95747257
Csub_107_109 sn_107 sn_109 3.65342017659435e-19
Rsub_107_132 sn_107 sn_132 684335.0211868426
Csub_107_132 sn_107 sn_132 1.53966744007293e-17
Rsub_107_120 sn_107 sn_120 9586114.24100622
Csub_107_120 sn_107 sn_120 1.099140197720409e-18
Rsub_107_165 sn_107 sn_165 40536134.2139478
Csub_107_165 sn_107 sn_165 2.599281778232462e-19
Rsub_107_169 sn_107 sn_169 629537.5625659024
Csub_107_169 sn_107 sn_169 1.673686230776261e-17
Rsub_107_130 sn_107 sn_130 2384691.548906605
Csub_107_130 sn_107 sn_130 4.41838421705358e-18
Rsub_107_209 sn_107 sn_209 10145711.21921297
Csub_107_209 sn_107 sn_209 1.038516006869684e-18
Rsub_107_179 sn_107 sn_179 7348419.395673548
Csub_107_179 sn_107 sn_179 1.433843515849607e-18
Rsub_107_192 sn_107 sn_192 7815957.137826634
Csub_107_192 sn_107 sn_192 1.348073347439039e-18
Rsub_107_164 sn_107 sn_164 346603055.0118512
Csub_107_164 sn_107 sn_164 3.039928053106668e-20
Rsub_107_226 sn_107 sn_226 1772667.044990218
Csub_107_226 sn_107 sn_226 5.943859300598746e-18
Rsub_107_157 sn_107 sn_157 4127847.21520032
Csub_107_157 sn_107 sn_157 2.55253718292446e-18
Rsub_107_154 sn_107 sn_154 7478036.772574934
Csub_107_154 sn_107 sn_154 1.408990597755772e-18
Rsub_107_156 sn_107 sn_156 3279304.10460293
Csub_107_156 sn_107 sn_156 3.213024216766196e-18
Rsub_107_215 sn_107 sn_215 1352946.643237992
Csub_107_215 sn_107 sn_215 7.787804164259687e-18
Rsub_107_212 sn_107 sn_212 3672020.329603128
Csub_107_212 sn_107 sn_212 2.869396832388667e-18
Rsub_107_228 sn_107 sn_228 3378761.30367958
Csub_107_228 sn_107 sn_228 3.118445653664682e-18
Rsub_107_225 sn_107 sn_225 13721115.41303767
Csub_107_225 sn_107 sn_225 7.679028406260863e-19
Rsub_107_146 sn_107 sn_146 16663243.28364287
Csub_107_146 sn_107 sn_146 6.323188903190849e-19
Rsub_107_160 sn_107 sn_160 3005447.944092613
Csub_107_160 sn_107 sn_160 3.505794709550731e-18
Rsub_107_159 sn_107 sn_159 21214950.59849899
Csub_107_159 sn_107 sn_159 4.966536902035249e-19
Rsub_107_144 sn_107 sn_144 8039941.176119754
Csub_107_144 sn_107 sn_144 1.310517486561404e-18
Rsub_107_138 sn_107 sn_138 2474629.601584796
Csub_107_138 sn_107 sn_138 4.257802256742687e-18
Rsub_107_172 sn_107 sn_172 17230280.24011749
Csub_107_172 sn_107 sn_172 6.115097000974927e-19
Rsub_41_122 sn_41 sn_122 8465209.486833299
Csub_41_122 sn_41 sn_122 1.244680774718965e-18
Rsub_41_128 sn_41 sn_128 8465209.486833299
Csub_41_128 sn_41 sn_128 1.244680774718965e-18
Rsub_41_193 sn_41 sn_193 2926299.66943403
Csub_41_193 sn_41 sn_193 3.600616714783638e-18
Rsub_41_196 sn_41 sn_196 5763365.671427465
Csub_41_196 sn_41 sn_196 1.828182368241148e-18
Rsub_41_84 sn_41 sn_84 3301631.585358635
Csub_41_84 sn_41 sn_84 3.191295948631862e-18
Rsub_41_203 sn_41 sn_203 15172382.01308202
Csub_41_203 sn_41 sn_203 6.944515036034009e-19
Rsub_41_207 sn_41 sn_207 10910899.75934509
Csub_41_207 sn_41 sn_207 9.656841997109907e-19
Rsub_41_86 sn_41 sn_86 16365428.15070112
Csub_41_86 sn_41 sn_86 6.43825716333526e-19
Rsub_41_192 sn_41 sn_192 2250905.088592256
Csub_41_192 sn_41 sn_192 4.680998570588174e-18
Rsub_41_135 sn_41 sn_135 6088636.018485915
Csub_41_135 sn_41 sn_135 1.730516238816022e-18
Rsub_41_174 sn_41 sn_174 56910673.16336142
Csub_41_174 sn_41 sn_174 1.851407287344001e-19
Rsub_41_185 sn_41 sn_185 6886062.356974057
Csub_41_185 sn_41 sn_185 1.530117352416781e-18
Rsub_41_179 sn_41 sn_179 350542.6362981909
Csub_41_179 sn_41 sn_179 3.005763753447409e-17
Rsub_41_164 sn_41 sn_164 29497490.62846201
Csub_41_164 sn_41 sn_164 3.571993168823449e-19
Rsub_41_74 sn_41 sn_74 13766028.69773928
Csub_41_74 sn_41 sn_74 7.653974674599039e-19
Rsub_41_121 sn_41 sn_121 6640979.627514831
Csub_41_121 sn_41 sn_121 1.586585728794493e-18
Rsub_41_221 sn_41 sn_221 3353689.688726003
Csub_41_221 sn_41 sn_221 3.141758624135732e-18
Rsub_41_229 sn_41 sn_229 8465209.486833299
Csub_41_229 sn_41 sn_229 1.244680774718965e-18
Rsub_41_68 sn_41 sn_68 89002.90399394378
Csub_41_68 sn_41 sn_68 1.183835923257848e-16
Rsub_41_82 sn_41 sn_82 36782002.52967783
Csub_41_82 sn_41 sn_82 2.864575819037738e-19
Rsub_41_70 sn_41 sn_70 24442830.73638511
Csub_41_70 sn_41 sn_70 4.310664184466e-19
Rsub_41_151 sn_41 sn_151 4355900.946212607
Csub_41_151 sn_41 sn_151 2.41889878404864e-18
Rsub_41_58 sn_41 sn_58 39989047.57845407
Csub_41_58 sn_41 sn_58 2.634842323153256e-19
Rsub_41_117 sn_41 sn_117 1882472.205984999
Csub_41_117 sn_41 sn_117 5.597152228187513e-18
Rsub_41_66 sn_41 sn_66 7641616.810712338
Csub_41_66 sn_41 sn_66 1.378829083324293e-18
Rsub_41_95 sn_41 sn_95 10098571.04010609
Csub_41_95 sn_41 sn_95 1.043363804679371e-18
Rsub_41_126 sn_41 sn_126 4581002.248315397
Csub_41_126 sn_41 sn_126 2.300038928403638e-18
Rsub_41_134 sn_41 sn_134 8386585.250113484
Csub_41_134 sn_41 sn_134 1.256349656981955e-18
Rsub_41_144 sn_41 sn_144 2187683.879695628
Csub_41_144 sn_41 sn_144 4.816273319935025e-18
Rsub_41_127 sn_41 sn_127 1696932.443476593
Csub_41_127 sn_41 sn_127 6.209135515520797e-18
Rsub_41_175 sn_41 sn_175 5614849.678464275
Csub_41_175 sn_41 sn_175 1.876538839969773e-18
Rsub_41_87 sn_41 sn_87 2249652.219881401
Csub_41_87 sn_41 sn_87 4.68360549649113e-18
Rsub_41_115 sn_41 sn_115 4328654.775415515
Csub_41_115 sn_41 sn_115 2.434124236950402e-18
Rsub_41_139 sn_41 sn_139 2458730.046492718
Csub_41_139 sn_41 sn_139 4.285335641974963e-18
Rsub_41_110 sn_41 sn_110 906838.6179532281
Csub_41_110 sn_41 sn_110 1.161891795699137e-17
Rsub_41_133 sn_41 sn_133 789533.7167476789
Csub_41_133 sn_41 sn_133 1.334519765113119e-17
Rsub_41_195 sn_41 sn_195 377199.0141062027
Csub_41_195 sn_41 sn_195 2.793348632471078e-17
Rsub_41_181 sn_41 sn_181 297674.0380986251
Csub_41_181 sn_41 sn_181 3.539604451073783e-17
Rsub_41_188 sn_41 sn_188 198581.798807511
Csub_41_188 sn_41 sn_188 5.305865676261303e-17
Rsub_41_69 sn_41 sn_69 1819664.587245121
Csub_41_69 sn_41 sn_69 5.790343767793875e-18
Rsub_41_153 sn_41 sn_153 370549.4997322239
Csub_41_153 sn_41 sn_153 2.843475300828674e-17
Rsub_41_206 sn_41 sn_206 334696.7146428397
Csub_41_206 sn_41 sn_206 3.148068995380983e-17
Rsub_41_166 sn_41 sn_166 1642263.650575535
Csub_41_166 sn_41 sn_166 6.415829454994921e-18
Rsub_41_129 sn_41 sn_129 226868.8861075346
Csub_41_129 sn_41 sn_129 4.644305212146088e-17
Rsub_41_50 sn_41 sn_50 555834.6885848131
Csub_41_50 sn_41 sn_50 1.895614598839898e-17
Rsub_41_198 sn_41 sn_198 407288.2495977167
Csub_41_198 sn_41 sn_198 2.586984405427116e-17
Rsub_41_230 sn_41 0 59369.35946861149
Csub_41_230 sn_41 0 1.774734239435517e-16
Rsub_41_72 sn_41 sn_72 2753335.28821472
Csub_41_72 sn_41 sn_72 3.826807271649768e-18
Rsub_41_201 sn_41 sn_201 1975605.31718836
Csub_41_201 sn_41 sn_201 5.33329375587291e-18
Rsub_41_191 sn_41 sn_191 5777765.535574772
Csub_41_191 sn_41 sn_191 1.82362600859362e-18
Rsub_41_112 sn_41 sn_112 4089859.941112472
Csub_41_112 sn_41 sn_112 2.576245557045653e-18
Rsub_41_199 sn_41 sn_199 503760.8621957293
Csub_41_199 sn_41 sn_199 2.091564528515555e-17
Rsub_41_177 sn_41 sn_177 458803.7840724619
Csub_41_177 sn_41 sn_177 2.296511900731382e-17
Rsub_41_138 sn_41 sn_138 372983.6977517494
Csub_41_138 sn_41 sn_138 2.824917969804373e-17
Rsub_41_76 sn_41 sn_76 23381.14276944181
Csub_41_76 sn_41 sn_76 4.506402277309025e-16
Rsub_41_204 sn_41 sn_204 332158.3330774996
Csub_41_204 sn_41 sn_204 3.172126800073872e-17
Rsub_41_162 sn_41 sn_162 4499944.81966611
Csub_41_162 sn_41 sn_162 2.34146949006628e-18
Rsub_41_131 sn_41 sn_131 92866.12613798516
Csub_41_131 sn_41 sn_131 1.134588459797964e-16
Rsub_41_43 sn_41 sn_43 1029501.12563636
Csub_41_43 sn_41 sn_43 1.023455267784884e-17
Rsub_41_210 sn_41 sn_210 1192553.406846621
Csub_41_210 sn_41 sn_210 8.835229887180341e-18
Rsub_41_55 sn_41 sn_55 73677311.06419072
Csub_41_55 sn_41 sn_55 1.430085239274026e-19
Rsub_41_222 sn_41 sn_222 227351.4762586781
Csub_41_222 sn_41 sn_222 4.634446925799463e-17
Rsub_41_99 sn_41 sn_99 100030.7823461275
Csub_41_99 sn_41 sn_99 1.053324112348892e-16
Rsub_41_178 sn_41 sn_178 462532.9035638909
Csub_41_178 sn_41 sn_178 2.27799653193204e-17
Rsub_41_149 sn_41 sn_149 7511459.405977345
Csub_41_149 sn_41 sn_149 1.402721220039537e-18
Rsub_41_67 sn_41 sn_67 218263.8384610974
Csub_41_67 sn_41 sn_67 4.827406856087153e-17
Rsub_41_48 sn_41 sn_48 146530.7327489838
Csub_41_48 sn_41 sn_48 7.190630459945662e-17
Rsub_41_215 sn_41 sn_215 626593.1628445704
Csub_41_215 sn_41 sn_215 1.681550985075723e-17
Rsub_41_220 sn_41 sn_220 4474973.193038912
Csub_41_220 sn_41 sn_220 2.354535557580575e-18
Rsub_41_145 sn_41 sn_145 2180663.253880414
Csub_41_145 sn_41 sn_145 4.831779268752614e-18
Rsub_41_52 sn_41 sn_52 2589.236041960741
Csub_41_52 sn_41 sn_52 4.069340659359537e-15
Rsub_41_219 sn_41 sn_219 180256.2879745978
Csub_41_219 sn_41 sn_219 5.845279307934508e-17
Rsub_41_228 sn_41 sn_228 5810752.665497041
Csub_41_228 sn_41 sn_228 1.813273444728305e-18
Rsub_41_61 sn_41 sn_61 1749432.116801544
Csub_41_61 sn_41 sn_61 6.022802143071243e-18
Rsub_41_214 sn_41 sn_214 31545791.98547595
Csub_41_214 sn_41 sn_214 3.340059906272481e-19
Rsub_41_47 sn_41 sn_47 200460.4559822881
Csub_41_47 sn_41 sn_47 5.256140644098386e-17
Rsub_41_46 sn_41 sn_46 25762.82401234149
Csub_41_46 sn_41 sn_46 4.089801450796922e-16
Rsub_41_213 sn_41 sn_213 2641197.414764266
Csub_41_213 sn_41 sn_213 3.98928283184406e-18
Rsub_41_101 sn_41 sn_101 207723.7852579794
Csub_41_101 sn_41 sn_101 5.072352927299287e-17
Rsub_41_180 sn_41 sn_180 4528350.347185339
Csub_41_180 sn_41 sn_180 2.326781872957136e-18
Rsub_41_97 sn_41 sn_97 903120.3018988485
Csub_41_97 sn_41 sn_97 1.166675522638191e-17
Rsub_41_176 sn_41 sn_176 4973655.433063592
Csub_41_176 sn_41 sn_176 2.11845867572292e-18
Rsub_41_216 sn_41 sn_216 3010080.519946127
Csub_41_216 sn_41 sn_216 3.500399219359945e-18
Rsub_41_49 sn_41 sn_49 645137.1794703141
Csub_41_49 sn_41 sn_49 1.633215979100897e-17
Rsub_41_93 sn_41 sn_93 943738.2118918324
Csub_41_93 sn_41 sn_93 1.116462528428133e-17
Rsub_41_78 sn_41 sn_78 441788.6446881751
Csub_41_78 sn_41 sn_78 2.384960235831073e-17
Rsub_41_157 sn_41 sn_157 6216620.070013432
Csub_41_157 sn_41 sn_157 1.694889406713774e-18
Rsub_41_100 sn_41 sn_100 8779706.433712555
Csub_41_100 sn_41 sn_100 1.200095194729032e-18
Rsub_41_105 sn_41 sn_105 807260.5499509498
Csub_41_105 sn_41 sn_105 1.305214716967181e-17
Rsub_41_227 sn_41 sn_227 331242.1722251958
Csub_41_227 sn_41 sn_227 3.180900376135303e-17
Rsub_41_60 sn_41 sn_60 1101395.184557497
Csub_41_60 sn_41 sn_60 9.56648771481891e-18
Rsub_41_190 sn_41 sn_190 37030932.51656514
Csub_41_190 sn_41 sn_190 2.845319517005599e-19
Rsub_41_114 sn_41 sn_114 690894.9550549255
Csub_41_114 sn_41 sn_114 1.525048551178429e-17
Rsub_41_132 sn_41 sn_132 687771.7888359212
Csub_41_132 sn_41 sn_132 1.531973784511194e-17
Rsub_41_158 sn_41 sn_158 2807385.423009607
Csub_41_158 sn_41 sn_158 3.753130373860299e-18
Rsub_41_211 sn_41 sn_211 4262109.797331894
Csub_41_211 sn_41 sn_211 2.472128594346843e-18
Rsub_41_44 sn_41 sn_44 1531102.269109171
Csub_41_44 sn_41 sn_44 6.881632739242403e-18
Rsub_41_107 sn_41 sn_107 15659497.32902684
Csub_41_107 sn_41 sn_107 6.728494076690005e-19
Rsub_41_186 sn_41 sn_186 32053873.96995809
Csub_41_186 sn_41 sn_186 3.287117030567079e-19
Rsub_41_182 sn_41 sn_182 1702338.829919054
Csub_41_182 sn_41 sn_182 6.189416182635633e-18
Rsub_41_118 sn_41 sn_118 2494421.301794197
Csub_41_118 sn_41 sn_118 4.224019212252268e-18
Rsub_41_168 sn_41 sn_168 547839.457719987
Csub_41_168 sn_41 sn_168 1.92327941219879e-17
Rsub_41_169 sn_41 sn_169 300553.0054373724
Csub_41_169 sn_41 sn_169 3.505698932172395e-17
Rsub_41_212 sn_41 sn_212 9738920.784196192
Csub_41_212 sn_41 sn_212 1.081894363421463e-18
Rsub_41_170 sn_41 sn_170 451360.0532527408
Csub_41_170 sn_41 sn_170 2.334385470379688e-17
Rsub_41_137 sn_41 sn_137 3867241.756008055
Csub_41_137 sn_41 sn_137 2.724547407945409e-18
Rsub_41_218 sn_41 sn_218 4638060.997216824
Csub_41_218 sn_41 sn_218 2.271743193664909e-18
Rsub_41_59 sn_41 sn_59 1575126.501232096
Csub_41_59 sn_41 sn_59 6.689293522766681e-18
Rsub_41_226 sn_41 sn_226 3096673.57369993
Csub_41_226 sn_41 sn_226 3.402516684908746e-18
Rsub_41_160 sn_41 sn_160 506407.1287585506
Csub_41_160 sn_41 sn_160 2.080634908923978e-17
Rsub_41_77 sn_41 sn_77 4907904.239624131
Csub_41_77 sn_41 sn_77 2.146839666748863e-18
Rsub_208_215 sn_208 sn_215 3275419.581923025
Csub_208_215 sn_208 sn_215 3.216834740923161e-18
Rsub_208_210 sn_208 sn_210 889732.4015648297
Csub_208_210 sn_208 sn_210 1.184230616272804e-17
Rsub_208_227 sn_208 sn_227 2325753.00045548
Csub_208_227 sn_208 sn_227 4.530353610278701e-18
Rsub_208_224 sn_208 sn_224 4088.480813541158
Csub_208_224 sn_208 sn_224 2.577114576967779e-15
Rsub_208_216 sn_208 sn_216 264146.2280012399
Csub_208_216 sn_208 sn_216 3.988882817656795e-17
Rsub_208_230 sn_208 0 49685.30557491558
Csub_208_230 sn_208 0 2.120643796050137e-16
Rsub_208_213 sn_208 sn_213 4694512.625807025
Csub_208_213 sn_208 sn_213 2.244425426466649e-18
Rsub_208_222 sn_208 sn_222 431680.8954554854
Csub_208_222 sn_208 sn_222 2.440803754150968e-17
Rsub_208_226 sn_208 sn_226 610105.3334311356
Csub_208_226 sn_208 sn_226 1.72699416393797e-17
Rsub_208_212 sn_208 sn_212 927410.2509899409
Csub_208_212 sn_208 sn_212 1.13611893883889e-17
Rsub_208_218 sn_208 sn_218 194825.5560410366
Csub_208_218 sn_208 sn_218 5.40816293115605e-17
Rsub_208_221 sn_208 sn_221 1075059.733460421
Csub_208_221 sn_208 sn_221 9.80083540875909e-18
Rsub_208_214 sn_208 sn_214 3502595.737290466
Csub_208_214 sn_208 sn_214 3.008192863953179e-18
Rsub_208_211 sn_208 sn_211 1479307.033760349
Csub_208_211 sn_208 sn_211 7.122580547357103e-18
Rsub_208_228 sn_208 sn_228 24922953.69837524
Csub_208_228 sn_208 sn_228 4.227622307430154e-19
Rsub_155_179 sn_155 sn_179 623161.1425557636
Csub_155_179 sn_155 sn_179 1.690812019988416e-17
Rsub_155_217 sn_155 sn_217 805490.8996587157
Csub_155_217 sn_155 sn_217 1.308082252287925e-17
Rsub_155_182 sn_155 sn_182 12166950.157959
Csub_155_182 sn_155 sn_182 8.659921644651082e-19
Rsub_155_209 sn_155 sn_209 906404.0671019627
Csub_155_209 sn_155 sn_209 1.162448833213889e-17
Rsub_155_201 sn_155 sn_201 15991439.61673808
Csub_155_201 sn_155 sn_201 6.588827369364275e-19
Rsub_155_204 sn_155 sn_204 3334620.411584968
Csub_155_204 sn_155 sn_204 3.159725006667832e-18
Rsub_155_221 sn_155 sn_221 3842249.0572192
Csub_155_221 sn_155 sn_221 2.742269786606625e-18
Rsub_155_178 sn_155 sn_178 5910328.788207032
Csub_155_178 sn_155 sn_178 1.78272375020043e-18
Rsub_155_227 sn_155 sn_227 699111.3981584387
Csub_155_227 sn_155 sn_227 1.507125120543683e-17
Rsub_155_215 sn_155 sn_215 633662.3455643789
Csub_155_215 sn_155 sn_215 1.662791481296803e-17
Rsub_155_202 sn_155 sn_202 2997055.72700174
Csub_155_202 sn_155 sn_202 3.515611474055145e-18
Rsub_155_169 sn_155 sn_169 271091.7352451862
Csub_155_169 sn_155 sn_169 3.88668562422251e-17
Rsub_155_198 sn_155 sn_198 899434.2350732168
Csub_155_198 sn_155 sn_198 1.171456799325889e-17
Rsub_155_174 sn_155 sn_174 4644390.515352788
Csub_155_174 sn_155 sn_174 2.268647192220366e-18
Rsub_155_196 sn_155 sn_196 1032375.22985481
Csub_155_196 sn_155 sn_196 1.020605996495268e-17
Rsub_155_167 sn_155 sn_167 1474204.291144206
Csub_155_167 sn_155 sn_167 7.147234318557092e-18
Rsub_155_203 sn_155 sn_203 394307.5184422295
Csub_155_203 sn_155 sn_203 2.672148769532964e-17
Rsub_155_165 sn_155 sn_165 414485.8565637107
Csub_155_165 sn_155 sn_165 2.542061046324372e-17
Rsub_155_213 sn_155 sn_213 1281111.24277469
Csub_155_213 sn_155 sn_213 8.224487577994861e-18
Rsub_155_188 sn_155 sn_188 6550927.765772779
Csub_155_188 sn_155 sn_188 1.608395616462284e-18
Rsub_155_170 sn_155 sn_170 900252.7722255227
Csub_155_170 sn_155 sn_170 1.170391675238352e-17
Rsub_155_205 sn_155 sn_205 3547880.463068384
Csub_155_205 sn_155 sn_205 2.969796646732998e-18
Rsub_155_197 sn_155 sn_197 976028.9968940172
Csub_155_197 sn_155 sn_197 1.079525663249748e-17
Rsub_155_159 sn_155 sn_159 618743.9722328709
Csub_155_159 sn_155 sn_159 1.702882609782336e-17
Rsub_155_176 sn_155 sn_176 676540.974162742
Csub_155_176 sn_155 sn_176 1.557405080345577e-17
Rsub_155_180 sn_155 sn_180 389444.8678376373
Csub_155_180 sn_155 sn_180 2.705513507144931e-17
Rsub_155_211 sn_155 sn_211 27343543.44161861
Csub_155_211 sn_155 sn_211 3.853371646848376e-19
Rsub_155_183 sn_155 sn_183 919106.5518444792
Csub_155_183 sn_155 sn_183 1.146383243714801e-17
Rsub_155_220 sn_155 sn_220 2195477.539796494
Csub_155_220 sn_155 sn_220 4.799176175223665e-18
Rsub_155_228 sn_155 sn_228 829828.3462155671
Csub_155_228 sn_155 sn_228 1.269718436382855e-17
Rsub_155_212 sn_155 sn_212 1153586.777745161
Csub_155_212 sn_155 sn_212 9.133672217381826e-18
Rsub_155_210 sn_155 sn_210 126599.1248060643
Csub_155_210 sn_155 sn_210 8.322714330269435e-17
Rsub_155_175 sn_155 sn_175 3123134.210447521
Csub_155_175 sn_155 sn_175 3.373688990688686e-18
Rsub_155_226 sn_155 sn_226 164774.102022897
Csub_155_226 sn_155 sn_226 6.394502153479099e-17
Rsub_155_189 sn_155 sn_189 496767.2935344802
Csub_155_189 sn_155 sn_189 2.121009905314685e-17
Rsub_155_158 sn_155 sn_158 2140.189047523751
Csub_155_158 sn_155 sn_158 4.923155510220447e-15
Rsub_155_195 sn_155 sn_195 593434.1629950277
Csub_155_195 sn_155 sn_195 1.77551010023639e-17
Rsub_155_192 sn_155 sn_192 1142106.516246891
Csub_155_192 sn_155 sn_192 9.225482345424526e-18
Rsub_155_219 sn_155 sn_219 498272.5753314691
Csub_155_219 sn_155 sn_219 2.114602332914018e-17
Rsub_155_181 sn_155 sn_181 53933.75279634372
Csub_155_181 sn_155 sn_181 1.953597321887879e-16
Rsub_155_218 sn_155 sn_218 923723.9854381066
Csub_155_218 sn_155 sn_218 1.140652799789834e-17
Rsub_155_216 sn_155 sn_216 19248.23621382168
Csub_155_216 sn_155 sn_216 5.47399947984014e-16
Rsub_155_222 sn_155 sn_222 63767.79954922132
Csub_155_222 sn_155 sn_222 1.652320383753725e-16
Rsub_155_185 sn_155 sn_185 970152.4124460177
Csub_155_185 sn_155 sn_185 1.086064763335966e-17
Rsub_155_208 sn_155 sn_208 593608.6855744075
Csub_155_208 sn_155 sn_208 1.774988095404018e-17
Rsub_155_171 sn_155 sn_171 240730.9798233322
Csub_155_171 sn_155 sn_171 4.376870608827547e-17
Rsub_155_184 sn_155 sn_184 32423.32009105782
Csub_155_184 sn_155 sn_184 3.249662117463383e-16
Rsub_155_156 sn_155 sn_156 202110.5333859554
Csub_155_156 sn_155 sn_156 5.213228289348615e-17
Rsub_155_230 sn_155 0 11511.60885955621
Csub_155_230 sn_155 0 9.152920005167898e-16
Rsub_155_190 sn_155 sn_190 12801.68185088258
Csub_155_190 sn_155 sn_190 8.230546286778399e-16
Rsub_155_162 sn_155 sn_162 16806.79927654034
Csub_155_162 sn_155 sn_162 6.269179115465064e-16
Rsub_155_177 sn_155 sn_177 181606.3103181895
Csub_155_177 sn_155 sn_177 5.801826755782437e-17
Rsub_155_214 sn_155 sn_214 1617476.940193145
Csub_155_214 sn_155 sn_214 6.514147584058801e-18
Rsub_155_157 sn_155 sn_157 878372.7982870984
Csub_155_157 sn_155 sn_157 1.19954574216973e-17
Rsub_155_186 sn_155 sn_186 1415983.390408348
Csub_155_186 sn_155 sn_186 7.441106706196206e-18
Rsub_155_166 sn_155 sn_166 161075.1038872521
Csub_155_166 sn_155 sn_166 6.541348258018345e-17
Rsub_155_168 sn_155 sn_168 471917.5133129915
Csub_155_168 sn_155 sn_168 2.232696012542737e-17
Rsub_155_163 sn_155 sn_163 2132806.691424637
Csub_155_163 sn_155 sn_163 4.94019619527357e-18
Rsub_155_200 sn_155 sn_200 1481443.568076518
Csub_155_200 sn_155 sn_200 7.112308378989014e-18
Rsub_155_207 sn_155 sn_207 329112.4274066954
Csub_155_207 sn_155 sn_207 3.201484545951135e-17
Rsub_155_160 sn_155 sn_160 157127.0362079802
Csub_155_160 sn_155 sn_160 6.70571007798012e-17
Rsub_155_206 sn_155 sn_206 4599003.028331396
Csub_155_206 sn_155 sn_206 2.291036434923339e-18
Rsub_155_191 sn_155 sn_191 194379.0033136445
Csub_155_191 sn_155 sn_191 5.420587266428476e-17
Rsub_155_224 sn_155 sn_224 103399.8785929561
Csub_155_224 sn_155 sn_224 1.019003469405213e-16
Rsub_155_164 sn_155 sn_164 206162.219602447
Csub_155_164 sn_155 sn_164 5.110773216619434e-17
Rsub_163_170 sn_163 sn_170 8078959.601237318
Csub_163_170 sn_163 sn_170 1.304188165592053e-18
Rsub_163_228 sn_163 sn_228 5749350.784776611
Csub_163_228 sn_163 sn_228 1.832638831175335e-18
Rsub_163_221 sn_163 sn_221 6811801.699286447
Csub_163_221 sn_163 sn_221 1.546798331392079e-18
Rsub_163_206 sn_163 sn_206 7749831.46983547
Csub_163_206 sn_163 sn_206 1.359575823453835e-18
Rsub_163_210 sn_163 sn_210 16463614.83046755
Csub_163_210 sn_163 sn_210 6.399860304512954e-19
Rsub_163_226 sn_163 sn_226 2586555.113414179
Csub_163_226 sn_163 sn_226 4.073558474585196e-18
Rsub_163_191 sn_163 sn_191 17979422.85925303
Csub_163_191 sn_163 sn_191 5.860301292600972e-19
Rsub_163_189 sn_163 sn_189 6424647.005633689
Csub_163_189 sn_163 sn_189 1.640009714617892e-18
Rsub_163_197 sn_163 sn_197 33711620.43619996
Csub_163_197 sn_163 sn_197 3.125475241443984e-19
Rsub_163_180 sn_163 sn_180 9969235.505369598
Csub_163_180 sn_163 sn_180 1.056899849196548e-18
Rsub_163_178 sn_163 sn_178 1390377.626288649
Csub_163_178 sn_163 sn_178 7.578145176541107e-18
Rsub_163_219 sn_163 sn_219 3637655.813827859
Csub_163_219 sn_163 sn_219 2.896503693993686e-18
Rsub_163_217 sn_163 sn_217 5485950.572755419
Csub_163_217 sn_163 sn_217 1.920630410809163e-18
Rsub_163_220 sn_163 sn_220 45335.50500868402
Csub_163_220 sn_163 sn_220 2.324112966252772e-16
Rsub_163_183 sn_163 sn_183 988320.5217625747
Csub_163_183 sn_163 sn_183 1.066099840104422e-17
Rsub_163_187 sn_163 sn_187 443146.8307527188
Csub_163_187 sn_163 sn_187 2.377650650086559e-17
Rsub_163_167 sn_163 sn_167 242194.2884388453
Csub_163_167 sn_163 sn_167 4.350426085663243e-17
Rsub_163_172 sn_163 sn_172 1380357.971123797
Csub_163_172 sn_163 sn_172 7.633152937604934e-18
Rsub_163_209 sn_163 sn_209 542732.9662597138
Csub_163_209 sn_163 sn_209 1.941375253993321e-17
Rsub_163_202 sn_163 sn_202 317631.2936699702
Csub_163_202 sn_163 sn_202 3.317205738921232e-17
Rsub_163_165 sn_163 sn_165 3200686.266377321
Csub_163_165 sn_163 sn_165 3.291945109682888e-18
Rsub_163_175 sn_163 sn_175 4804.50310805625
Csub_163_175 sn_163 sn_175 2.193043331486724e-15
Rsub_163_195 sn_163 sn_195 3408627.992515242
Csub_163_195 sn_163 sn_195 3.091121567201319e-18
Rsub_163_229 sn_163 sn_229 727224.4944698198
Csub_163_229 sn_163 sn_229 1.448862570272964e-17
Rsub_163_177 sn_163 sn_177 784237.3029346763
Csub_163_177 sn_163 sn_177 1.343532558678562e-17
Rsub_163_211 sn_163 sn_211 5954599.682248682
Csub_163_211 sn_163 sn_211 1.769469664541921e-18
Rsub_163_179 sn_163 sn_179 2713.203101812209
Csub_163_179 sn_163 sn_179 3.883411269577441e-15
Rsub_163_216 sn_163 sn_216 798226.5184450708
Csub_163_216 sn_163 sn_216 1.319986652755518e-17
Rsub_163_230 sn_163 0 29191.51915943419
Csub_163_230 sn_163 0 3.609433083863603e-16
Rsub_163_193 sn_163 sn_193 27228262.5154006
Csub_163_193 sn_163 sn_193 3.869686321802741e-19
Rsub_163_181 sn_163 sn_181 3224849.728024515
Csub_163_181 sn_163 sn_181 3.267278909360052e-18
Rsub_163_218 sn_163 sn_218 9200531.076689407
Csub_163_218 sn_163 sn_218 1.145203838170319e-18
Rsub_163_169 sn_163 sn_169 17330163.31220437
Csub_163_169 sn_163 sn_169 6.079852400934921e-19
Rsub_163_185 sn_163 sn_185 7893816.883417795
Csub_163_185 sn_163 sn_185 1.334776782618753e-18
Rsub_163_222 sn_163 sn_222 411339.1593319981
Csub_163_222 sn_163 sn_222 2.561507520786721e-17
Rsub_163_225 sn_163 sn_225 3224144.665729913
Csub_163_225 sn_163 sn_225 3.26799340433586e-18
Rsub_163_203 sn_163 sn_203 3537144.471008723
Csub_163_203 sn_163 sn_203 2.978810616470298e-18
Rsub_163_166 sn_163 sn_166 6961109.982365372
Csub_163_166 sn_163 sn_166 1.513621179513346e-18
Rsub_163_205 sn_163 sn_205 500415.1721103703
Csub_163_205 sn_163 sn_205 2.105548370525045e-17
Rsub_163_173 sn_163 sn_173 7371268.029906355
Csub_163_173 sn_163 sn_173 1.429399047691915e-18
Rsub_163_223 sn_163 sn_223 10997885.51880079
Csub_163_223 sn_163 sn_223 9.580462975558323e-19
Rsub_163_215 sn_163 sn_215 2516591.717882894
Csub_163_215 sn_163 sn_215 4.186806873501879e-18
Rsub_163_199 sn_163 sn_199 22302604.32685172
Csub_163_199 sn_163 sn_199 4.724328759015989e-19
Rsub_163_194 sn_163 sn_194 6210301.873458315
Csub_163_194 sn_163 sn_194 1.696613742282157e-18
Rsub_102_114 sn_102 sn_114 16983289.89442435
Csub_102_114 sn_102 sn_114 6.204029706687839e-19
Rsub_102_223 sn_102 sn_223 8470107.913561342
Csub_102_223 sn_102 sn_223 1.243960951826862e-18
Rsub_102_143 sn_102 sn_143 27131687.00077902
Csub_102_143 sn_102 sn_143 3.883460509450618e-19
Rsub_102_161 sn_102 sn_161 1887839.400221569
Csub_102_161 sn_102 sn_161 5.58123932628664e-18
Rsub_102_157 sn_102 sn_157 9909546.822609637
Csub_102_157 sn_102 sn_157 1.063265928386346e-18
Rsub_102_194 sn_102 sn_194 1619861.610070119
Csub_102_194 sn_102 sn_194 6.5045578194633e-18
Rsub_102_104 sn_102 sn_104 39438734.01384536
Csub_102_104 sn_102 sn_104 2.671607942215149e-19
Rsub_102_141 sn_102 sn_141 9670907.778960695
Csub_102_141 sn_102 sn_141 1.089503048012968e-18
Rsub_102_209 sn_102 sn_209 416326.3380625001
Csub_102_209 sn_102 sn_209 2.530823188190471e-17
Rsub_102_130 sn_102 sn_130 20396011.95323865
Csub_102_130 sn_102 sn_130 5.165952798216971e-19
Rsub_102_167 sn_102 sn_167 40447156.66086376
Csub_102_167 sn_102 sn_167 2.604999800251717e-19
Rsub_102_228 sn_102 sn_228 51183357.01061549
Csub_102_228 sn_102 sn_228 2.0585760914519e-19
Rsub_102_117 sn_102 sn_117 7254570.669273852
Csub_102_117 sn_102 sn_117 1.452392427143404e-18
Rsub_102_179 sn_102 sn_179 1060712.155583672
Csub_102_179 sn_102 sn_179 9.933405068250727e-18
Rsub_102_111 sn_102 sn_111 38058.27912991769
Csub_102_111 sn_102 sn_111 2.768512855313853e-16
Rsub_102_230 sn_102 0 724316.145906895
Csub_102_230 sn_102 0 1.454680192036528e-17
Rsub_102_119 sn_102 sn_119 136549.6500934144
Csub_102_119 sn_102 sn_119 7.716228855234657e-17
Rsub_102_109 sn_102 sn_109 327588.5208485093
Csub_102_109 sn_102 sn_109 3.216377507654645e-17
Rsub_102_220 sn_102 sn_220 3291679.486113612
Csub_102_220 sn_102 sn_220 3.200944547207454e-18
Rsub_102_145 sn_102 sn_145 19405210.42470455
Csub_102_145 sn_102 sn_145 5.429718756780975e-19
Rsub_102_108 sn_102 sn_108 17691.93984152687
Csub_102_108 sn_102 sn_108 5.955527543394965e-16
Rsub_102_122 sn_102 sn_122 2164368.983239771
Csub_102_122 sn_102 sn_122 4.868154914352123e-18
Rsub_102_115 sn_102 sn_115 3533923.47413179
Csub_102_115 sn_102 sn_115 2.981525655367676e-18
Rsub_102_177 sn_102 sn_177 2248945.483309064
Csub_102_177 sn_102 sn_177 4.685077330877218e-18
Rsub_102_187 sn_102 sn_187 939679904.0771896
Csub_102_187 sn_102 sn_187 1.121284328473251e-20
Rsub_102_113 sn_102 sn_113 478637.1798246031
Csub_102_113 sn_102 sn_113 2.20135082403985e-17
Rsub_102_175 sn_102 sn_175 58336.49829926933
Csub_102_175 sn_102 sn_175 1.806156318841299e-16
Rsub_102_212 sn_102 sn_212 17891685.92043605
Csub_102_212 sn_102 sn_212 5.889038936344804e-19
Rsub_102_121 sn_102 sn_121 27162461.4163984
Csub_102_121 sn_102 sn_121 3.879060642077512e-19
Rsub_102_195 sn_102 sn_195 20396011.95323865
Csub_102_195 sn_102 sn_195 5.165952798216971e-19
Rsub_102_128 sn_102 sn_128 10006908.87401833
Csub_102_128 sn_102 sn_128 1.052920900437761e-18
Rsub_102_202 sn_102 sn_202 4494649.357246486
Csub_102_202 sn_102 sn_202 2.344228139897628e-18
Rsub_4_46 sn_4 sn_46 1422902.648899899
Csub_4_46 sn_4 sn_46 7.404922262514699e-18
Rsub_4_24 sn_4 sn_24 39806784.88674395
Csub_4_24 sn_4 sn_24 2.646906433716719e-19
Rsub_4_98 sn_4 sn_98 347374674.645528
Csub_4_98 sn_4 sn_98 3.033175493573836e-20
Rsub_4_97 sn_4 sn_97 469576796.3443946
Csub_4_97 sn_4 sn_97 2.243825415620065e-20
Rsub_4_188 sn_4 sn_188 7954470.909905651
Csub_4_188 sn_4 sn_188 1.324598910671606e-18
Rsub_4_27 sn_4 sn_27 173656141.2425396
Csub_4_27 sn_4 sn_27 6.06744076359157e-20
Rsub_4_175 sn_4 sn_175 263617700.7804845
Csub_4_175 sn_4 sn_175 3.996880130216966e-20
Rsub_4_171 sn_4 sn_171 2151984.374430488
Csub_4_171 sn_4 sn_171 4.896171007291086e-18
Rsub_4_204 sn_4 sn_204 135403061.1106468
Csub_4_204 sn_4 sn_204 7.781569645327255e-20
Rsub_4_161 sn_4 sn_161 405844589.8027965
Csub_4_161 sn_4 sn_161 2.596186758914237e-20
Rsub_4_158 sn_4 sn_158 9135801.366243696
Csub_4_158 sn_4 sn_158 1.153317927988425e-18
Rsub_4_130 sn_4 sn_130 67267725.88968094
Csub_4_130 sn_4 sn_130 1.56635048425895e-19
Rsub_4_132 sn_4 sn_132 107300765.2758404
Csub_4_132 sn_4 sn_132 9.819579082351965e-20
Rsub_4_220 sn_4 sn_220 121591585.3502204
Csub_4_220 sn_4 sn_220 8.665470946761446e-20
Rsub_4_30 sn_4 sn_30 65057619.71561873
Csub_4_30 sn_4 sn_30 1.619561789731519e-19
Rsub_4_197 sn_4 sn_197 2111302.610137194
Csub_4_197 sn_4 sn_197 4.990513179702521e-18
Rsub_4_170 sn_4 sn_170 55697441.15256427
Csub_4_170 sn_4 sn_170 1.891735649644815e-19
Rsub_4_12 sn_4 sn_12 226050748.7970402
Csub_4_12 sn_4 sn_12 4.661114178254809e-20
Rsub_4_179 sn_4 sn_179 326129138.918768
Csub_4_179 sn_4 sn_179 3.230770343662675e-20
Rsub_4_151 sn_4 sn_151 147370620.4055826
Csub_4_151 sn_4 sn_151 7.149649959559282e-20
Rsub_4_153 sn_4 sn_153 145193471.0066235
Csub_4_153 sn_4 sn_153 7.256857645995214e-20
Rsub_4_164 sn_4 sn_164 20902571.31035213
Csub_4_164 sn_4 sn_164 5.040759505512004e-19
Rsub_4_6 sn_4 sn_6 195663008.4707603
Csub_4_6 sn_4 sn_6 5.385015586022004e-20
Rsub_4_181 sn_4 sn_181 17669421.63813298
Csub_4_181 sn_4 sn_181 5.963117366270131e-19
Rsub_4_196 sn_4 sn_196 38794818.99920178
Csub_4_196 sn_4 sn_196 2.71595119504148e-19
Rsub_4_29 sn_4 sn_29 200343604.2986729
Csub_4_29 sn_4 sn_29 5.259206321616426e-20
Rsub_4_117 sn_4 sn_117 64699162.72961848
Csub_4_117 sn_4 sn_117 1.628534753419078e-19
Rsub_4_144 sn_4 sn_144 91786957.56536089
Csub_4_144 sn_4 sn_144 1.147928178655125e-19
Rsub_4_184 sn_4 sn_184 11156834.46534839
Csub_4_184 sn_4 sn_184 9.443972244058012e-19
Rsub_4_141 sn_4 sn_141 8891713.365148526
Csub_4_141 sn_4 sn_141 1.184977863043609e-18
Rsub_4_186 sn_4 sn_186 5152185.065039307
Csub_4_186 sn_4 sn_186 2.045051443071488e-18
Rsub_4_19 sn_4 sn_19 217356355.5376886
Csub_4_19 sn_4 sn_19 4.847561726992164e-20
Rsub_4_32 sn_4 sn_32 23430552.79259964
Csub_4_32 sn_4 sn_32 4.496899238996132e-19
Rsub_4_190 sn_4 sn_190 24420331.10358889
Csub_4_190 sn_4 sn_190 4.314635807981132e-19
Rsub_4_23 sn_4 sn_23 551513963.0293988
Csub_4_23 sn_4 sn_23 1.910465411311508e-20
Rsub_4_35 sn_4 sn_35 4148603.482891486
Csub_4_35 sn_4 sn_35 2.539766344429307e-18
Rsub_4_202 sn_4 sn_202 671880091.4998844
Csub_4_202 sn_4 sn_202 1.568208916372069e-20
Rsub_4_77 sn_4 sn_77 101053193.7425548
Csub_4_77 sn_4 sn_77 1.0426670461374e-19
Rsub_4_33 sn_4 sn_33 7897029.348800211
Csub_4_33 sn_4 sn_33 1.334233803225108e-18
Rsub_4_224 sn_4 sn_224 1275387.399668656
Csub_4_224 sn_4 sn_224 8.261398462120109e-18
Rsub_4_57 sn_4 sn_57 4246004.081888948
Csub_4_57 sn_4 sn_57 2.481505740225894e-18
Rsub_4_66 sn_4 sn_66 50084939.93281551
Csub_4_66 sn_4 sn_66 2.103722898812249e-19
Rsub_4_166 sn_4 sn_166 4867942.681582149
Csub_4_166 sn_4 sn_166 2.164463345489824e-18
Rsub_4_115 sn_4 sn_115 185828820.8031197
Csub_4_115 sn_4 sn_115 5.66999427574967e-20
Rsub_4_226 sn_4 sn_226 1158656.976593845
Csub_4_226 sn_4 sn_226 9.093703930566721e-18
Rsub_4_59 sn_4 sn_59 1282443.164863131
Csub_4_59 sn_4 sn_59 8.215945775152157e-18
Rsub_4_203 sn_4 sn_203 62986668.82359622
Csub_4_203 sn_4 sn_203 1.672811675711734e-19
Rsub_4_36 sn_4 sn_36 14573172.88651161
Csub_4_36 sn_4 sn_36 7.230054555917731e-19
Rsub_4_45 sn_4 sn_45 1462179.638475331
Csub_4_45 sn_4 sn_45 7.206011645201668e-18
Rsub_4_212 sn_4 sn_212 17016881.69181445
Csub_4_212 sn_4 sn_212 6.191782779625432e-19
Rsub_4_160 sn_4 sn_160 3432851.034665013
Csub_4_160 sn_4 sn_160 3.069309852315855e-18
Rsub_4_177 sn_4 sn_177 86112435.38857177
Csub_4_177 sn_4 sn_177 1.223572815550439e-19
Rsub_4_10 sn_4 sn_10 163777226.4012546
Csub_4_10 sn_4 sn_10 6.433424068628192e-20
Rsub_4_93 sn_4 sn_93 778255.0560836527
Csub_4_93 sn_4 sn_93 1.353859948594726e-17
Rsub_4_214 sn_4 sn_214 68679120.20954619
Csub_4_214 sn_4 sn_214 1.53416110603663e-19
Rsub_4_47 sn_4 sn_47 50266712.67360828
Csub_4_47 sn_4 sn_47 2.096115489120102e-19
Rsub_4_56 sn_4 sn_56 11063989.22969834
Csub_4_56 sn_4 sn_56 9.523222848000981e-19
Rsub_4_123 sn_4 sn_123 2316171151.737152
Rsub_4_44 sn_4 sn_44 45119.32135021641
Csub_4_44 sn_4 sn_44 2.335248666629039e-16
Rsub_4_211 sn_4 sn_211 39544491.48169405
Csub_4_211 sn_4 sn_211 2.664463015565026e-19
Rsub_4_192 sn_4 sn_192 20829846.35104999
Csub_4_192 sn_4 sn_192 5.058358724618669e-19
Rsub_4_25 sn_4 sn_25 2702996.339984367
Csub_4_25 sn_4 sn_25 3.89807538632884e-18
Rsub_4_217 sn_4 sn_217 525338279.7826921
Csub_4_217 sn_4 sn_217 2.005656908647215e-20
Rsub_4_138 sn_4 sn_138 29666396.73513309
Csub_4_138 sn_4 sn_138 3.551655968300302e-19
Rsub_4_128 sn_4 sn_128 35858846.83731178
Csub_4_128 sn_4 sn_128 2.938321901435658e-19
Rsub_4_207 sn_4 sn_207 122657.7621632967
Csub_4_207 sn_4 sn_207 8.590148162170588e-17
Rsub_4_222 sn_4 sn_222 2597073.210866026
Csub_4_222 sn_4 sn_222 4.057060639702367e-18
Rsub_4_55 sn_4 sn_55 551513963.0293988
Csub_4_55 sn_4 sn_55 1.910465411311508e-20
Rsub_4_131 sn_4 sn_131 25650669.57894726
Csub_4_131 sn_4 sn_131 4.107683610285871e-19
Rsub_4_120 sn_4 sn_120 2324492.541652936
Csub_4_120 sn_4 sn_120 4.532810199828628e-18
Rsub_4_218 sn_4 sn_218 1603542.165534113
Csub_4_218 sn_4 sn_218 6.570755499104993e-18
Rsub_4_51 sn_4 sn_51 552722257.5763917
Csub_4_51 sn_4 sn_51 1.90628898290273e-20
Rsub_4_139 sn_4 sn_139 36950097.52600356
Csub_4_139 sn_4 sn_139 2.85154416569942e-19
Rsub_4_176 sn_4 sn_176 70412984.60679382
Csub_4_176 sn_4 sn_176 1.496383594740193e-19
Rsub_4_9 sn_4 sn_9 336945464.6964919
Csub_4_9 sn_4 sn_9 3.127059006928875e-20
Rsub_4_208 sn_4 sn_208 2220082.919193988
Csub_4_208 sn_4 sn_208 4.74598647245812e-18
Rsub_4_41 sn_4 sn_41 551513963.0293988
Csub_4_41 sn_4 sn_41 1.910465411311508e-20
Rsub_4_5 sn_4 sn_5 275928315.8192886
Csub_4_5 sn_4 sn_5 3.818558262476611e-20
Rsub_4_84 sn_4 sn_84 7195865.511864135
Csub_4_84 sn_4 sn_84 1.464241304240337e-18
Rsub_4_58 sn_4 sn_58 68212586.68186921
Csub_4_58 sn_4 sn_58 1.544653855654265e-19
Rsub_4_225 sn_4 sn_225 396470339.1155962
Csub_4_225 sn_4 sn_225 2.657571692685427e-20
Rsub_4_216 sn_4 sn_216 9106668.005872013
Csub_4_216 sn_4 sn_216 1.157007535076061e-18
Rsub_4_49 sn_4 sn_49 54727381.0374495
Csub_4_49 sn_4 sn_49 1.925267261559615e-19
Rsub_4_221 sn_4 sn_221 18300405.6864376
Csub_4_221 sn_4 sn_221 5.757513621699968e-19
Rsub_4_54 sn_4 sn_54 51579316.74706497
Csub_4_54 sn_4 sn_54 2.042772988618459e-19
Rsub_4_142 sn_4 sn_142 55424363.53612901
Csub_4_142 sn_4 sn_142 1.901056291852892e-19
Rsub_4_146 sn_4 sn_146 49897313.6929582
Csub_4_146 sn_4 sn_146 2.111633417194756e-19
Rsub_4_215 sn_4 sn_215 46269498.40313661
Csub_4_215 sn_4 sn_215 2.277198557552492e-19
Rsub_4_48 sn_4 sn_48 26610650.16677916
Csub_4_48 sn_4 sn_48 3.959498710551531e-19
Rsub_4_127 sn_4 sn_127 135396880.1017857
Csub_4_127 sn_4 sn_127 7.781924882101501e-20
Rsub_4_155 sn_4 sn_155 7352795.728590986
Csub_4_155 sn_4 sn_155 1.432990102153852e-18
Rsub_4_76 sn_4 sn_76 115211670.4460602
Csub_4_76 sn_4 sn_76 9.145326564085337e-20
Rsub_4_21 sn_4 sn_21 184982235.6424871
Csub_4_21 sn_4 sn_21 5.695943432424361e-20
Rsub_4_148 sn_4 sn_148 41606704.36716352
Csub_4_148 sn_4 sn_148 2.532400405773429e-19
Rsub_4_157 sn_4 sn_157 303822457.9022005
Csub_4_157 sn_4 sn_157 3.467973886782808e-20
Rsub_4_168 sn_4 sn_168 54050412.45997049
Csub_4_168 sn_4 sn_168 1.949380776702357e-19
Rsub_4_135 sn_4 sn_135 717753489.7067325
Csub_4_135 sn_4 sn_135 1.467980811425258e-20
Rsub_4_140 sn_4 sn_140 551513963.0293988
Csub_4_140 sn_4 sn_140 1.910465411311508e-20
Rsub_4_64 sn_4 sn_64 976672.9802118961
Csub_4_64 sn_4 sn_64 1.078813862542203e-17
Rsub_4_70 sn_4 sn_70 507335841.2139942
Csub_4_70 sn_4 sn_70 2.076826166473366e-20
Rsub_4_90 sn_4 sn_90 353340097.7610563
Csub_4_90 sn_4 sn_90 2.981966544129737e-20
Rsub_4_162 sn_4 sn_162 4715780.426414119
Csub_4_162 sn_4 sn_162 2.234303243470126e-18
Rsub_4_134 sn_4 sn_134 92001428.61182731
Csub_4_134 sn_4 sn_134 1.145252161973002e-19
Rsub_4_88 sn_4 sn_88 141455034.8488626
Csub_4_88 sn_4 sn_88 7.448645086042846e-20
Rsub_4_227 sn_4 sn_227 14025741.61927751
Csub_4_227 sn_4 sn_227 7.512246972914612e-19
Rsub_4_118 sn_4 sn_118 326256615.9317098
Csub_4_118 sn_4 sn_118 3.229507996991987e-20
Rsub_4_174 sn_4 sn_174 275285680.6956889
Csub_4_174 sn_4 sn_174 3.827472419053072e-20
Rsub_4_229 sn_4 sn_229 150977327.6807843
Csub_4_229 sn_4 sn_229 6.978851503126077e-20
Rsub_4_137 sn_4 sn_137 664033966.7532285
Csub_4_137 sn_4 sn_137 1.586738635336348e-20
Rsub_4_42 sn_4 sn_42 459159.9170261278
Csub_4_42 sn_4 sn_42 2.294730683477852e-17
Rsub_4_195 sn_4 sn_195 135069630.4139166
Csub_4_195 sn_4 sn_195 7.800779101816805e-20
Rsub_4_150 sn_4 sn_150 102834896.8250144
Csub_4_150 sn_4 sn_150 1.02460194229193e-19
Rsub_4_156 sn_4 sn_156 113568031.0373906
Csub_4_156 sn_4 sn_156 9.277684402894175e-20
Rsub_4_87 sn_4 sn_87 413880349.4800853
Csub_4_87 sn_4 sn_87 2.545780082447956e-20
Rsub_4_95 sn_4 sn_95 377993741.7708097
Csub_4_95 sn_4 sn_95 2.787475647842506e-20
Rsub_4_8 sn_4 sn_8 60226542.08923627
Csub_4_8 sn_4 sn_8 1.749475088013245e-19
Rsub_4_159 sn_4 sn_159 1085968681.551073
Rsub_4_74 sn_4 sn_74 55253561.69988035
Csub_4_74 sn_4 sn_74 1.906932906779984e-19
Rsub_4_230 sn_4 0 845703.4909356921
Csub_4_230 sn_4 0 1.245883884264492e-17
Rsub_4_83 sn_4 sn_83 294938759.0203941
Csub_4_83 sn_4 sn_83 3.572430947097541e-20
Rsub_4_122 sn_4 sn_122 242653029.7708616
Csub_4_122 sn_4 sn_122 4.342201501534785e-20
Rsub_4_72 sn_4 sn_72 242548467.105411
Csub_4_72 sn_4 sn_72 4.344073424983085e-20
Rsub_4_210 sn_4 sn_210 107095424.2191575
Csub_4_210 sn_4 sn_210 9.838406803140717e-20
Rsub_4_213 sn_4 sn_213 87036349.53498876
Csub_4_213 sn_4 sn_213 1.210584262612521e-19
Rsub_4_185 sn_4 sn_185 226822449.6480704
Csub_4_185 sn_4 sn_185 4.645256022310857e-20
Rsub_4_125 sn_4 sn_125 64794032.7691685
Csub_4_125 sn_4 sn_125 1.626150287599272e-19
Rsub_4_205 sn_4 sn_205 500627305.3323175
Csub_4_205 sn_4 sn_205 2.104656176361747e-20
Rsub_4_116 sn_4 sn_116 46719836.004525
Csub_4_116 sn_4 sn_116 2.255248391969848e-19
Rsub_4_20 sn_4 sn_20 525774181.0995828
Csub_4_20 sn_4 sn_20 2.003994087384517e-20
Rsub_4_165 sn_4 sn_165 58767179.16362463
Csub_4_165 sn_4 sn_165 1.792919730398054e-19
Rsub_4_206 sn_4 sn_206 16071990.62514379
Csub_4_206 sn_4 sn_206 6.555804908040592e-19
Rsub_4_180 sn_4 sn_180 8846327.110534014
Csub_4_180 sn_4 sn_180 1.191057415193633e-18
Rsub_4_13 sn_4 sn_13 546227911.9958166
Csub_4_13 sn_4 sn_13 1.928953696952546e-20
Rsub_4_68 sn_4 sn_68 276361128.7881958
Csub_4_68 sn_4 sn_68 3.812577965805459e-20
Rsub_4_61 sn_4 sn_61 410138426.8854855
Csub_4_61 sn_4 sn_61 2.569006660078668e-20
Rsub_4_92 sn_4 sn_92 258918693.2362454
Csub_4_92 sn_4 sn_92 4.069417843313533e-20
Rsub_4_169 sn_4 sn_169 61879601.94276935
Csub_4_169 sn_4 sn_169 1.702739379606044e-19
Rsub_4_108 sn_4 sn_108 552722257.5763917
Csub_4_108 sn_4 sn_108 1.90628898290273e-20
Rsub_4_194 sn_4 sn_194 552722257.5763917
Csub_4_194 sn_4 sn_194 1.90628898290273e-20
Rsub_4_34 sn_4 sn_34 18162173.03104959
Csub_4_34 sn_4 sn_34 5.801334170871017e-19
Rsub_4_110 sn_4 sn_110 6502518906.888356
Rsub_4_191 sn_4 sn_191 157624265.9812681
Csub_4_191 sn_4 sn_191 6.684556744252909e-20
Rsub_4_152 sn_4 sn_152 242834490.7175467
Csub_4_152 sn_4 sn_152 4.338956740080851e-20
Rsub_4_91 sn_4 sn_91 1740917241.204929
Rsub_4_89 sn_4 sn_89 552722257.5763917
Csub_4_89 sn_4 sn_89 1.90628898290273e-20
Rsub_4_96 sn_4 sn_96 164676975.6966601
Csub_4_96 sn_4 sn_96 6.398273624868188e-20
Rsub_4_183 sn_4 sn_183 401905424.6584823
Csub_4_183 sn_4 sn_183 2.621632567209895e-20
Rsub_4_112 sn_4 sn_112 158483862.4770036
Csub_4_112 sn_4 sn_112 6.648300550952859e-20
Rsub_4_167 sn_4 sn_167 552722257.5763917
Csub_4_167 sn_4 sn_167 1.90628898290273e-20
Rsub_39_190 sn_39 sn_190 106773952.0888566
Csub_39_190 sn_39 sn_190 9.868028012545241e-20
Rsub_39_121 sn_39 sn_121 121675260.8821761
Csub_39_121 sn_39 sn_121 8.659511741201833e-20
Rsub_39_86 sn_39 sn_86 46226785.98809548
Csub_39_86 sn_39 sn_86 2.279302633097487e-19
Rsub_39_119 sn_39 sn_119 121675260.8821761
Csub_39_119 sn_39 sn_119 8.659511741201833e-20
Rsub_39_161 sn_39 sn_161 29717810.80041486
Csub_39_161 sn_39 sn_161 3.545511334261175e-19
Rsub_39_122 sn_39 sn_122 35031225.20967223
Csub_39_122 sn_39 sn_122 3.007740505553556e-19
Rsub_39_184 sn_39 sn_184 59776677.3133568
Csub_39_184 sn_39 sn_184 1.762641213227099e-19
Rsub_39_92 sn_39 sn_92 12868378.34875843
Csub_39_92 sn_39 sn_92 8.187887561797239e-19
Rsub_39_176 sn_39 sn_176 48791340.40328405
Csub_39_176 sn_39 sn_176 2.159498676433331e-19
Rsub_39_183 sn_39 sn_183 28599364.74050065
Csub_39_183 sn_39 sn_183 3.684166972879956e-19
Rsub_39_146 sn_39 sn_146 120056146.1892057
Csub_39_146 sn_39 sn_146 8.776296621769571e-20
Rsub_39_162 sn_39 sn_162 32297193.71043891
Csub_39_162 sn_39 sn_162 3.262352635555596e-19
Rsub_39_64 sn_39 sn_64 28080765.27211294
Csub_39_64 sn_39 sn_64 3.752206679599934e-19
Rsub_39_147 sn_39 sn_147 121578597.3184167
Csub_39_147 sn_39 sn_147 8.666396664072994e-20
Rsub_39_180 sn_39 sn_180 121578597.3184167
Csub_39_180 sn_39 sn_180 8.666396664072994e-20
Rsub_39_158 sn_39 sn_158 35078038.97736292
Csub_39_158 sn_39 sn_158 3.003726493670173e-19
Rsub_39_118 sn_39 sn_118 61265487.16239411
Csub_39_118 sn_39 sn_118 1.719807348352808e-19
Rsub_39_73 sn_39 sn_73 689553.7735756984
Csub_39_73 sn_39 sn_73 1.528014769260532e-17
Rsub_39_165 sn_39 sn_165 15305364.64350717
Csub_39_165 sn_39 sn_165 6.884176723420819e-19
Rsub_39_91 sn_39 sn_91 90316415.5414312
Csub_39_91 sn_39 sn_91 1.166618874217451e-19
Rsub_39_197 sn_39 sn_197 16524871.49804396
Csub_39_197 sn_39 sn_197 6.376136421682432e-19
Rsub_39_98 sn_39 sn_98 32009206.47395402
Csub_39_98 sn_39 sn_98 3.291704063580447e-19
Rsub_39_152 sn_39 sn_152 27820411.92667412
Csub_39_152 sn_39 sn_152 3.787321169075738e-19
Rsub_39_172 sn_39 sn_172 26859852.64027396
Csub_39_172 sn_39 sn_172 3.922762959031086e-19
Rsub_39_174 sn_39 sn_174 11407021.43806528
Csub_39_174 sn_39 sn_174 9.236840273719227e-19
Rsub_39_137 sn_39 sn_137 44995226.6329352
Csub_39_137 sn_39 sn_137 2.341689172539383e-19
Rsub_39_75 sn_39 sn_75 275212570.2880066
Csub_39_75 sn_39 sn_75 3.82848918972113e-20
Rsub_39_96 sn_39 sn_96 10292793.96758549
Csub_39_96 sn_39 sn_96 1.023675742020287e-18
Rsub_39_200 sn_39 sn_200 2883284.047489778
Csub_39_200 sn_39 sn_200 3.654334199713411e-18
Rsub_39_205 sn_39 sn_205 241269.3081856979
Csub_39_205 sn_39 sn_205 4.367104784882287e-17
Rsub_39_156 sn_39 sn_156 81409316.03593245
Csub_39_156 sn_39 sn_156 1.294260167666733e-19
Rsub_39_81 sn_39 sn_81 26934535.47085135
Csub_39_81 sn_39 sn_81 3.91188610385823e-19
Rsub_39_128 sn_39 sn_128 7359798.297849829
Csub_39_128 sn_39 sn_128 1.431626666359626e-18
Rsub_39_168 sn_39 sn_168 6971107.627887746
Csub_39_168 sn_39 sn_168 1.511450412855348e-18
Rsub_39_140 sn_39 sn_140 60066723.70334955
Csub_39_140 sn_39 sn_140 1.754129883005829e-19
Rsub_39_85 sn_39 sn_85 887946.7944104193
Csub_39_85 sn_39 sn_85 1.186612032224976e-17
Rsub_39_66 sn_39 sn_66 965736.4867163954
Csub_39_66 sn_39 sn_66 1.09103090202744e-17
Rsub_39_189 sn_39 sn_189 31100591.88646703
Csub_39_189 sn_39 sn_189 3.387872340402241e-19
Rsub_39_100 sn_39 sn_100 24453824.13941238
Csub_39_100 sn_39 sn_100 4.308726292526283e-19
Rsub_39_175 sn_39 sn_175 11071070.99610375
Csub_39_175 sn_39 sn_175 9.517131184451905e-19
Rsub_39_157 sn_39 sn_157 5704138.198807965
Csub_39_157 sn_39 sn_157 1.847164836299353e-18
Rsub_39_192 sn_39 sn_192 29893311.3034825
Csub_39_192 sn_39 sn_192 3.524696008167728e-19
Rsub_39_155 sn_39 sn_155 3593459.62418382
Csub_39_155 sn_39 sn_155 2.932127978096636e-18
Rsub_39_196 sn_39 sn_196 24305557.38650886
Csub_39_196 sn_39 sn_196 4.335010028644076e-19
Rsub_39_166 sn_39 sn_166 15514940.06907775
Csub_39_166 sn_39 sn_166 6.791185435018128e-19
Rsub_39_144 sn_39 sn_144 25924151.1526852
Csub_39_144 sn_39 sn_144 4.064350435303893e-19
Rsub_39_191 sn_39 sn_191 61645634.94424105
Csub_39_191 sn_39 sn_191 1.709201878082744e-19
Rsub_39_223 sn_39 sn_223 85254112.35172553
Csub_39_223 sn_39 sn_223 1.235891526119062e-19
Rsub_39_207 sn_39 sn_207 9756120.497040413
Csub_39_207 sn_39 sn_207 1.079987019986716e-18
Rsub_39_164 sn_39 sn_164 120636127.5717623
Csub_39_164 sn_39 sn_164 8.734102888011064e-20
Rsub_39_199 sn_39 sn_199 11244962.96525357
Csub_39_199 sn_39 sn_199 9.36995838473391e-19
Rsub_39_134 sn_39 sn_134 16262491.36291085
Csub_39_134 sn_39 sn_134 6.479009437791369e-19
Rsub_39_210 sn_39 sn_210 16675023.47233082
Csub_39_210 sn_39 sn_210 6.318721841509479e-19
Rsub_39_43 sn_39 sn_43 3164407.300481379
Csub_39_43 sn_39 sn_43 3.329686257716306e-18
Rsub_39_148 sn_39 sn_148 52900228.10159802
Csub_39_148 sn_39 sn_148 1.991765230575955e-19
Rsub_39_111 sn_39 sn_111 17205243.20721423
Csub_39_111 sn_39 sn_111 6.123995676975963e-19
Rsub_39_58 sn_39 sn_58 32766149.64840206
Csub_39_58 sn_39 sn_58 3.215661167177708e-19
Rsub_39_225 sn_39 sn_225 16448076.4338406
Csub_39_225 sn_39 sn_225 6.405906213173981e-19
Rsub_39_208 sn_39 sn_208 27164867.65906995
Csub_39_208 sn_39 sn_208 3.878717037928224e-19
Rsub_39_41 sn_39 sn_41 2416071.661058916
Csub_39_41 sn_39 sn_41 4.360997925703939e-18
Rsub_39_169 sn_39 sn_169 6428142.896800087
Csub_39_169 sn_39 sn_169 1.639117809200389e-18
Rsub_39_79 sn_39 sn_79 6066750.435732307
Csub_39_79 sn_39 sn_79 1.73675901355223e-18
Rsub_39_83 sn_39 sn_83 13996358.17804443
Csub_39_83 sn_39 sn_83 7.528017908800155e-19
Rsub_39_182 sn_39 sn_182 149532539.6296334
Csub_39_182 sn_39 sn_182 7.046281383521656e-20
Rsub_39_105 sn_39 sn_105 714490.4593575754
Csub_39_105 sn_39 sn_105 1.474684982036533e-17
Rsub_39_177 sn_39 sn_177 2310630.692857826
Csub_39_177 sn_39 sn_177 4.56000326438939e-18
Rsub_39_87 sn_39 sn_87 5817063.820047609
Csub_39_87 sn_39 sn_87 1.811306155163305e-18
Rsub_39_198 sn_39 sn_198 4841494.706700907
Csub_39_198 sn_39 sn_198 2.176287312190366e-18
Rsub_39_170 sn_39 sn_170 2086490.293412603
Csub_39_170 sn_39 sn_170 5.049859822255311e-18
Rsub_39_117 sn_39 sn_117 2822221.545788437
Csub_39_117 sn_39 sn_117 3.733400560970647e-18
Rsub_39_138 sn_39 sn_138 817658.0000712482
Csub_39_138 sn_39 sn_138 1.288617429452398e-17
Rsub_39_226 sn_39 sn_226 8689952.752437945
Csub_39_226 sn_39 sn_226 1.212490309486898e-18
Rsub_39_59 sn_39 sn_59 15404333.46573681
Csub_39_59 sn_39 sn_59 6.839947684634223e-19
Rsub_39_131 sn_39 sn_131 1171663.649194844
Csub_39_131 sn_39 sn_131 8.992754455999867e-18
Rsub_39_130 sn_39 sn_130 3947775.499957558
Csub_39_130 sn_39 sn_130 2.668967245564819e-18
Rsub_39_218 sn_39 sn_218 2406064.920920666
Csub_39_218 sn_39 sn_218 4.379135164066263e-18
Rsub_39_51 sn_39 sn_51 32040.63082225357
Csub_39_51 sn_39 sn_51 3.288475673491413e-16
Rsub_39_209 sn_39 sn_209 139989607.6434739
Csub_39_209 sn_39 sn_209 7.526618353745486e-20
Rsub_39_204 sn_39 sn_204 186493.9008255144
Csub_39_204 sn_39 sn_204 5.649773775759048e-17
Rsub_39_213 sn_39 sn_213 9256058.747600341
Csub_39_213 sn_39 sn_213 1.138333689267218e-18
Rsub_39_46 sn_39 sn_46 586096.7678344118
Csub_39_46 sn_39 sn_46 1.797737861814458e-17
Rsub_39_125 sn_39 sn_125 11982048.5305307
Csub_39_125 sn_39 sn_125 8.793557692061297e-19
Rsub_39_132 sn_39 sn_132 3051172.692900253
Csub_39_132 sn_39 sn_132 3.453257013851511e-18
Rsub_39_114 sn_39 sn_114 1973732.021272351
Csub_39_114 sn_39 sn_114 5.338355657541463e-18
Rsub_39_97 sn_39 sn_97 38983.12241020946
Csub_39_97 sn_39 sn_97 2.702832110613734e-16
Rsub_39_206 sn_39 sn_206 1638442.561827857
Csub_39_206 sn_39 sn_206 6.430792111793917e-18
Rsub_39_127 sn_39 sn_127 7705257.000446308
Csub_39_127 sn_39 sn_127 1.367440891539335e-18
Rsub_39_110 sn_39 sn_110 2354430.151950072
Csub_39_110 sn_39 sn_110 4.475173533393246e-18
Rsub_39_195 sn_39 sn_195 98676.72135016347
Csub_39_195 sn_39 sn_195 1.067778028907174e-16
Rsub_39_99 sn_39 sn_99 1031640.206475639
Csub_39_99 sn_39 sn_99 1.02133315821661e-17
Rsub_39_178 sn_39 sn_178 2962281.63876697
Csub_39_178 sn_39 sn_178 3.556881075837118e-18
Rsub_39_72 sn_39 sn_72 70531.08689715569
Csub_39_72 sn_39 sn_72 1.493877943153448e-16
Rsub_39_63 sn_39 sn_63 25711434.90610831
Csub_39_63 sn_39 sn_63 4.097975683078983e-19
Rsub_39_230 sn_39 0 79708.9421313871
Csub_39_230 sn_39 0 1.321869694978807e-16
Rsub_39_151 sn_39 sn_151 40425255.63845263
Csub_39_151 sn_39 sn_151 2.606411100145936e-19
Rsub_39_153 sn_39 sn_153 261632.8905931123
Csub_39_153 sn_39 sn_153 4.027201426527136e-17
Rsub_39_126 sn_39 sn_126 3626170.231050692
Csub_39_126 sn_39 sn_126 2.905678120681342e-18
Rsub_39_228 sn_39 sn_228 12451342.37764577
Csub_39_228 sn_39 sn_228 8.462126558455599e-19
Rsub_39_61 sn_39 sn_61 345985.1979306124
Csub_39_61 sn_39 sn_61 3.045356727758944e-17
Rsub_39_52 sn_39 sn_52 575839.7557290198
Csub_39_52 sn_39 sn_52 1.829759650562975e-17
Rsub_39_219 sn_39 sn_219 599971.8203998646
Csub_39_219 sn_39 sn_219 1.756163063659844e-17
Rsub_39_112 sn_39 sn_112 1477842.889503643
Csub_39_112 sn_39 sn_112 7.129637106261579e-18
Rsub_39_78 sn_39 sn_78 2070334.074374335
Csub_39_78 sn_39 sn_78 5.089267298763933e-18
Rsub_39_129 sn_39 sn_129 3375744.766282976
Csub_39_129 sn_39 sn_129 3.121232270718055e-18
Rsub_39_217 sn_39 sn_217 7534906.75334702
Csub_39_217 sn_39 sn_217 1.398356190346971e-18
Rsub_39_50 sn_39 sn_50 1608997.670932499
Csub_39_50 sn_39 sn_50 6.54847654075444e-18
Rsub_39_216 sn_39 sn_216 28585557.60051158
Csub_39_216 sn_39 sn_216 3.685946466211817e-19
Rsub_39_49 sn_39 sn_49 7214199.380108424
Csub_39_49 sn_39 sn_49 1.460520141886021e-18
Rsub_39_67 sn_39 sn_67 6586159.024542592
Csub_39_67 sn_39 sn_67 1.599791845743014e-18
Rsub_39_48 sn_39 sn_48 16737.73973483851
Csub_39_48 sn_39 sn_48 6.295045608995224e-16
Rsub_39_215 sn_39 sn_215 5949563.696611916
Csub_39_215 sn_39 sn_215 1.770967425431581e-18
Rsub_39_101 sn_39 sn_101 526655.5516543952
Csub_39_101 sn_39 sn_101 2.000640355756529e-17
Rsub_39_181 sn_39 sn_181 2549422.78009944
Csub_39_181 sn_39 sn_181 4.132889838624188e-18
Rsub_39_135 sn_39 sn_135 14718713.78992421
Csub_39_135 sn_39 sn_135 7.15856266560657e-19
Rsub_39_47 sn_39 sn_47 4942299.938655994
Csub_39_47 sn_39 sn_47 2.131898839206284e-18
Rsub_39_203 sn_39 sn_203 59033726.62452679
Csub_39_203 sn_39 sn_203 1.78482438847972e-19
Rsub_39_45 sn_39 sn_45 7676623.800676418
Csub_39_45 sn_39 sn_45 1.372541337938377e-18
Rsub_39_212 sn_39 sn_212 9409984.011634152
Csub_39_212 sn_39 sn_212 1.119713220469141e-18
Rsub_39_133 sn_39 sn_133 4183535.852695019
Csub_39_133 sn_39 sn_133 2.518559389288474e-18
Rsub_39_160 sn_39 sn_160 23103835.97033643
Csub_39_160 sn_39 sn_160 4.560490957327626e-19
Rsub_39_159 sn_39 sn_159 30948870.79623901
Csub_39_159 sn_39 sn_159 3.404480755243071e-19
Rsub_39_80 sn_39 sn_80 9388325.213462649
Csub_39_80 sn_39 sn_80 1.122296390747193e-18
Rsub_39_62 sn_39 sn_62 8771273.145226061
Csub_39_62 sn_39 sn_62 1.201249046492719e-18
Rsub_39_229 sn_39 sn_229 4211896.832112842
Csub_39_229 sn_39 sn_229 2.501600566731952e-18
Rsub_39_71 sn_39 sn_71 14401720.46754934
Csub_39_71 sn_39 sn_71 7.316128323675854e-19
Rsub_39_141 sn_39 sn_141 2206341.732109546
Csub_39_141 sn_39 sn_141 4.775544671475604e-18
Rsub_39_53 sn_39 sn_53 513790.514038332
Csub_39_53 sn_39 sn_53 2.050735312221804e-17
Rsub_39_76 sn_39 sn_76 2746769.926886379
Csub_39_76 sn_39 sn_76 3.835954150762714e-18
Rsub_39_68 sn_39 sn_68 61215237.6905716
Csub_39_68 sn_39 sn_68 1.721219078734842e-19
Rsub_39_211 sn_39 sn_211 39075989.96717799
Csub_39_211 sn_39 sn_211 2.696408590308308e-19
Rsub_39_44 sn_39 sn_44 13253379.87868085
Csub_39_44 sn_39 sn_44 7.950035084392926e-19
Rsub_39_202 sn_39 sn_202 1194699.08549356
Csub_39_202 sn_39 sn_202 8.819361821037232e-18
Rsub_39_65 sn_39 sn_65 31097120.91343686
Csub_39_65 sn_39 sn_65 3.38825048516863e-19
Rsub_39_222 sn_39 sn_222 596448.109123575
Csub_39_222 sn_39 sn_222 1.766538168376858e-17
Rsub_39_77 sn_39 sn_77 4822325.931330354
Csub_39_77 sn_39 sn_77 2.18493806770196e-18
Rsub_39_188 sn_39 sn_188 8231130.926815814
Csub_39_188 sn_39 sn_188 1.280077257415951e-18
Rsub_39_179 sn_39 sn_179 7004786.887833675
Csub_39_179 sn_39 sn_179 1.504183306494361e-18
Rsub_39_69 sn_39 sn_69 16284296.55475024
Csub_39_69 sn_39 sn_69 6.470333837758829e-19
Rsub_39_60 sn_39 sn_60 6522518.105025015
Csub_39_60 sn_39 sn_60 1.615401189015111e-18
Rsub_39_227 sn_39 sn_227 1742105.459029087
Csub_39_227 sn_39 sn_227 6.048131843925346e-18
Rsub_39_139 sn_39 sn_139 6074681.032430175
Csub_39_139 sn_39 sn_139 1.734491645895502e-18
Rsub_39_224 sn_39 sn_224 26179269.92550041
Csub_39_224 sn_39 sn_224 4.024743062818089e-19
Rsub_39_54 sn_39 sn_54 78416494.67626028
Csub_39_54 sn_39 sn_54 1.343656528607852e-19
Rsub_39_104 sn_39 sn_104 241272255.1435246
Csub_39_104 sn_39 sn_104 4.367051444005532e-20
Rsub_170_217 sn_170 sn_217 2176686.515652407
Csub_170_217 sn_170 sn_217 4.840606778451032e-18
Rsub_170_223 sn_170 sn_223 4780781.116026884
Csub_170_223 sn_170 sn_223 2.203925100630094e-18
Rsub_170_227 sn_170 sn_227 105844.7420252443
Csub_170_227 sn_170 sn_227 9.95465934407683e-17
Rsub_170_210 sn_170 sn_210 57367986.47157328
Csub_170_210 sn_170 sn_210 1.836648652023196e-19
Rsub_170_190 sn_170 sn_190 4274878.352426155
Csub_170_190 sn_170 sn_190 2.464744639166199e-18
Rsub_170_194 sn_170 sn_194 4763615.015185233
Csub_170_194 sn_170 sn_194 2.211867136332865e-18
Rsub_170_192 sn_170 sn_192 643200.0741132436
Csub_170_192 sn_170 sn_192 1.638134684103739e-17
Rsub_170_171 sn_170 sn_171 16698630.63944065
Csub_170_171 sn_170 sn_171 6.309788946013203e-19
Rsub_170_185 sn_170 sn_185 44303.33892873989
Csub_170_185 sn_170 sn_185 2.378259462379913e-16
Rsub_170_222 sn_170 sn_222 56058.43263074749
Csub_170_222 sn_170 sn_222 1.879553709899988e-16
Rsub_170_226 sn_170 sn_226 473579.9719166658
Csub_170_226 sn_170 sn_226 2.224858340099752e-17
Rsub_170_177 sn_170 sn_177 428885.9895250676
Csub_170_177 sn_170 sn_177 2.456709652347867e-17
Rsub_170_214 sn_170 sn_214 43579.2254546954
Csub_170_214 sn_170 sn_214 2.417776679666701e-16
Rsub_170_207 sn_170 sn_207 9162374.268327055
Csub_170_207 sn_170 sn_207 1.149973052143595e-18
Rsub_170_206 sn_170 sn_206 16523.20345426719
Csub_170_206 sn_170 sn_206 6.376780102837085e-16
Rsub_170_186 sn_170 sn_186 11919203.46513886
Csub_170_186 sn_170 sn_186 8.839922510801141e-19
Rsub_170_181 sn_170 sn_181 1046063.32104585
Csub_170_181 sn_170 sn_181 1.007251022977812e-17
Rsub_170_218 sn_170 sn_218 561548.3345964674
Csub_170_218 sn_170 sn_218 1.876327085860132e-17
Rsub_170_215 sn_170 sn_215 2583.440601652579
Csub_170_215 sn_170 sn_215 4.078469423872184e-15
Rsub_170_178 sn_170 sn_178 53699.92122522193
Csub_170_178 sn_170 sn_178 1.962104089136205e-16
Rsub_170_198 sn_170 sn_198 3348.564221993678
Csub_170_198 sn_170 sn_198 3.14656754468838e-15
Rsub_170_184 sn_170 sn_184 1870441.32629935
Csub_170_184 sn_170 sn_184 5.633153713020408e-18
Rsub_170_221 sn_170 sn_221 465491.7623390328
Csub_170_221 sn_170 sn_221 2.26351664082853e-17
Rsub_170_230 sn_170 0 19033.50793020154
Csub_170_230 sn_170 0 5.535754912267733e-16
Rsub_170_213 sn_170 sn_213 61523.7914654038
Csub_170_213 sn_170 sn_213 1.71258683043858e-16
Rsub_170_196 sn_170 sn_196 757014.1410934936
Csub_170_196 sn_170 sn_196 1.391847645938323e-17
Rsub_170_212 sn_170 sn_212 186513.7105682379
Csub_170_212 sn_170 sn_212 5.649173709605183e-17
Rsub_170_199 sn_170 sn_199 165593.8182969645
Csub_170_199 sn_170 sn_199 6.362848330083553e-17
Rsub_170_219 sn_170 sn_219 727519.9461328603
Csub_170_219 sn_170 sn_219 1.448274175606702e-17
Rsub_170_182 sn_170 sn_182 48832.43683515292
Csub_170_182 sn_170 sn_182 2.157681284224817e-16
Rsub_170_202 sn_170 sn_202 780197.6244316866
Csub_170_202 sn_170 sn_202 1.350489052040502e-17
Rsub_170_188 sn_170 sn_188 754893.8191127186
Csub_170_188 sn_170 sn_188 1.39575702376452e-17
Rsub_170_174 sn_170 sn_174 2767159.427827845
Csub_170_174 sn_170 sn_174 3.807689356916054e-18
Rsub_170_211 sn_170 sn_211 314396.3638439596
Csub_170_211 sn_170 sn_211 3.351337583363222e-17
Rsub_170_229 sn_170 sn_229 12518755.30164167
Csub_170_229 sn_170 sn_229 8.416558394466167e-19
Rsub_170_201 sn_170 sn_201 462542.9178005929
Csub_170_201 sn_170 sn_201 2.277947212408166e-17
Rsub_170_172 sn_170 sn_172 2154096.888388196
Csub_170_172 sn_170 sn_172 4.891369352524311e-18
Rsub_170_204 sn_170 sn_204 423537.2320470798
Csub_170_204 sn_170 sn_204 2.487734891996173e-17
Rsub_170_200 sn_170 sn_200 1227824.468602501
Csub_170_200 sn_170 sn_200 8.581424928127175e-18
Rsub_170_203 sn_170 sn_203 2252535.886048071
Csub_170_203 sn_170 sn_203 4.677609607683358e-18
Rsub_170_197 sn_170 sn_197 5535230.858274193
Csub_170_197 sn_170 sn_197 1.903530994823787e-18
Rsub_170_195 sn_170 sn_195 763879.7102336955
Csub_170_195 sn_170 sn_195 1.379338050359598e-17
Rsub_170_216 sn_170 sn_216 585101.810260837
Csub_170_216 sn_170 sn_216 1.800794890300009e-17
Rsub_170_228 sn_170 sn_228 5869294.32475834
Csub_170_228 sn_170 sn_228 1.795187448307736e-18
Rsub_3_87 sn_3 sn_87 347795502.4064108
Csub_3_87 sn_3 sn_87 3.029505393062203e-20
Rsub_3_128 sn_3 sn_128 224391685.8521021
Csub_3_128 sn_3 sn_128 4.695576604016721e-20
Rsub_3_186 sn_3 sn_186 268589566.8287998
Csub_3_186 sn_3 sn_186 3.922893814019962e-20
Rsub_3_151 sn_3 sn_151 251103177.5309499
Csub_3_151 sn_3 sn_151 4.196077327986548e-20
Rsub_3_165 sn_3 sn_165 319834502.085197
Csub_3_165 sn_3 sn_165 3.294354872140502e-20
Rsub_3_24 sn_3 sn_24 127719612.8640005
Csub_3_24 sn_3 sn_24 8.249698903683296e-20
Rsub_3_209 sn_3 sn_209 347795502.4064108
Csub_3_209 sn_3 sn_209 3.029505393062203e-20
Rsub_3_49 sn_3 sn_49 347795502.4064108
Csub_3_49 sn_3 sn_49 3.029505393062203e-20
Rsub_3_216 sn_3 sn_216 125997580.4522243
Csub_3_216 sn_3 sn_216 8.362449075936994e-20
Rsub_3_80 sn_3 sn_80 347795502.4064108
Csub_3_80 sn_3 sn_80 3.029505393062203e-20
Rsub_3_230 sn_3 0 3060838.937459108
Csub_3_230 sn_3 0 3.442351498238795e-18
Rsub_3_169 sn_3 sn_169 347795502.4064108
Csub_3_169 sn_3 sn_169 3.029505393062203e-20
Rsub_3_112 sn_3 sn_112 347795502.4064108
Csub_3_112 sn_3 sn_112 3.029505393062203e-20
Rsub_3_132 sn_3 sn_132 247442448.5461619
Csub_3_132 sn_3 sn_132 4.258155205033204e-20
Rsub_3_139 sn_3 sn_139 36295381.36531739
Csub_3_139 sn_3 sn_139 2.902981896285652e-19
Rsub_3_134 sn_3 sn_134 204945992.7938401
Csub_3_134 sn_3 sn_134 5.141102472215153e-20
Rsub_3_50 sn_3 sn_50 74866132.95455912
Csub_3_50 sn_3 sn_50 1.407376484721769e-19
Rsub_3_177 sn_3 sn_177 68763278.30353402
Csub_3_177 sn_3 sn_177 1.532283474868663e-19
Rsub_3_89 sn_3 sn_89 181146681.5753827
Csub_3_89 sn_3 sn_89 5.816547899523808e-20
Rsub_3_43 sn_3 sn_43 99592481.50533099
Csub_3_43 sn_3 sn_43 1.05795973179622e-19
Rsub_3_210 sn_3 sn_210 173897751.2032054
Csub_3_210 sn_3 sn_210 6.059010786124407e-20
Rsub_3_131 sn_3 sn_131 23299138.34130602
Csub_3_131 sn_3 sn_131 4.522263161788406e-19
Rsub_3_182 sn_3 sn_182 106554078.6515728
Csub_3_182 sn_3 sn_182 9.888390604627955e-20
Rsub_3_52 sn_3 sn_52 7823415.236447197
Csub_3_52 sn_3 sn_52 1.346788222762783e-18
Rsub_3_219 sn_3 sn_219 42415587.95241628
Csub_3_219 sn_3 sn_219 2.484106436070226e-19
Rsub_3_61 sn_3 sn_61 27705757.54488427
Csub_3_61 sn_3 sn_61 3.802994191788671e-19
Rsub_3_18 sn_3 sn_18 25213516.24854055
Csub_3_18 sn_3 sn_18 4.178902854471911e-19
Rsub_3_97 sn_3 sn_97 344281829.6815659
Csub_3_97 sn_3 sn_97 3.060423930003926e-20
Rsub_3_99 sn_3 sn_99 45107.98630772161
Csub_3_99 sn_3 sn_99 2.335835483843436e-16
Rsub_3_20 sn_3 sn_20 517363585.3852962
Csub_3_20 sn_3 sn_20 2.03657230618254e-20
Rsub_3_48 sn_3 sn_48 8130768.745366319
Csub_3_48 sn_3 sn_48 1.295877896937443e-18
Rsub_3_215 sn_3 sn_215 121165561.974224
Csub_3_215 sn_3 sn_215 8.695939118799666e-20
Rsub_3_136 sn_3 sn_136 82076629.32660463
Csub_3_136 sn_3 sn_136 1.283737354795912e-19
Rsub_3_67 sn_3 sn_67 8342577.927903098
Csub_3_67 sn_3 sn_67 1.262976935101683e-18
Rsub_3_178 sn_3 sn_178 29444610.1346986
Csub_3_178 sn_3 sn_178 3.578408222771278e-19
Rsub_3_11 sn_3 sn_11 325647064.1296784
Csub_3_11 sn_3 sn_11 3.23555304586876e-20
Rsub_3_213 sn_3 sn_213 347795502.4064108
Csub_3_213 sn_3 sn_213 3.029505393062203e-20
Rsub_3_46 sn_3 sn_46 195428.76262435
Csub_3_46 sn_3 sn_46 5.391470201591081e-17
Rsub_3_204 sn_3 sn_204 1688881.776007169
Csub_3_204 sn_3 sn_204 6.238733611739367e-18
Rsub_3_12 sn_3 sn_12 25933947.70541414
Csub_3_12 sn_3 sn_12 4.062815126302709e-19
Rsub_3_138 sn_3 sn_138 49437446.49603395
Csub_3_138 sn_3 sn_138 2.131275834215118e-19
Rsub_3_101 sn_3 sn_101 326110.4582359348
Csub_3_101 sn_3 sn_101 3.230955412845746e-17
Rsub_3_181 sn_3 sn_181 96667594.15512086
Csub_3_181 sn_3 sn_181 1.08997059400509e-19
Rsub_3_14 sn_3 sn_14 4681176630.847656
Rsub_3_7 sn_3 sn_7 16157274.26459583
Csub_3_7 sn_3 sn_7 6.521201119496851e-19
Rsub_3_78 sn_3 sn_78 95570713.64989334
Csub_3_78 sn_3 sn_78 1.102480362428659e-19
Rsub_3_40 sn_3 sn_40 1069471523.872481
Rsub_3_105 sn_3 sn_105 11840239.76639787
Csub_3_105 sn_3 sn_105 8.898876804954676e-19
Rsub_3_76 sn_3 sn_76 6805313.781533349
Csub_3_76 sn_3 sn_76 1.548272987914447e-18
Rsub_3_206 sn_3 sn_206 53479513.01402391
Csub_3_206 sn_3 sn_206 1.970190622242021e-19
Rsub_3_39 sn_3 sn_39 34378880.30329932
Csub_3_39 sn_3 sn_39 3.06481287618283e-19
Rsub_3_118 sn_3 sn_118 137816614.2342066
Csub_3_118 sn_3 sn_118 7.645292667199196e-20
Rsub_3_192 sn_3 sn_192 347234714.7013707
Csub_3_192 sn_3 sn_192 3.034398076036724e-20
Rsub_3_201 sn_3 sn_201 19175620.12071728
Csub_3_201 sn_3 sn_201 5.494728950562812e-19
Rsub_3_34 sn_3 sn_34 347795502.4064108
Csub_3_34 sn_3 sn_34 3.029505393062203e-20
Rsub_3_153 sn_3 sn_153 58036042.89480274
Csub_3_153 sn_3 sn_153 1.815506877567211e-19
Rsub_3_189 sn_3 sn_189 39328350.82407963
Csub_3_189 sn_3 sn_189 2.679106365115827e-19
Rsub_3_110 sn_3 sn_110 666240871.9203444
Csub_3_110 sn_3 sn_110 1.581482605811933e-20
Rsub_3_198 sn_3 sn_198 164067613.9460578
Csub_3_198 sn_3 sn_198 6.422037383742405e-20
Rsub_3_51 sn_3 sn_51 24449826.14630709
Csub_3_51 sn_3 sn_51 4.309430847965941e-19
Rsub_3_130 sn_3 sn_130 61370034.52733198
Csub_3_130 sn_3 sn_130 1.716877558140763e-19
Rsub_3_183 sn_3 sn_183 347795502.4064108
Csub_3_183 sn_3 sn_183 3.029505393062203e-20
Rsub_3_41 sn_3 sn_41 23568041.03261229
Csub_3_41 sn_3 sn_41 4.470665800203817e-19
Rsub_3_188 sn_3 sn_188 49527667.48029949
Csub_3_188 sn_3 sn_188 2.127393442548264e-19
Rsub_3_195 sn_3 sn_195 50837891.3893412
Csub_3_195 sn_3 sn_195 2.072565012883109e-19
Rsub_3_166 sn_3 sn_166 105032699.4913278
Csub_3_166 sn_3 sn_166 1.003162210745613e-19
Rsub_3_222 sn_3 sn_222 43714079.18777656
Csub_3_222 sn_3 sn_222 2.410318070974314e-19
Rsub_3_66 sn_3 sn_66 108027479.2635854
Csub_3_66 sn_3 sn_66 9.753521579931656e-20
Rsub_3_145 sn_3 sn_145 695591004.8128216
Csub_3_145 sn_3 sn_145 1.514752696531102e-20
Rsub_3_71 sn_3 sn_71 157404107.9199566
Csub_3_71 sn_3 sn_71 6.693906303632195e-20
Rsub_3_229 sn_3 sn_229 695591004.8128216
Csub_3_229 sn_3 sn_229 1.514752696531102e-20
Rsub_3_117 sn_3 sn_117 347795502.4064108
Csub_3_117 sn_3 sn_117 3.029505393062203e-20
Rsub_3_53 sn_3 sn_53 173897751.2032054
Csub_3_53 sn_3 sn_53 6.059010786124407e-20
Rsub_3_114 sn_3 sn_114 108795508.2850999
Csub_3_114 sn_3 sn_114 9.684667748064581e-20
Rsub_3_148 sn_3 sn_148 347795502.4064108
Csub_3_148 sn_3 sn_148 3.029505393062203e-20
Rsub_3_60 sn_3 sn_60 154095475.500752
Csub_3_60 sn_3 sn_60 6.837633271184903e-20
Rsub_3_227 sn_3 sn_227 18502150.96090874
Csub_3_227 sn_3 sn_227 5.694734371420619e-19
Rsub_3_133 sn_3 sn_133 212990393.4324164
Csub_3_133 sn_3 sn_133 4.946928982303286e-20
Rsub_3_214 sn_3 sn_214 166147654.4635825
Csub_3_214 sn_3 sn_214 6.341638427727228e-20
Rsub_3_47 sn_3 sn_47 173897751.2032054
Csub_3_47 sn_3 sn_47 6.059010786124407e-20
Rsub_3_199 sn_3 sn_199 116082616.368892
Csub_3_199 sn_3 sn_199 9.076710907985347e-20
Rsub_3_94 sn_3 sn_94 575072638.5771511
Csub_3_94 sn_3 sn_94 1.832200455284996e-20
Rsub_148_168 sn_148 sn_168 12656482.6149007
Csub_148_168 sn_148 sn_168 8.324969758837431e-19
Rsub_148_224 sn_148 sn_224 556308.7403155508
Csub_148_224 sn_148 sn_224 1.893999273902019e-17
Rsub_148_190 sn_148 sn_190 3541049.045982951
Csub_148_190 sn_148 sn_190 2.975525999613825e-18
Rsub_148_181 sn_148 sn_181 4368482.18330118
Csub_148_181 sn_148 sn_181 2.411932350898998e-18
Rsub_148_225 sn_148 sn_225 11109865.5947499
Csub_148_225 sn_148 sn_225 9.483898263547977e-19
Rsub_148_217 sn_148 sn_217 4475800.490220869
Csub_148_217 sn_148 sn_217 2.354100350373315e-18
Rsub_148_153 sn_148 sn_153 1424821.497511725
Csub_148_153 sn_148 sn_153 7.394949838018778e-18
Rsub_148_158 sn_148 sn_158 1882893.538166517
Csub_148_158 sn_148 sn_158 5.595899762070451e-18
Rsub_148_180 sn_148 sn_180 9360289.518917711
Csub_148_180 sn_148 sn_180 1.125657863566627e-18
Rsub_148_159 sn_148 sn_159 41186.84731159778
Csub_148_159 sn_148 sn_159 2.558215593079162e-16
Rsub_148_204 sn_148 sn_204 3683730.633368486
Csub_148_204 sn_148 sn_204 2.860275234781541e-18
Rsub_148_195 sn_148 sn_195 900893.0003338878
Csub_148_195 sn_148 sn_195 1.169559925354619e-17
Rsub_148_208 sn_148 sn_208 2256892.432547122
Csub_148_208 sn_148 sn_208 4.668580278918548e-18
Rsub_148_162 sn_148 sn_162 3846210.013713206
Csub_148_162 sn_148 sn_162 2.739445704905197e-18
Rsub_148_177 sn_148 sn_177 155883.3008832011
Csub_148_177 sn_148 sn_177 6.759212463767809e-17
Rsub_148_219 sn_148 sn_219 1599730.118771187
Csub_148_219 sn_148 sn_219 6.58641315719146e-18
Rsub_148_202 sn_148 sn_202 5097123.936353914
Csub_148_202 sn_148 sn_202 2.067142889558024e-18
Rsub_148_191 sn_148 sn_191 4344531.936590519
Csub_148_191 sn_148 sn_191 2.425228691148436e-18
Rsub_148_207 sn_148 sn_207 2790152.010851264
Csub_148_207 sn_148 sn_207 3.77631163508377e-18
Rsub_148_216 sn_148 sn_216 6843974.746639519
Csub_148_216 sn_148 sn_216 1.539526940452776e-18
Rsub_148_170 sn_148 sn_170 113598.178711785
Csub_148_170 sn_148 sn_170 9.275222210175201e-17
Rsub_148_186 sn_148 sn_186 8424490.884949751
Csub_148_186 sn_148 sn_186 1.250696765670825e-18
Rsub_148_166 sn_148 sn_166 404497.9741696327
Csub_148_166 sn_148 sn_166 2.604829733414526e-17
Rsub_148_203 sn_148 sn_203 603420.3938508668
Csub_148_203 sn_148 sn_203 1.746126516372606e-17
Rsub_148_192 sn_148 sn_192 108301.2062208266
Csub_148_192 sn_148 sn_192 9.728869945128836e-17
Rsub_148_175 sn_148 sn_175 3982451.643407783
Csub_148_175 sn_148 sn_175 2.645727919803173e-18
Rsub_148_212 sn_148 sn_212 244552.1408516898
Csub_148_212 sn_148 sn_212 4.308481400136227e-17
Rsub_148_205 sn_148 sn_205 10826319.14105559
Csub_148_205 sn_148 sn_205 9.732286075212328e-19
Rsub_148_222 sn_148 sn_222 12233.17491396266
Csub_148_222 sn_148 sn_222 8.613040830638254e-16
Rsub_148_198 sn_148 sn_198 52387.72748961078
Csub_148_198 sn_148 sn_198 2.011250345669133e-16
Rsub_148_215 sn_148 sn_215 154921.3180665267
Csub_148_215 sn_148 sn_215 6.801183745225687e-17
Rsub_148_178 sn_148 sn_178 1122622.876587864
Csub_148_178 sn_148 sn_178 9.385594861789138e-18
Rsub_148_227 sn_148 sn_227 130093.138412847
Csub_148_227 sn_148 sn_227 8.099184653992096e-17
Rsub_148_213 sn_148 sn_213 7866.220289411733
Csub_148_213 sn_148 sn_213 1.339459500824374e-15
Rsub_148_230 sn_148 0 39616.11924282615
Csub_148_230 sn_148 0 2.659645544190448e-16
Rsub_148_182 sn_148 sn_182 47138.77742336671
Csub_148_182 sn_148 sn_182 2.235205085528387e-16
Rsub_148_184 sn_148 sn_184 5236652.99502185
Csub_148_184 sn_148 sn_184 2.012064483219789e-18
Rsub_148_221 sn_148 sn_221 970598.1237475009
Csub_148_221 sn_148 sn_221 1.085566028249509e-17
Rsub_148_174 sn_148 sn_174 220712.2984006178
Csub_148_174 sn_148 sn_174 4.773854279341105e-17
Rsub_148_211 sn_148 sn_211 625731.4350768803
Csub_148_211 sn_148 sn_211 1.683866737642074e-17
Rsub_148_214 sn_148 sn_214 145331.9312228628
Csub_148_214 sn_148 sn_214 7.249943913614259e-17
Rsub_148_160 sn_148 sn_160 839356.0974863307
Csub_148_160 sn_148 sn_160 1.255305529296115e-17
Rsub_148_206 sn_148 sn_206 546882.1576247653
Csub_148_206 sn_148 sn_206 1.926646052596114e-17
Rsub_148_226 sn_148 sn_226 892511.3491691098
Csub_148_226 sn_148 sn_226 1.180543363626582e-17
Rsub_148_199 sn_148 sn_199 3551748.194284786
Csub_148_199 sn_148 sn_199 2.966562640669331e-18
Rsub_148_200 sn_148 sn_200 238557.462346121
Csub_148_200 sn_148 sn_200 4.416748651921315e-17
Rsub_148_229 sn_148 sn_229 7260906.239352264
Csub_148_229 sn_148 sn_229 1.451125128861318e-18
Rsub_148_150 sn_148 sn_150 6963753.01942361
Csub_148_150 sn_148 sn_150 1.513046696636307e-18
Rsub_148_164 sn_148 sn_164 6504281.907758793
Csub_148_164 sn_148 sn_164 1.61993032461605e-18
Rsub_148_201 sn_148 sn_201 5020786.462429367
Csub_148_201 sn_148 sn_201 2.098572321502755e-18
Rsub_148_188 sn_148 sn_188 5115442.471702802
Csub_148_188 sn_148 sn_188 2.059740395970609e-18
Rsub_148_196 sn_148 sn_196 851013.647335385
Csub_148_196 sn_148 sn_196 1.238109815890833e-17
Rsub_153_171 sn_153 sn_171 32623952.76880591
Csub_153_171 sn_153 sn_171 3.229677156811202e-19
Rsub_153_166 sn_153 sn_166 563930.0920287409
Csub_153_166 sn_153 sn_166 1.868402422776369e-17
Rsub_153_174 sn_153 sn_174 17684232.16188688
Csub_153_174 sn_153 sn_174 5.958123262449737e-19
Rsub_153_220 sn_153 sn_220 5241433.864361602
Csub_153_220 sn_153 sn_220 2.010229218739427e-18
Rsub_153_164 sn_153 sn_164 27247581.33843943
Csub_153_164 sn_153 sn_164 3.866942673317463e-19
Rsub_153_161 sn_153 sn_161 41155700.75701482
Csub_153_161 sn_153 sn_161 2.560151645682791e-19
Rsub_153_229 sn_153 sn_229 41155700.75701482
Csub_153_229 sn_153 sn_229 2.560151645682791e-19
Rsub_153_197 sn_153 sn_197 6434668.637142223
Csub_153_197 sn_153 sn_197 1.637455492488186e-18
Rsub_153_227 sn_153 sn_227 363247.8077152072
Csub_153_227 sn_153 sn_227 2.90063237229247e-17
Rsub_153_203 sn_153 sn_203 1147134.295582928
Csub_153_203 sn_153 sn_203 9.185047943210328e-18
Rsub_153_179 sn_153 sn_179 1102468.113194172
Csub_153_179 sn_153 sn_179 9.557177551106434e-18
Rsub_153_214 sn_153 sn_214 1586312.452175499
Csub_153_214 sn_153 sn_214 6.642123679846341e-18
Rsub_153_160 sn_153 sn_160 1052377.193132994
Csub_153_160 sn_153 sn_160 1.00120789114236e-17
Rsub_153_183 sn_153 sn_183 2212966.348767969
Csub_153_183 sn_153 sn_183 4.761248858617307e-18
Rsub_153_211 sn_153 sn_211 3222912.522632819
Csub_153_211 sn_153 sn_211 3.269242782184692e-18
Rsub_153_216 sn_153 sn_216 1920732.631774738
Csub_153_216 sn_153 sn_216 5.485658611680061e-18
Rsub_153_201 sn_153 sn_201 3883681.535879786
Csub_153_201 sn_153 sn_201 2.713014289376621e-18
Rsub_153_168 sn_153 sn_168 691023.6473337413
Csub_153_168 sn_153 sn_168 1.524764534887362e-17
Rsub_153_224 sn_153 sn_224 1532035.236717242
Csub_153_224 sn_153 sn_224 6.877442012891934e-18
Rsub_153_226 sn_153 sn_226 1470821.945118963
Csub_153_226 sn_153 sn_226 7.163670311825397e-18
Rsub_153_189 sn_153 sn_189 5630531.06913541
Csub_153_189 sn_153 sn_189 1.871312558772173e-18
Rsub_153_206 sn_153 sn_206 664821.8842741335
Csub_153_206 sn_153 sn_206 1.584858102818615e-17
Rsub_153_169 sn_153 sn_169 202206.0516635522
Csub_153_169 sn_153 sn_169 5.210765659853498e-17
Rsub_153_228 sn_153 sn_228 322862.5746330749
Csub_153_228 sn_153 sn_228 3.263457684497637e-17
Rsub_153_154 sn_153 sn_154 7549616.390535697
Csub_153_154 sn_153 sn_154 1.395631639700089e-18
Rsub_153_222 sn_153 sn_222 124665.4206686616
Csub_153_222 sn_153 sn_222 8.451809207169078e-17
Rsub_153_190 sn_153 sn_190 264940.9715865175
Csub_153_190 sn_153 sn_190 3.97691736356801e-17
Rsub_153_215 sn_153 sn_215 241213.8030151486
Csub_153_215 sn_153 sn_215 4.368109689630113e-17
Rsub_153_178 sn_153 sn_178 524919.0186624932
Csub_153_178 sn_153 sn_178 2.007258858533498e-17
Rsub_153_180 sn_153 sn_180 5567942.893453493
Csub_153_180 sn_153 sn_180 1.892347623503515e-18
Rsub_153_176 sn_153 sn_176 303414.8977550226
Csub_153_176 sn_153 sn_176 3.472632220826931e-17
Rsub_153_213 sn_153 sn_213 860676.2456605888
Csub_153_213 sn_153 sn_213 1.22420986466787e-17
Rsub_153_230 sn_153 0 15288.611510489
Csub_153_230 sn_153 0 6.891720346874715e-16
Rsub_153_156 sn_153 sn_156 6044437.512481487
Csub_153_156 sn_153 sn_156 1.743170225595458e-18
Rsub_153_177 sn_153 sn_177 36910.60695274427
Csub_153_177 sn_153 sn_177 2.854595026226362e-16
Rsub_153_219 sn_153 sn_219 2552.155966180877
Csub_153_219 sn_153 sn_219 4.128463793690913e-15
Rsub_153_158 sn_153 sn_158 733192.5086442366
Csub_153_158 sn_153 sn_158 1.43706917051202e-17
Rsub_153_195 sn_153 sn_195 1975.267506212395
Csub_153_195 sn_153 sn_195 5.334205857734109e-15
Rsub_153_188 sn_153 sn_188 1600539.258022988
Csub_153_188 sn_153 sn_188 6.583083451039395e-18
Rsub_153_181 sn_153 sn_181 14251.38396981264
Csub_153_181 sn_153 sn_181 7.39330546741877e-16
Rsub_153_218 sn_153 sn_218 924873.4199263939
Csub_153_218 sn_153 sn_218 1.139235194267833e-17
Rsub_153_204 sn_153 sn_204 400699.7916982615
Csub_153_204 sn_153 sn_204 2.629520583870001e-17
Rsub_153_172 sn_153 sn_172 3787531.264210002
Csub_153_172 sn_153 sn_172 2.781886872273169e-18
Rsub_153_196 sn_153 sn_196 1719331.382102818
Csub_153_196 sn_153 sn_196 6.1282447420598e-18
Rsub_153_170 sn_153 sn_170 639315.7754543922
Csub_153_170 sn_153 sn_170 1.64808751899501e-17
Rsub_153_155 sn_153 sn_155 802846.8353603088
Csub_153_155 sn_153 sn_155 1.312390239104741e-17
Rsub_153_192 sn_153 sn_192 5023412.930394961
Csub_153_192 sn_153 sn_192 2.097475092775537e-18
Rsub_153_210 sn_153 sn_210 776013.288180947
Csub_153_210 sn_153 sn_210 1.357771015355752e-17
Rsub_153_208 sn_153 sn_208 3667515.695011347
Csub_153_208 sn_153 sn_208 2.872921175650866e-18
Rsub_153_175 sn_153 sn_175 251154.6387371621
Csub_153_175 sn_153 sn_175 4.195217558078481e-17
Rsub_153_221 sn_153 sn_221 2494987.923075092
Csub_153_221 sn_153 sn_221 4.223059921365752e-18
Rsub_153_157 sn_153 sn_157 3049583.269144306
Csub_153_157 sn_153 sn_157 3.455056829842351e-18
Rsub_73_130 sn_73 sn_130 1279727.738646775
Csub_73_130 sn_73 sn_130 8.233379010266366e-18
Rsub_73_216 sn_73 sn_216 2039584.321532779
Csub_73_216 sn_73 sn_216 5.165995536929639e-18
Rsub_73_106 sn_73 sn_106 1415022.7594874
Csub_73_106 sn_73 sn_106 7.44615832613668e-18
Rsub_73_143 sn_73 sn_143 921857.7837264996
Csub_73_143 sn_73 sn_143 1.142961928426479e-17
Rsub_73_76 sn_73 sn_76 28336233.20977074
Csub_73_76 sn_73 sn_76 3.718378312399289e-19
Rsub_73_87 sn_73 sn_87 1064840.651342198
Csub_73_87 sn_73 sn_87 9.894892244157942e-18
Rsub_73_117 sn_73 sn_117 4568346.506438574
Csub_73_117 sn_73 sn_117 2.306410752201044e-18
Rsub_73_194 sn_73 sn_194 1547384.387169062
Csub_73_194 sn_73 sn_194 6.809221800089689e-18
Rsub_73_83 sn_73 sn_83 143414.7266065625
Csub_73_83 sn_73 sn_83 7.34686301158968e-17
Rsub_73_165 sn_73 sn_165 600873.869501405
Csub_73_165 sn_73 sn_165 1.753526661256379e-17
Rsub_73_202 sn_73 sn_202 3219.174737205016
Csub_73_202 sn_73 sn_202 3.273038701645035e-15
Rsub_73_225 sn_73 sn_225 10469.99169036066
Csub_73_225 sn_73 sn_225 1.006350703404144e-15
Rsub_73_209 sn_73 sn_209 414672.4883683787
Csub_73_209 sn_73 sn_209 2.540916939941722e-17
Rsub_73_107 sn_73 sn_107 15546015.01318251
Csub_73_107 sn_73 sn_107 6.77761052803269e-19
Rsub_73_223 sn_73 sn_223 69113.43970018887
Csub_73_223 sn_73 sn_223 1.524520201560914e-16
Rsub_73_85 sn_73 sn_85 4379.998777903147
Csub_73_85 sn_73 sn_85 2.405590511893744e-15
Rsub_73_122 sn_73 sn_122 4159581.191863901
Csub_73_122 sn_73 sn_122 2.533063550445717e-18
Rsub_73_215 sn_73 sn_215 4315305.16356735
Csub_73_215 sn_73 sn_215 2.441654321735097e-18
Rsub_73_152 sn_73 sn_152 1539147.562951206
Csub_73_152 sn_73 sn_152 6.84566168693211e-18
Rsub_73_189 sn_73 sn_189 1315722.916716354
Csub_73_189 sn_73 sn_189 8.008132539430015e-18
Rsub_73_226 sn_73 sn_226 9858016.90037071
Csub_73_226 sn_73 sn_226 1.068823842433642e-18
Rsub_73_115 sn_73 sn_115 168486.1227986252
Csub_73_115 sn_73 sn_115 6.253620967243229e-17
Rsub_73_200 sn_73 sn_200 13219378.28859977
Csub_73_200 sn_73 sn_200 7.970483385982329e-19
Rsub_73_230 sn_73 0 252376.1689919866
Csub_73_230 sn_73 0 4.174912213111751e-17
Rsub_120_195 sn_120 sn_195 12431647.17435901
Csub_120_195 sn_120 sn_195 8.475532931759928e-19
Rsub_120_154 sn_120 sn_154 12337785.72452278
Csub_120_154 sn_120 sn_154 8.54001174723558e-19
Rsub_120_198 sn_120 sn_198 5943097.749804133
Csub_120_198 sn_120 sn_198 1.772894195216165e-18
Rsub_120_126 sn_120 sn_126 8108531.872074842
Csub_120_126 sn_120 sn_126 1.299431718153176e-18
Rsub_120_213 sn_120 sn_213 7430769.940926475
Csub_120_213 sn_120 sn_213 1.417953130832133e-18
Rsub_120_196 sn_120 sn_196 54017356.72980167
Csub_120_196 sn_120 sn_196 1.950573693365667e-19
Rsub_120_146 sn_120 sn_146 6445384.301662466
Csub_120_146 sn_120 sn_146 1.634733168588926e-18
Rsub_120_225 sn_120 sn_225 54017356.72980167
Csub_120_225 sn_120 sn_225 1.950573693365667e-19
Rsub_120_229 sn_120 sn_229 9215804.897881275
Csub_120_229 sn_120 sn_229 1.143305833726184e-18
Rsub_120_202 sn_120 sn_202 102320101.3388474
Csub_120_202 sn_120 sn_202 1.029756945542593e-19
Rsub_120_212 sn_120 sn_212 1184773.160168476
Csub_120_212 sn_120 sn_212 8.89324965863651e-18
Rsub_120_133 sn_120 sn_133 34194581.97458316
Csub_120_133 sn_120 sn_133 3.081331279341789e-19
Rsub_120_164 sn_120 sn_164 525799039.4504463
Csub_120_164 sn_120 sn_164 2.003899343985585e-20
Rsub_120_221 sn_120 sn_221 10321516.24841058
Csub_120_221 sn_120 sn_221 1.02082710026761e-18
Rsub_120_203 sn_120 sn_203 2111997.713575033
Csub_120_203 sn_120 sn_203 4.988870695505929e-18
Rsub_120_182 sn_120 sn_182 78550679.27520858
Csub_120_182 sn_120 sn_182 1.341361220482205e-19
Rsub_120_174 sn_120 sn_174 73536806.1299825
Csub_120_174 sn_120 sn_174 1.432817667333264e-19
Rsub_120_211 sn_120 sn_211 4076603.328484547
Csub_120_211 sn_120 sn_211 2.584623190735331e-18
Rsub_120_144 sn_120 sn_144 52236030.84622791
Csub_120_144 sn_120 sn_144 2.017091140260491e-19
Rsub_120_158 sn_120 sn_158 2527523.089906334
Csub_120_158 sn_120 sn_158 4.168699207658066e-18
Rsub_120_190 sn_120 sn_190 3142985.678562129
Csub_120_190 sn_120 sn_190 3.352380373253973e-18
Rsub_120_160 sn_120 sn_160 344842.8835106423
Csub_120_160 sn_120 sn_160 3.055444669457658e-17
Rsub_120_197 sn_120 sn_197 23468.39617307585
Csub_120_197 sn_120 sn_197 4.489647875604724e-16
Rsub_120_139 sn_120 sn_139 12274173.63157576
Csub_120_139 sn_120 sn_139 8.584271184761892e-19
Rsub_120_218 sn_120 sn_218 309304.4586667668
Csub_120_218 sn_120 sn_218 3.406508767331291e-17
Rsub_120_181 sn_120 sn_181 1652762.648567893
Csub_120_181 sn_120 sn_181 6.375073584437419e-18
Rsub_120_186 sn_120 sn_186 418709.806685778
Csub_120_186 sn_120 sn_186 2.516416700537692e-17
Rsub_120_166 sn_120 sn_166 356789.0172903372
Csub_120_166 sn_120 sn_166 2.953141209964973e-17
Rsub_120_208 sn_120 sn_208 22453.59882943863
Csub_120_208 sn_120 sn_208 4.692558899919307e-16
Rsub_120_171 sn_120 sn_171 5572352.674278519
Csub_120_171 sn_120 sn_171 1.890850080409567e-18
Rsub_120_141 sn_120 sn_141 144404.8667885231
Csub_120_141 sn_120 sn_141 7.296487809971381e-17
Rsub_120_215 sn_120 sn_215 30054350.85686241
Csub_120_215 sn_120 sn_215 3.505809708687876e-19
Rsub_120_157 sn_120 sn_157 6127083.892715584
Csub_120_157 sn_120 sn_157 1.719657130002202e-18
Rsub_120_230 sn_120 0 261021.4738262524
Csub_120_230 sn_120 0 4.036634744175707e-17
Rsub_120_156 sn_120 sn_156 17183355.91588275
Csub_120_156 sn_120 sn_156 6.131796113523448e-19
Rsub_120_162 sn_120 sn_162 3514633.916488061
Csub_120_162 sn_120 sn_162 2.997889325770351e-18
Rsub_120_224 sn_120 sn_224 59305.95082969403
Csub_120_224 sn_120 sn_224 1.77663174686923e-16
Rsub_120_185 sn_120 sn_185 12390511.30454211
Csub_120_185 sn_120 sn_185 8.503671271715429e-19
Rsub_120_227 sn_120 sn_227 2454078.734637158
Csub_120_227 sn_120 sn_227 4.293457807003836e-18
Rsub_120_148 sn_120 sn_148 3364205.843805211
Csub_120_148 sn_120 sn_148 3.131937815764661e-18
Rsub_120_222 sn_120 sn_222 1295375.103824208
Csub_120_222 sn_120 sn_222 8.133924660991383e-18
Rsub_120_226 sn_120 sn_226 398677.1198190015
Csub_120_226 sn_120 sn_226 2.642861347802839e-17
Rsub_120_206 sn_120 sn_206 2269999.917891437
Csub_120_206 sn_120 sn_206 4.641622856099992e-18
Rsub_120_127 sn_120 sn_127 6440599.151659118
Csub_120_127 sn_120 sn_127 1.635947720720326e-18
Rsub_120_138 sn_120 sn_138 3884052.198217676
Csub_120_138 sn_120 sn_138 2.712755381368204e-18
Rsub_120_207 sn_120 sn_207 56536.19988809963
Csub_120_207 sn_120 sn_207 1.863670271982295e-16
Rsub_120_128 sn_120 sn_128 35500966.07976544
Csub_120_128 sn_120 sn_128 2.967942753601712e-19
Rsub_120_192 sn_120 sn_192 13196540.80120699
Csub_120_192 sn_120 sn_192 7.984276835082652e-19
Rsub_120_155 sn_120 sn_155 1364295.158494507
Csub_120_155 sn_120 sn_155 7.723023450333839e-18
Rsub_120_177 sn_120 sn_177 20131186.34423431
Csub_120_177 sn_120 sn_177 5.233910869464337e-19
Rsub_120_140 sn_120 sn_140 12560620.13126525
Csub_120_140 sn_120 sn_140 8.388505815889714e-19
Rsub_120_214 sn_120 sn_214 7654567.001032637
Csub_120_214 sn_120 sn_214 1.376496345359389e-18
Rsub_120_135 sn_120 sn_135 985809.3727915999
Csub_120_135 sn_120 sn_135 1.068815512718544e-17
Rsub_120_159 sn_120 sn_159 16253853.58750192
Csub_120_159 sn_120 sn_159 6.48245257378953e-19
Rsub_82_160 sn_82 sn_160 26273182.37088943
Csub_82_160 sn_82 sn_160 4.010356778821122e-19
Rsub_82_203 sn_82 sn_203 39148743.32256708
Csub_82_203 sn_82 sn_203 2.691397630676002e-19
Rsub_82_218 sn_82 sn_218 39148743.32256708
Csub_82_218 sn_82 sn_218 2.691397630676002e-19
Rsub_82_166 sn_82 sn_166 29713474.58668339
Csub_82_166 sn_82 sn_166 3.546028745810869e-19
Rsub_82_227 sn_82 sn_227 12476964.24388874
Csub_82_227 sn_82 sn_227 8.44474929660138e-19
Rsub_82_219 sn_82 sn_219 1151282.893551493
Csub_82_219 sn_82 sn_219 9.151950021360008e-18
Rsub_82_140 sn_82 sn_140 682874.5241190577
Csub_82_140 sn_82 sn_140 1.542960401960022e-17
Rsub_82_180 sn_82 sn_180 1701536.999140609
Csub_82_180 sn_82 sn_180 6.192332877599275e-18
Rsub_82_132 sn_82 sn_132 3917393.000098144
Csub_82_132 sn_82 sn_132 2.689667210301858e-18
Rsub_82_169 sn_82 sn_169 31951058.36129575
Csub_82_169 sn_82 sn_169 3.29769467511395e-19
Rsub_82_90 sn_82 sn_90 5306251.723064073
Csub_82_90 sn_82 sn_90 1.98567351345815e-18
Rsub_82_215 sn_82 sn_215 6825563.935090139
Csub_82_215 sn_82 sn_215 1.543679555627935e-18
Rsub_82_136 sn_82 sn_136 39174635.34857407
Csub_82_136 sn_82 sn_136 2.689618782275027e-19
Rsub_82_141 sn_82 sn_141 1612625.561640677
Csub_82_141 sn_82 sn_141 6.533744567158068e-18
Rsub_82_139 sn_82 sn_139 7850612.200934258
Csub_82_139 sn_82 sn_139 1.342122529116406e-18
Rsub_82_176 sn_82 sn_176 1208023.811637623
Csub_82_176 sn_82 sn_176 8.722082628442996e-18
Rsub_82_97 sn_82 sn_97 5688444.876611123
Csub_82_97 sn_82 sn_97 1.852260807791652e-18
Rsub_82_230 sn_82 0 202942.576259606
Csub_82_230 sn_82 0 5.19185461051388e-17
Rsub_82_151 sn_82 sn_151 15810980.76346168
Csub_82_151 sn_82 sn_151 6.664029044029477e-19
Rsub_82_186 sn_82 sn_186 32798812.52869028
Csub_82_186 sn_82 sn_186 3.212458833079206e-19
Rsub_82_107 sn_82 sn_107 930560.8185434414
Csub_82_107 sn_82 sn_107 1.132272420272564e-17
Rsub_82_112 sn_82 sn_112 278113.3404270156
Csub_82_112 sn_82 sn_112 3.78855738673027e-17
Rsub_82_191 sn_82 sn_191 18948453.75162812
Csub_82_191 sn_82 sn_191 5.560603329611877e-19
Rsub_82_126 sn_82 sn_126 45472.62940943525
Csub_82_126 sn_82 sn_126 2.317104517392117e-16
Rsub_82_228 sn_82 sn_228 482406.0117043311
Csub_82_228 sn_82 sn_228 2.184152611408139e-17
Rsub_82_135 sn_82 sn_135 1257177.38913783
Csub_82_135 sn_82 sn_135 8.381063478604163e-18
Rsub_82_214 sn_82 sn_214 19432293.34360785
Csub_82_214 sn_82 sn_214 5.422151320958688e-19
Rsub_82_86 sn_82 sn_86 712256.8153614167
Csub_82_86 sn_82 sn_86 1.479309607853107e-17
Rsub_82_165 sn_82 sn_165 4100359.066307716
Csub_82_165 sn_82 sn_165 2.569648982404333e-18
Rsub_82_185 sn_82 sn_185 6865862.958495447
Csub_82_185 sn_82 sn_185 1.534618964276403e-18
Rsub_82_222 sn_82 sn_222 247530.0040022816
Csub_82_222 sn_82 sn_222 4.256649025114903e-17
Rsub_82_181 sn_82 sn_181 889385.0287098308
Csub_82_181 sn_82 sn_181 1.184693148873278e-17
Rsub_82_127 sn_82 sn_127 6627271.988154447
Csub_82_127 sn_82 sn_127 1.589867372436631e-18
Rsub_82_206 sn_82 sn_206 12683920.0381556
Csub_82_206 sn_82 sn_206 8.306961468169377e-19
Rsub_82_150 sn_82 sn_150 69585.92535520202
Csub_82_150 sn_82 sn_150 1.514168770257264e-16
Rsub_82_229 sn_82 sn_229 8958184.541059617
Csub_82_229 sn_82 sn_229 1.176185135943147e-18
Rsub_82_171 sn_82 sn_171 13908176.6741922
Csub_82_171 sn_82 sn_171 7.575747525397299e-19
Rsub_82_216 sn_82 sn_216 1476441.783233403
Csub_82_216 sn_82 sn_216 7.136402953291621e-18
Rsub_82_137 sn_82 sn_137 5163574.843732946
Csub_82_137 sn_82 sn_137 2.040540482340094e-18
Rsub_82_210 sn_82 sn_210 68611.60427169777
Csub_82_210 sn_82 sn_210 1.535670767951463e-16
Rsub_82_131 sn_82 sn_131 362707.108375854
Csub_82_131 sn_82 sn_131 2.904956439759544e-17
Rsub_82_118 sn_82 sn_118 271202.7480786441
Csub_82_118 sn_82 sn_118 3.885094666951753e-17
Rsub_82_197 sn_82 sn_197 8124393.846477025
Csub_82_197 sn_82 sn_197 1.296894722404297e-18
Rsub_82_155 sn_82 sn_155 2355707.332123912
Csub_82_155 sn_82 sn_155 4.472747254528548e-18
Rsub_82_168 sn_82 sn_168 365883.8794980014
Csub_82_168 sn_82 sn_168 2.879734279817473e-17
Rsub_82_177 sn_82 sn_177 1514724.250836608
Csub_82_177 sn_82 sn_177 6.956040676321461e-18
Rsub_82_195 sn_82 sn_195 1516832.984078885
Csub_82_195 sn_82 sn_195 6.946370241696983e-18
Rsub_82_225 sn_82 sn_225 69736475.55973536
Csub_82_225 sn_82 sn_225 1.510899915382817e-19
Rsub_82_153 sn_82 sn_153 999837.178025643
Csub_82_153 sn_82 sn_153 1.053819935265477e-17
Rsub_82_190 sn_82 sn_190 99932888.22733405
Csub_82_190 sn_82 sn_190 1.054355947189368e-19
Rsub_82_130 sn_82 sn_130 9752399.781198759
Csub_82_130 sn_82 sn_130 1.080399054450459e-18
Rsub_82_159 sn_82 sn_159 8958380.492746236
Csub_82_159 sn_82 sn_159 1.176159408585245e-18
Rsub_82_125 sn_82 sn_125 6514410.64297977
Csub_82_125 sn_82 sn_125 1.617411624731487e-18
Rsub_82_156 sn_82 sn_156 13554238.622466
Csub_82_156 sn_82 sn_156 7.773570907011996e-19
Rsub_82_154 sn_82 sn_154 10086931.33311221
Csub_82_154 sn_82 sn_154 1.044567783230768e-18
Rsub_82_162 sn_82 sn_162 8497150.401379563
Csub_82_162 sn_82 sn_162 1.240002001202585e-18
Rsub_82_178 sn_82 sn_178 27797499.77315783
Csub_82_178 sn_82 sn_178 3.790442877313869e-19
Rsub_82_99 sn_82 sn_99 19840312.62089368
Csub_82_99 sn_82 sn_99 5.310643891333704e-19
Rsub_82_128 sn_82 sn_128 7075522.652754418
Csub_82_128 sn_82 sn_128 1.489145610766757e-18
Rsub_82_129 sn_82 sn_129 16577017.04943252
Csub_82_129 sn_82 sn_129 6.356079305951303e-19
Rsub_82_138 sn_82 sn_138 1281961.473161855
Csub_82_138 sn_82 sn_138 8.219032882667374e-18
Rsub_82_170 sn_82 sn_170 41234299.84255724
Csub_82_170 sn_82 sn_170 2.555271592451164e-19
Rsub_82_183 sn_82 sn_183 9709053.952398272
Csub_82_183 sn_82 sn_183 1.085222469036475e-18
Rsub_82_158 sn_82 sn_158 9509376.708809165
Csub_82_158 sn_82 sn_158 1.108009896428791e-18
Rsub_82_93 sn_82 sn_93 41168321.35111222
Csub_82_93 sn_82 sn_93 2.559366803510764e-19
Rsub_82_114 sn_82 sn_114 39122851.2965601
Csub_82_114 sn_82 sn_114 2.693178833608282e-19
Rsub_82_157 sn_82 sn_157 15810660.71051866
Csub_82_157 sn_82 sn_157 6.664163943016117e-19
Rsub_82_122 sn_82 sn_122 39122851.2965601
Csub_82_122 sn_82 sn_122 2.693178833608282e-19
Rsub_82_198 sn_82 sn_198 20718655.56605484
Csub_82_198 sn_82 sn_198 5.085505412567809e-19
Rsub_82_152 sn_82 sn_152 17232854.00214727
Csub_82_152 sn_82 sn_152 6.114183698717067e-19
Rsub_82_123 sn_82 sn_123 38876877.04949371
Csub_82_123 sn_82 sn_123 2.710218593128281e-19
Rsub_37_174 sn_37 sn_174 30447501.46547882
Csub_37_174 sn_37 sn_174 3.460541257934153e-19
Rsub_37_188 sn_37 sn_188 44803561.80249345
Csub_37_188 sn_37 sn_188 2.351706667580973e-19
Rsub_37_95 sn_37 sn_95 18902565.22058663
Csub_37_95 sn_37 sn_95 5.574102445500254e-19
Rsub_37_64 sn_37 sn_64 40864521.57929688
Csub_37_64 sn_37 sn_64 2.578393945414029e-19
Rsub_37_203 sn_37 sn_203 2115144.40449614
Csub_37_203 sn_37 sn_203 4.981448774765783e-18
Rsub_37_78 sn_37 sn_78 40894943.96441817
Csub_37_78 sn_37 sn_78 2.576475838039434e-19
Rsub_37_224 sn_37 sn_224 16722751.45487054
Csub_37_224 sn_37 sn_224 6.300687737101555e-19
Rsub_37_98 sn_37 sn_98 51374478.90779581
Csub_37_98 sn_37 sn_98 2.050917834347347e-19
Rsub_37_171 sn_37 sn_171 5923251.997171278
Csub_37_171 sn_37 sn_171 1.778834246333235e-18
Rsub_37_148 sn_37 sn_148 11490894.14920051
Csub_37_148 sn_37 sn_148 9.169420034178181e-19
Rsub_37_71 sn_37 sn_71 44958947.6152585
Csub_37_71 sn_37 sn_71 2.343578767100423e-19
Rsub_37_101 sn_37 sn_101 14888158.62496341
Csub_37_101 sn_37 sn_101 7.077089764857268e-19
Rsub_37_117 sn_37 sn_117 16346001.26499379
Csub_37_117 sn_37 sn_117 6.445908899318809e-19
Rsub_37_207 sn_37 sn_207 41202844.05245487
Csub_37_207 sn_37 sn_207 2.557222382225879e-19
Rsub_37_40 sn_37 sn_40 475088758.8976639
Csub_37_40 sn_37 sn_40 2.21779263451266e-20
Rsub_37_116 sn_37 sn_116 18400983.40120386
Csub_37_116 sn_37 sn_116 5.726043696958428e-19
Rsub_37_144 sn_37 sn_144 28781003.27388291
Csub_37_144 sn_37 sn_144 3.660915987522662e-19
Rsub_37_96 sn_37 sn_96 83034001.269346
Csub_37_96 sn_37 sn_96 1.268936019119651e-19
Rsub_37_154 sn_37 sn_154 8579087.215585673
Csub_37_154 sn_37 sn_154 1.228159038072059e-18
Rsub_37_76 sn_37 sn_76 6433902.821109021
Csub_37_76 sn_37 sn_76 1.637650395909121e-18
Rsub_37_186 sn_37 sn_186 21638256.14460546
Csub_37_186 sn_37 sn_186 4.869377380421115e-19
Rsub_37_93 sn_37 sn_93 15072894.23709998
Csub_37_93 sn_37 sn_93 6.990351910183121e-19
Rsub_37_110 sn_37 sn_110 14553343.27142215
Csub_37_110 sn_37 sn_110 7.239905845497438e-19
Rsub_37_197 sn_37 sn_197 20062463.23344783
Csub_37_197 sn_37 sn_197 5.251839407567727e-19
Rsub_37_58 sn_37 sn_58 19491908.24770314
Csub_37_58 sn_37 sn_58 5.405567976378907e-19
Rsub_37_225 sn_37 sn_225 8874909.001476625
Csub_37_225 sn_37 sn_225 1.187221581706012e-18
Rsub_37_62 sn_37 sn_62 12048222.8845521
Csub_37_62 sn_37 sn_62 8.745259448793554e-19
Rsub_37_229 sn_37 sn_229 6317994.306280123
Csub_37_229 sn_37 sn_229 1.667694364927913e-18
Rsub_37_79 sn_37 sn_79 40351185.43526265
Csub_37_79 sn_37 sn_79 2.611195529592108e-19
Rsub_37_156 sn_37 sn_156 7403478.178953391
Csub_37_156 sn_37 sn_156 1.423180192815739e-18
Rsub_37_179 sn_37 sn_179 8856106.13514765
Csub_37_179 sn_37 sn_179 1.189742234503419e-18
Rsub_37_147 sn_37 sn_147 23794112.43182949
Csub_37_147 sn_37 sn_147 4.428189339870185e-19
Rsub_37_42 sn_37 sn_42 80810739.30287921
Csub_37_42 sn_37 sn_42 1.303846938305958e-19
Rsub_37_209 sn_37 sn_209 10512583.84558684
Csub_37_209 sn_37 sn_209 1.002273433153467e-18
Rsub_37_152 sn_37 sn_152 24284427.06586736
Csub_37_152 sn_37 sn_152 4.338781999530642e-19
Rsub_37_81 sn_37 sn_81 3374646991.052935
Rsub_37_127 sn_37 sn_127 2300094.017218557
Csub_37_127 sn_37 sn_127 4.580892530198175e-18
Rsub_37_167 sn_37 sn_167 20818915.04468614
Csub_37_167 sn_37 sn_167 5.061014697266539e-19
Rsub_37_180 sn_37 sn_180 3676886.957602649
Csub_37_180 sn_37 sn_180 2.865598976450406e-18
Rsub_37_53 sn_37 sn_53 3913934.230534595
Csub_37_53 sn_37 sn_53 2.692044087003181e-18
Rsub_37_85 sn_37 sn_85 15838362.12931907
Csub_37_85 sn_37 sn_85 6.652508268342636e-19
Rsub_37_211 sn_37 sn_211 40615018.60389702
Csub_37_211 sn_37 sn_211 2.594233331514226e-19
Rsub_37_44 sn_37 sn_44 708700.7356448844
Csub_37_44 sn_37 sn_44 1.486732406541429e-17
Rsub_37_175 sn_37 sn_175 52488255.29996251
Csub_37_175 sn_37 sn_175 2.007398310729815e-19
Rsub_37_172 sn_37 sn_172 2661106.648147221
Csub_37_172 sn_37 sn_172 3.959436766491851e-18
Rsub_37_100 sn_37 sn_100 15131966.87250693
Csub_37_100 sn_37 sn_100 6.963062760448939e-19
Rsub_37_68 sn_37 sn_68 32383623.41021434
Csub_37_68 sn_37 sn_68 3.253645637105148e-19
Rsub_37_114 sn_37 sn_114 16131661.33774502
Csub_37_114 sn_37 sn_114 6.531555108695862e-19
Rsub_37_130 sn_37 sn_130 3166646.581599033
Csub_37_130 sn_37 sn_130 3.327331683761655e-18
Rsub_37_39 sn_37 sn_39 26665612.98951093
Csub_37_39 sn_37 sn_39 3.951337442111151e-19
Rsub_37_206 sn_37 sn_206 8392971.543534372
Csub_37_206 sn_37 sn_206 1.255393688347116e-18
Rsub_37_77 sn_37 sn_77 2624123.41397685
Csub_37_77 sn_37 sn_77 4.015239316150148e-18
Rsub_37_227 sn_37 sn_227 52419755.30426755
Csub_37_227 sn_37 sn_227 2.010021496871088e-19
Rsub_37_66 sn_37 sn_66 3831482.882272136
Csub_37_66 sn_37 sn_66 2.749975355750952e-18
Rsub_37_121 sn_37 sn_121 32351416.61435604
Csub_37_121 sn_37 sn_121 3.256884737948201e-19
Rsub_37_199 sn_37 sn_199 7834362.901248024
Csub_37_199 sn_37 sn_199 1.34490623360727e-18
Rsub_37_202 sn_37 sn_202 6624415.725437117
Csub_37_202 sn_37 sn_202 1.590552878764979e-18
Rsub_37_80 sn_37 sn_80 152465.7070427506
Csub_37_80 sn_37 sn_80 6.910723536851223e-17
Rsub_37_159 sn_37 sn_159 3327773.192971865
Csub_37_159 sn_37 sn_159 3.166226449711978e-18
Rsub_37_133 sn_37 sn_133 14570055.14875367
Csub_37_133 sn_37 sn_133 7.231601661529262e-19
Rsub_37_178 sn_37 sn_178 17116693.53234162
Csub_37_178 sn_37 sn_178 6.155676902388621e-19
Rsub_37_99 sn_37 sn_99 401969370.7037984
Csub_37_99 sn_37 sn_99 2.621215512958594e-20
Rsub_37_141 sn_37 sn_141 117148.1370264142
Csub_37_141 sn_37 sn_141 8.994153701184566e-17
Rsub_37_166 sn_37 sn_166 7726983.903611589
Csub_37_166 sn_37 sn_166 1.363595891186631e-18
Rsub_37_112 sn_37 sn_112 373962.5503227981
Csub_37_112 sn_37 sn_112 2.817523704749335e-17
Rsub_37_191 sn_37 sn_191 1940062.037475746
Csub_37_191 sn_37 sn_191 5.431003389942742e-18
Rsub_37_212 sn_37 sn_212 4339058.316979228
Csub_37_212 sn_37 sn_212 2.42828805987685e-18
Rsub_37_45 sn_37 sn_45 586084.6084953556
Csub_37_45 sn_37 sn_45 1.797775158996263e-17
Rsub_37_72 sn_37 sn_72 89008189.35919005
Csub_37_72 sn_37 sn_72 1.18376562629651e-19
Rsub_37_190 sn_37 sn_190 7290458.982481794
Csub_37_190 sn_37 sn_190 1.44524282045178e-18
Rsub_37_43 sn_37 sn_43 10856285.42207327
Csub_37_43 sn_37 sn_43 9.705422336084643e-19
Rsub_37_210 sn_37 sn_210 217208.3072936212
Csub_37_210 sn_37 sn_210 4.850865804127293e-17
Rsub_37_131 sn_37 sn_131 111402.6043537583
Csub_37_131 sn_37 sn_131 9.458022604903799e-17
Rsub_37_221 sn_37 sn_221 5793465.176532482
Csub_37_221 sn_37 sn_221 1.818684186609079e-18
Rsub_37_230 sn_37 0 78071.80566338717
Csub_37_230 sn_37 0 1.349588806445555e-16
Rsub_37_63 sn_37 sn_63 1338485.636011305
Csub_37_63 sn_37 sn_63 7.871943649413214e-18
Rsub_37_196 sn_37 sn_196 9042607.503052922
Csub_37_196 sn_37 sn_196 1.165204118244956e-18
Rsub_37_205 sn_37 sn_205 41637830.08937228
Csub_37_205 sn_37 sn_205 2.530507348633269e-19
Rsub_37_38 sn_37 sn_38 2234476.000454462
Csub_37_38 sn_37 sn_38 4.71541582907448e-18
Rsub_37_157 sn_37 sn_157 2480123.417939304
Csub_37_157 sn_37 sn_157 4.248370635919644e-18
Rsub_37_213 sn_37 sn_213 11503664.67105179
Csub_37_213 sn_37 sn_213 9.159240818923003e-19
Rsub_37_46 sn_37 sn_46 2263428.865312265
Csub_37_46 sn_37 sn_46 4.655098140571066e-18
Rsub_37_125 sn_37 sn_125 1855229.371276114
Csub_37_125 sn_37 sn_125 5.679342762335911e-18
Rsub_37_137 sn_37 sn_137 2566133.629192822
Csub_37_137 sn_37 sn_137 4.105976158982904e-18
Rsub_37_49 sn_37 sn_49 13019566.31506049
Csub_37_49 sn_37 sn_49 8.092806816492677e-19
Rsub_37_216 sn_37 sn_216 152679.3070910629
Csub_37_216 sn_37 sn_216 6.901055357780539e-17
Rsub_37_198 sn_37 sn_198 1102808.247689998
Csub_37_198 sn_37 sn_198 9.554229871149668e-18
Rsub_37_181 sn_37 sn_181 469688.8740979037
Csub_37_181 sn_37 sn_181 2.243289991159922e-17
Rsub_37_107 sn_37 sn_107 106305.0068838354
Csub_37_107 sn_37 sn_107 9.911559023502741e-17
Rsub_37_150 sn_37 sn_150 18714.91915414411
Csub_37_150 sn_37 sn_150 5.629991460527827e-16
Rsub_37_86 sn_37 sn_86 81070.05606940833
Csub_37_86 sn_37 sn_86 1.299676355621262e-16
Rsub_37_165 sn_37 sn_165 1706912.545712006
Csub_37_165 sn_37 sn_165 6.17283148377992e-18
Rsub_37_158 sn_37 sn_158 690688.8387814281
Csub_37_158 sn_37 sn_158 1.525503658176866e-17
Rsub_37_195 sn_37 sn_195 252694.4125710828
Csub_37_195 sn_37 sn_195 4.169654324773048e-17
Rsub_37_204 sn_37 sn_204 6249116.411219939
Csub_37_204 sn_37 sn_204 1.686075727972091e-18
Rsub_37_84 sn_37 sn_84 2548131.215734165
Csub_37_84 sn_37 sn_84 4.134984665298816e-18
Rsub_37_168 sn_37 sn_168 71613.30165366676
Csub_37_168 sn_37 sn_168 1.471302573533909e-16
Rsub_37_59 sn_37 sn_59 37669881.50092585
Csub_37_59 sn_37 sn_59 2.797057777304406e-19
Rsub_37_226 sn_37 sn_226 659859.7694240627
Csub_37_226 sn_37 sn_226 1.596776162217986e-17
Rsub_37_189 sn_37 sn_189 69328741.13804339
Csub_37_189 sn_37 sn_189 1.519785781376062e-19
Rsub_37_118 sn_37 sn_118 355341.2603448534
Csub_37_118 sn_37 sn_118 2.965173110492292e-17
Rsub_37_155 sn_37 sn_155 876533.1306713721
Csub_37_155 sn_37 sn_155 1.202063348610643e-17
Rsub_37_82 sn_37 sn_82 1008676.802676557
Csub_37_82 sn_37 sn_82 1.044584694946002e-17
Rsub_37_161 sn_37 sn_161 21011992.03647358
Csub_37_161 sn_37 sn_161 5.01450956384349e-19
Rsub_37_128 sn_37 sn_128 3930273.956384131
Csub_37_128 sn_37 sn_128 2.680852179557379e-18
Rsub_37_140 sn_37 sn_140 624623.0187928492
Csub_37_140 sn_37 sn_140 1.686854820463211e-17
Rsub_37_52 sn_37 sn_52 130849.4821412739
Csub_37_52 sn_37 sn_52 8.052369279424508e-17
Rsub_37_219 sn_37 sn_219 276569.3639374948
Csub_37_219 sn_37 sn_219 3.809707392106982e-17
Rsub_37_139 sn_37 sn_139 2870523.723340144
Csub_37_139 sn_37 sn_139 3.670578792489386e-18
Rsub_37_61 sn_37 sn_61 48984987.79226322
Csub_37_61 sn_37 sn_61 2.150961749120646e-19
Rsub_37_228 sn_37 sn_228 3342320.282007942
Csub_37_228 sn_37 sn_228 3.152445790114426e-18
Rsub_37_70 sn_37 sn_70 1925527.768285917
Csub_37_70 sn_37 sn_70 5.471997691110661e-18
Rsub_37_177 sn_37 sn_177 252529.0162339685
Csub_37_177 sn_37 sn_177 4.17238528045741e-17
Rsub_37_135 sn_37 sn_135 624555.4925820656
Csub_37_135 sn_37 sn_135 1.68703720123725e-17
Rsub_37_215 sn_37 sn_215 4660435.020596665
Csub_37_215 sn_37 sn_215 2.260836908070663e-18
Rsub_37_48 sn_37 sn_48 936530.7445940051
Csub_37_48 sn_37 sn_48 1.125054736649107e-17
Rsub_37_217 sn_37 sn_217 10688937.69378781
Csub_37_217 sn_37 sn_217 9.857371989691348e-19
Rsub_37_50 sn_37 sn_50 8455234.164920142
Csub_37_50 sn_37 sn_50 1.246149225049821e-18
Rsub_37_90 sn_37 sn_90 5033138.703131014
Csub_37_90 sn_37 sn_90 2.09342204212959e-18
Rsub_37_169 sn_37 sn_169 4480879.973035194
Csub_37_169 sn_37 sn_169 2.351431764661384e-18
Rsub_37_153 sn_37 sn_153 231155.8419864559
Csub_37_153 sn_37 sn_153 4.558173140546179e-17
Rsub_37_47 sn_37 sn_47 169052.1536096843
Csub_37_47 sn_37 sn_47 6.232682209158447e-17
Rsub_37_126 sn_37 sn_126 275376.0187343779
Csub_37_126 sn_37 sn_126 3.826216803720037e-17
Rsub_37_97 sn_37 sn_97 6329939.590839853
Csub_37_97 sn_37 sn_97 1.664547244254511e-18
Rsub_37_138 sn_37 sn_138 2967525.87487687
Csub_37_138 sn_37 sn_138 3.550595326373417e-18
Rsub_37_146 sn_37 sn_146 17395433.35376674
Csub_37_146 sn_37 sn_146 6.057039964427486e-19
Rsub_37_115 sn_37 sn_115 41565332.41655271
Csub_37_115 sn_37 sn_115 2.534921024241351e-19
Rsub_37_183 sn_37 sn_183 4156354.832680675
Csub_37_183 sn_37 sn_183 2.535029834167072e-18
Rsub_37_41 sn_37 sn_41 3557750.375806328
Csub_37_41 sn_37 sn_41 2.961557835502164e-18
Rsub_37_132 sn_37 sn_132 1402150.941914279
Csub_37_132 sn_37 sn_132 7.514514441537317e-18
Rsub_37_185 sn_37 sn_185 4011543.307224416
Csub_37_185 sn_37 sn_185 2.626541132749278e-18
Rsub_37_92 sn_37 sn_92 41565332.41655271
Csub_37_92 sn_37 sn_92 2.534921024241351e-19
Rsub_37_218 sn_37 sn_218 13340297.76500826
Csub_37_218 sn_37 sn_218 7.898237121713511e-19
Rsub_37_51 sn_37 sn_51 4115850.597492812
Csub_37_51 sn_37 sn_51 2.559977154819066e-18
Rsub_37_222 sn_37 sn_222 46617.28479237597
Csub_37_222 sn_37 sn_222 2.260209608765801e-16
Rsub_37_55 sn_37 sn_55 6604935.048629254
Csub_37_55 sn_37 sn_55 1.595244075021854e-18
Rsub_37_145 sn_37 sn_145 20299165.24135529
Csub_37_145 sn_37 sn_145 5.190599404927315e-19
Rsub_37_164 sn_37 sn_164 7326490.43952536
Csub_37_164 sn_37 sn_164 1.43813516023814e-18
Rsub_37_182 sn_37 sn_182 2100537.089854239
Csub_37_182 sn_37 sn_182 5.016090195751387e-18
Rsub_37_200 sn_37 sn_200 4395844.648313875
Csub_37_200 sn_37 sn_200 2.396918987178381e-18
Rsub_204_228 sn_204 sn_228 10530985.628843
Csub_204_228 sn_204 sn_228 1.000522066364988e-18
Rsub_204_218 sn_204 sn_218 2658113.74047471
Csub_204_218 sn_204 sn_218 3.9638949010317e-18
Rsub_204_221 sn_204 sn_221 13793067.87984219
Csub_204_221 sn_204 sn_221 7.6389702378167e-19
Rsub_204_211 sn_204 sn_211 6524626.77803445
Csub_204_211 sn_204 sn_211 1.614879112733576e-18
Rsub_204_207 sn_204 sn_207 2937813.898457196
Csub_204_207 sn_204 sn_207 3.586504750271376e-18
Rsub_204_229 sn_204 sn_229 275132.2869379536
Csub_204_229 sn_204 sn_229 3.829606339370171e-17
Rsub_204_230 sn_204 0 51653.0129149289
Csub_204_230 sn_204 0 2.03985845309417e-16
Rsub_204_222 sn_204 sn_222 456404.2643478825
Csub_204_222 sn_204 sn_222 2.30858568275752e-17
Rsub_204_215 sn_204 sn_215 261109.1855401183
Csub_204_215 sn_204 sn_215 4.035278759127038e-17
Rsub_204_227 sn_204 sn_227 2168347.776869414
Csub_204_227 sn_204 sn_227 4.859222129690936e-18
Rsub_204_206 sn_204 sn_206 147964.2238124222
Csub_204_206 sn_204 sn_206 7.120966968060708e-17
Rsub_204_226 sn_204 sn_226 1201824.674388856
Csub_204_226 sn_204 sn_226 8.767072042008079e-18
Rsub_204_214 sn_204 sn_214 1179671.623727128
Csub_204_214 sn_204 sn_214 8.931708867371397e-18
Rsub_204_212 sn_204 sn_212 1099342.540762694
Csub_204_212 sn_204 sn_212 9.584349837785846e-18
Rsub_204_219 sn_204 sn_219 338506.8351378815
Csub_204_219 sn_204 sn_219 3.112635376457983e-17
Rsub_204_208 sn_204 sn_208 13714400.19231458
Csub_204_208 sn_204 sn_208 7.682788422737254e-19
Rsub_204_225 sn_204 sn_225 2060619.73629869
Csub_204_225 sn_204 sn_225 5.113259528978285e-18
Rsub_204_216 sn_204 sn_216 2856181.747488652
Csub_204_216 sn_204 sn_216 3.689010165930228e-18
Rsub_204_217 sn_204 sn_217 6989892.468123976
Csub_204_217 sn_204 sn_217 1.507388497073389e-18
Rsub_204_220 sn_204 sn_220 25499328.0164854
Csub_204_220 sn_204 sn_220 4.13206320394723e-19
Rsub_86_103 sn_86 sn_103 22957844.05714862
Csub_86_103 sn_86 sn_103 4.589491711853119e-19
Rsub_86_204 sn_86 sn_204 25737066.98837401
Csub_86_204 sn_86 sn_204 4.093894423552442e-19
Rsub_86_187 sn_86 sn_187 42282664.09467833
Csub_86_187 sn_86 sn_187 2.491915712462431e-19
Rsub_86_144 sn_86 sn_144 38133557.38967917
Csub_86_144 sn_86 sn_144 2.763047620907693e-19
Rsub_86_138 sn_86 sn_138 11224847.7600681
Csub_86_138 sn_86 sn_138 9.386749582219796e-19
Rsub_86_97 sn_86 sn_97 8548690.692403616
Csub_86_97 sn_86 sn_97 1.232525995073461e-18
Rsub_86_115 sn_86 sn_115 25736673.85094688
Csub_86_115 sn_86 sn_115 4.093956959338144e-19
Rsub_86_116 sn_86 sn_116 17889948.14513414
Csub_86_116 sn_86 sn_116 5.889610979725398e-19
Rsub_86_151 sn_86 sn_151 13910343.44251135
Csub_86_151 sn_86 sn_151 7.57456747619149e-19
Rsub_86_134 sn_86 sn_134 5990600.042722056
Csub_86_134 sn_86 sn_134 1.758836081041784e-18
Rsub_86_146 sn_86 sn_146 10435852.36494657
Csub_86_146 sn_86 sn_146 1.009642828756513e-18
Rsub_86_225 sn_86 sn_225 6352130.444244127
Csub_86_225 sn_86 sn_225 1.658732230818316e-18
Rsub_86_141 sn_86 sn_141 569890.066647814
Csub_86_141 sn_86 sn_141 1.848862459422623e-17
Rsub_86_90 sn_86 sn_90 3186622.246317868
Csub_86_90 sn_86 sn_90 3.306473967664312e-18
Rsub_86_169 sn_86 sn_169 3865304.248090354
Csub_86_169 sn_86 sn_169 2.725913104365725e-18
Rsub_86_176 sn_86 sn_176 2006928.628638975
Csub_86_176 sn_86 sn_176 5.250053914162088e-18
Rsub_86_230 sn_86 0 103805.5918274448
Csub_86_230 sn_86 0 1.015020801552263e-16
Rsub_86_217 sn_86 sn_217 68908030.58317286
Csub_86_217 sn_86 sn_217 1.529064669684956e-19
Rsub_86_228 sn_86 sn_228 1390248.897627771
Csub_86_228 sn_86 sn_228 7.578846867067299e-18
Rsub_86_149 sn_86 sn_149 23247587.08414169
Csub_86_149 sn_86 sn_149 4.532291228373309e-19
Rsub_86_191 sn_86 sn_191 4905668.447981885
Csub_86_191 sn_86 sn_191 2.147818103476713e-18
Rsub_86_112 sn_86 sn_112 774355.8731871855
Csub_86_112 sn_86 sn_112 1.360677159826101e-17
Rsub_86_140 sn_86 sn_140 292743.4580453175
Csub_86_140 sn_86 sn_140 3.599220823783166e-17
Rsub_86_219 sn_86 sn_219 2061152.230209751
Csub_86_219 sn_86 sn_219 5.111938530206362e-18
Rsub_86_159 sn_86 sn_159 6333165.809652478
Csub_86_159 sn_86 sn_159 1.663699296514736e-18
Rsub_86_158 sn_86 sn_158 1241190.288608
Csub_86_158 sn_86 sn_158 8.489015422483453e-18
Rsub_86_135 sn_86 sn_135 222199.7669337146
Csub_86_135 sn_86 sn_135 4.741896738970562e-17
Rsub_86_210 sn_86 sn_210 44288.38150213846
Csub_86_210 sn_86 sn_210 2.379062667196643e-16
Rsub_86_131 sn_86 sn_131 1137939.886000073
Csub_86_131 sn_86 sn_131 9.259261962656369e-18
Rsub_86_150 sn_86 sn_150 392020.6718175924
Csub_86_150 sn_86 sn_150 2.687736708724543e-17
Rsub_86_229 sn_86 sn_229 12094563.68544881
Csub_86_229 sn_86 sn_229 8.711751640041912e-19
Rsub_86_162 sn_86 sn_162 2947436.504870685
Csub_86_162 sn_86 sn_162 3.574795753807859e-18
Rsub_86_216 sn_86 sn_216 213273.9430558872
Csub_86_216 sn_86 sn_216 4.940351995775207e-17
Rsub_86_137 sn_86 sn_137 5597023.707480484
Csub_86_137 sn_86 sn_137 1.882515431933561e-18
Rsub_86_155 sn_86 sn_155 349093.4800161725
Csub_86_155 sn_86 sn_155 3.018241275013751e-17
Rsub_86_118 sn_86 sn_118 22766.26184009088
Csub_86_118 sn_86 sn_118 4.628113115907104e-16
Rsub_86_197 sn_86 sn_197 9571624.893196164
Csub_86_197 sn_86 sn_197 1.100804055716777e-18
Rsub_86_222 sn_86 sn_222 91962.83568335598
Csub_86_222 sn_86 sn_222 1.14573277606499e-16
Rsub_86_168 sn_86 sn_168 55140.13147099529
Csub_86_168 sn_86 sn_168 1.910855709107691e-16
Rsub_86_218 sn_86 sn_218 35135048.79874693
Csub_86_218 sn_86 sn_218 2.99885267346086e-19
Rsub_86_139 sn_86 sn_139 52004997.3025706
Csub_86_139 sn_86 sn_139 2.026052119746805e-19
Rsub_86_107 sn_86 sn_107 29070.19892054384
Csub_86_107 sn_86 sn_107 3.624496526848288e-16
Rsub_86_181 sn_86 sn_181 630928.7814925199
Csub_86_181 sn_86 sn_181 1.669995697027006e-17
Rsub_86_102 sn_86 sn_102 5397886.373538685
Csub_86_102 sn_86 sn_102 1.951964671557659e-18
Rsub_86_167 sn_86 sn_167 24383383.95831493
Csub_86_167 sn_86 sn_167 4.32117359930141e-19
Rsub_86_130 sn_86 sn_130 11941279.34916109
Csub_86_130 sn_86 sn_130 8.823580115785683e-19
Rsub_86_165 sn_86 sn_165 7344014.705787444
Csub_86_165 sn_86 sn_165 1.434703486354233e-18
Rsub_86_160 sn_86 sn_160 2530426.468734984
Csub_86_160 sn_86 sn_160 4.163916095731255e-18
Rsub_86_132 sn_86 sn_132 27589956.19062615
Csub_86_132 sn_86 sn_132 3.818956227922477e-19
Rsub_86_200 sn_86 sn_200 6733602.881297903
Csub_86_200 sn_86 sn_200 1.564761642165493e-18
Rsub_86_224 sn_86 sn_224 6790502.989489803
Csub_86_224 sn_86 sn_224 1.551649932050416e-18
Rsub_86_177 sn_86 sn_177 2519357.034791058
Csub_86_177 sn_86 sn_177 4.182211316906038e-18
Rsub_86_190 sn_86 sn_190 405527.4842184043
Csub_86_190 sn_86 sn_190 2.598216868712993e-17
Rsub_86_227 sn_86 sn_227 3866422.028281633
Csub_86_227 sn_86 sn_227 2.72512504459136e-18
Rsub_86_126 sn_86 sn_126 1542863.022284269
Csub_86_126 sn_86 sn_126 6.829176245750142e-18
Rsub_86_205 sn_86 sn_205 24794204.10429249
Csub_86_205 sn_86 sn_205 4.249575206330529e-19
Rsub_86_156 sn_86 sn_156 4283891.113031855
Csub_86_156 sn_86 sn_156 2.459559130757871e-18
Rsub_86_120 sn_86 sn_120 4767613.372624783
Csub_86_120 sn_86 sn_120 2.210012154662029e-18
Rsub_86_128 sn_86 sn_128 8548165.180707354
Csub_86_128 sn_86 sn_128 1.232601766518288e-18
Rsub_86_207 sn_86 sn_207 26002498.6512853
Csub_86_207 sn_86 sn_207 4.05210423949361e-19
Rsub_86_213 sn_86 sn_213 24504213.41301421
Csub_86_213 sn_86 sn_213 4.299866037174677e-19
Rsub_86_96 sn_86 sn_96 24504213.41301421
Csub_86_96 sn_86 sn_96 4.299866037174677e-19
Rsub_86_206 sn_86 sn_206 25591678.50530775
Csub_86_206 sn_86 sn_206 4.1171521829038e-19
Rsub_86_127 sn_86 sn_127 7881333.060589307
Csub_86_127 sn_86 sn_127 1.336891033690456e-18
Rsub_86_133 sn_86 sn_133 47628531.165567
Csub_86_133 sn_86 sn_133 2.212220961759858e-19
Rsub_86_185 sn_86 sn_185 11226085.01049547
Csub_86_185 sn_86 sn_185 9.385715048816442e-19
Rsub_86_180 sn_86 sn_180 841386.9427300079
Csub_86_180 sn_86 sn_180 1.252275613886136e-17
Rsub_86_117 sn_86 sn_117 8476667.5894574
Csub_86_117 sn_86 sn_117 1.242998311663706e-18
Rsub_86_164 sn_86 sn_164 18802152.5139312
Csub_86_164 sn_86 sn_164 5.603870883625233e-19
Rsub_86_195 sn_86 sn_195 626237.9444532997
Csub_86_195 sn_86 sn_195 1.682504804372444e-17
Rsub_86_182 sn_86 sn_182 26074996.32410487
Csub_86_182 sn_86 sn_182 4.040837962646083e-19
Rsub_86_192 sn_86 sn_192 13137406.2571383
Csub_86_192 sn_86 sn_192 8.020215936083224e-19
Rsub_86_129 sn_86 sn_129 7637099.279530475
Csub_86_129 sn_86 sn_129 1.379644694481146e-18
Rsub_86_157 sn_86 sn_157 26002498.6512853
Csub_86_157 sn_86 sn_157 4.05210423949361e-19
Rsub_86_198 sn_86 sn_198 25876182.46418333
Csub_86_198 sn_86 sn_198 4.071884837268455e-19
Rsub_86_166 sn_86 sn_166 1821644.816121944
Csub_86_166 sn_86 sn_166 5.784049343197908e-18
Rsub_80_85 sn_80 sn_85 14551785.13891883
Csub_80_85 sn_80 sn_85 7.240681058470359e-19
Rsub_80_83 sn_80 sn_83 14760787.43893921
Csub_80_83 sn_80 sn_83 7.138158140828298e-19
Rsub_80_203 sn_80 sn_203 14760787.43893921
Csub_80_203 sn_80 sn_203 7.138158140828298e-19
Rsub_80_136 sn_80 sn_136 8686453.776620172
Csub_80_136 sn_80 sn_136 1.212978710666629e-18
Rsub_80_206 sn_80 sn_206 15622921.92652327
Csub_80_206 sn_80 sn_206 6.744246403959849e-19
Rsub_80_226 sn_80 sn_226 15074290.88896978
Csub_80_226 sn_80 sn_226 6.989704245351801e-19
Rsub_80_205 sn_80 sn_205 5314983.113796448
Csub_80_205 sn_80 sn_205 1.982411472743867e-18
Rsub_80_120 sn_80 sn_120 5066696.751507417
Csub_80_120 sn_80 sn_120 2.079556764295246e-18
Rsub_80_220 sn_80 sn_220 3201413.614407025
Csub_80_220 sn_80 sn_220 3.291197193269136e-18
Rsub_80_209 sn_80 sn_209 3188899.307106029
Csub_80_209 sn_80 sn_209 3.304112951685517e-18
Rsub_80_192 sn_80 sn_192 10637307.35782613
Csub_80_192 sn_80 sn_192 9.905216750626321e-19
Rsub_80_212 sn_80 sn_212 14988759.97722835
Csub_80_212 sn_80 sn_212 7.029589851487072e-19
Rsub_80_133 sn_80 sn_133 146212445.6127592
Csub_80_133 sn_80 sn_133 7.206283608808291e-20
Rsub_80_213 sn_80 sn_213 6656254.921580569
Csub_80_213 sn_80 sn_213 1.582944707852032e-18
Rsub_80_145 sn_80 sn_145 13397030.50537513
Csub_80_145 sn_80 sn_145 7.864790259306026e-19
Rsub_80_179 sn_80 sn_179 13846402.37635005
Csub_80_179 sn_80 sn_179 7.609545942581112e-19
Rsub_80_84 sn_80 sn_84 13746204.96365225
Csub_80_84 sn_80 sn_84 7.665012656286298e-19
Rsub_80_227 sn_80 sn_227 14395033.41390355
Csub_80_227 sn_80 sn_227 7.319526950214137e-19
Rsub_80_105 sn_80 sn_105 7317152.341023155
Csub_80_105 sn_80 sn_105 1.439970498243951e-18
Rsub_80_170 sn_80 sn_170 4704895.701486775
Csub_80_170 sn_80 sn_170 2.239472279672514e-18
Rsub_80_149 sn_80 sn_149 20300916.51100854
Csub_80_149 sn_80 sn_149 5.190151635034015e-19
Rsub_80_199 sn_80 sn_199 31543666.23453863
Csub_80_199 sn_80 sn_199 3.340284995373528e-19
Rsub_80_141 sn_80 sn_141 953277.9903314153
Csub_80_141 sn_80 sn_141 1.105289706580438e-17
Rsub_80_188 sn_80 sn_188 17394173.99410472
Csub_80_188 sn_80 sn_188 6.057478501595451e-19
Rsub_80_90 sn_80 sn_90 5692145.04744032
Csub_80_90 sn_80 sn_90 1.851056748275962e-18
Rsub_80_169 sn_80 sn_169 3184030.876827359
Csub_80_169 sn_80 sn_169 3.30916498923176e-18
Rsub_80_135 sn_80 sn_135 446248.5080152526
Csub_80_135 sn_80 sn_135 2.361124645344443e-17
Rsub_80_177 sn_80 sn_177 28854.55555950066
Csub_80_177 sn_80 sn_177 3.65158405593974e-16
Rsub_80_210 sn_80 sn_210 97947.85866162408
Csub_80_210 sn_80 sn_210 1.075723721396493e-16
Rsub_80_131 sn_80 sn_131 112912.7080858204
Csub_80_131 sn_80 sn_131 9.331530242124428e-17
Rsub_80_222 sn_80 sn_222 167601.0383061642
Csub_80_222 sn_80 sn_222 6.286645720525039e-17
Rsub_80_176 sn_80 sn_176 384266.2698304356
Csub_80_176 sn_80 sn_176 2.741974596646075e-17
Rsub_80_97 sn_80 sn_97 2025288.893761866
Csub_80_97 sn_80 sn_97 5.202459527963464e-18
Rsub_80_132 sn_80 sn_132 7908766.323241445
Csub_80_132 sn_80 sn_132 1.332253738647771e-18
Rsub_80_211 sn_80 sn_211 3620135.529865998
Csub_80_211 sn_80 sn_211 2.910521834142496e-18
Rsub_80_128 sn_80 sn_128 7163836.193683734
Csub_80_128 sn_80 sn_128 1.470787887573405e-18
Rsub_80_207 sn_80 sn_207 7390663.819238715
Csub_80_207 sn_80 sn_207 1.425647784817701e-18
Rsub_80_189 sn_80 sn_189 8212435.515186154
Csub_80_189 sn_80 sn_189 1.282991322458033e-18
Rsub_80_110 sn_80 sn_110 10217341.42038771
Csub_80_110 sn_80 sn_110 1.031235334977206e-18
Rsub_80_115 sn_80 sn_115 7483630.742665154
Csub_80_115 sn_80 sn_115 1.407937385547384e-18
Rsub_80_229 sn_80 sn_229 2673684.273436186
Csub_80_229 sn_80 sn_229 3.940810665983625e-18
Rsub_80_150 sn_80 sn_150 9310.316104112426
Csub_80_150 sn_80 sn_150 1.131699867588381e-15
Rsub_80_216 sn_80 sn_216 854243.6208637161
Csub_80_216 sn_80 sn_216 1.233428409049948e-17
Rsub_80_137 sn_80 sn_137 5663957.934179656
Csub_80_137 sn_80 sn_137 1.860268671602707e-18
Rsub_80_168 sn_80 sn_168 211992.4370460076
Csub_80_168 sn_80 sn_168 4.970216696901939e-17
Rsub_80_228 sn_80 sn_228 261325.501936515
Csub_80_228 sn_80 sn_228 4.031938492091628e-17
Rsub_80_159 sn_80 sn_159 97370951.05035281
Csub_80_159 sn_80 sn_159 1.082097215706699e-19
Rsub_80_162 sn_80 sn_162 6910773.651790686
Csub_80_162 sn_80 sn_162 1.5246460140537e-18
Rsub_80_219 sn_80 sn_219 57249.25611079798
Csub_80_219 sn_80 sn_219 1.840457713867601e-16
Rsub_80_140 sn_80 sn_140 721337.5575650181
Csub_80_140 sn_80 sn_140 1.460686940771178e-17
Rsub_80_93 sn_80 sn_93 9279464.041977551
Csub_80_93 sn_80 sn_93 1.135462506731646e-18
Rsub_80_195 sn_80 sn_195 108543.4275249105
Csub_80_195 sn_80 sn_195 9.707159376197047e-17
Rsub_80_116 sn_80 sn_116 122416112.2233918
Csub_80_116 sn_80 sn_116 8.607105152140783e-20
Rsub_80_230 sn_80 0 76341.40177600882
Csub_80_230 sn_80 0 1.380179464498806e-16
Rsub_80_151 sn_80 sn_151 14839163.30144685
Csub_80_151 sn_80 sn_151 7.100456601352095e-19
Rsub_80_82 sn_80 sn_82 30670.45731375613
Csub_80_82 sn_80 sn_82 3.435385196393612e-16
Rsub_80_86 sn_80 sn_86 385176.4464079327
Csub_80_86 sn_80 sn_86 2.735495277681393e-17
Rsub_80_180 sn_80 sn_180 522264.9857510539
Csub_80_180 sn_80 sn_180 2.017459295510266e-17
Rsub_80_112 sn_80 sn_112 38714.93749575575
Csub_80_112 sn_80 sn_112 2.72155508539439e-16
Rsub_80_191 sn_80 sn_191 1167181.743459349
Csub_80_191 sn_80 sn_191 9.027286077146363e-18
Rsub_80_126 sn_80 sn_126 6923.791467809703
Csub_80_126 sn_80 sn_126 1.521779439952305e-15
Rsub_80_153 sn_80 sn_153 69497.84505933971
Csub_80_153 sn_80 sn_153 1.516087800022228e-16
Rsub_80_107 sn_80 sn_107 1517062.191955953
Csub_80_107 sn_80 sn_107 6.945320737738035e-18
Rsub_80_181 sn_80 sn_181 343946.3142662123
Csub_80_181 sn_80 sn_181 3.063409336049704e-17
Rsub_80_158 sn_80 sn_158 1387058.448885243
Csub_80_158 sn_80 sn_158 7.59627938584564e-18
Rsub_80_215 sn_80 sn_215 1917498.071802314
Csub_80_215 sn_80 sn_215 5.49491217601405e-18
Rsub_80_157 sn_80 sn_157 29678326.6028937
Csub_80_157 sn_80 sn_157 3.550228300676047e-19
Rsub_80_198 sn_80 sn_198 7850237.302092114
Csub_80_198 sn_80 sn_198 1.342186624017339e-18
Rsub_80_91 sn_80 sn_91 14455687.58041889
Csub_80_91 sn_80 sn_91 7.288815176458513e-19
Rsub_80_156 sn_80 sn_156 1278530.244496459
Csub_80_156 sn_80 sn_156 8.241090539379244e-18
Rsub_80_155 sn_80 sn_155 944726.692578219
Csub_80_155 sn_80 sn_155 1.115294358146616e-17
Rsub_80_117 sn_80 sn_117 2259681.235854583
Csub_80_117 sn_80 sn_117 4.662818513977365e-18
Rsub_80_223 sn_80 sn_223 15426982.27025416
Csub_80_223 sn_80 sn_223 6.829905757100745e-19
Rsub_80_154 sn_80 sn_154 1572135.675281798
Csub_80_154 sn_80 sn_154 6.702019213667029e-18
Rsub_80_118 sn_80 sn_118 4318618.293256532
Csub_80_118 sn_80 sn_118 2.439781149142675e-18
Rsub_80_130 sn_80 sn_130 2984239.935398814
Csub_80_130 sn_80 sn_130 3.530709235958906e-18
Rsub_80_217 sn_80 sn_217 3121658.044620536
Csub_80_217 sn_80 sn_217 3.375284336600295e-18
Rsub_80_134 sn_80 sn_134 6839431.977773842
Csub_80_134 sn_80 sn_134 1.540549498331221e-18
Rsub_80_127 sn_80 sn_127 1078558.392276853
Csub_80_127 sn_80 sn_127 9.769043176222778e-18
Rsub_80_129 sn_80 sn_129 4076582.260332408
Csub_80_129 sn_80 sn_129 2.584636548305748e-18
Rsub_80_185 sn_80 sn_185 1728939.359309166
Csub_80_185 sn_80 sn_185 6.094189160249132e-18
Rsub_80_99 sn_80 sn_99 14301594.49772568
Csub_80_99 sn_80 sn_99 7.367348797300591e-19
Rsub_80_178 sn_80 sn_178 16489712.61454125
Csub_80_178 sn_80 sn_178 6.389731433486921e-19
Rsub_80_218 sn_80 sn_218 2402529.76925153
Csub_80_218 sn_80 sn_218 4.385578749982554e-18
Rsub_80_139 sn_80 sn_139 1572056.565785408
Csub_80_139 sn_80 sn_139 6.702356474664078e-18
Rsub_80_148 sn_80 sn_148 6294201.803333756
Csub_80_148 sn_80 sn_148 1.673998360943766e-18
Rsub_80_125 sn_80 sn_125 1753290.293360238
Csub_80_125 sn_80 sn_125 6.009548756490569e-18
Rsub_80_221 sn_80 sn_221 16302179.4015895
Csub_80_221 sn_80 sn_221 6.463236137128189e-19
Rsub_80_184 sn_80 sn_184 4066238.231109914
Csub_80_184 sn_80 sn_184 2.591211558048329e-18
Rsub_80_163 sn_80 sn_163 7812614.854468941
Csub_80_163 sn_80 sn_163 1.348650061279159e-18
Rsub_80_225 sn_80 sn_225 16824685.15164044
Csub_80_225 sn_80 sn_225 6.262514517962715e-19
Rsub_80_174 sn_80 sn_174 6494142.947030137
Csub_80_174 sn_80 sn_174 1.622459435859582e-18
Rsub_190_202 sn_190 sn_202 3472698.443489422
Csub_190_202 sn_190 sn_202 3.034091117811766e-18
Rsub_190_209 sn_190 sn_209 4403784.25804818
Csub_190_209 sn_190 sn_209 2.392597567188707e-18
Rsub_190_213 sn_190 sn_213 2366044.029923056
Csub_190_213 sn_190 sn_213 4.453206858780497e-18
Rsub_190_211 sn_190 sn_211 14160236.75309505
Csub_190_211 sn_190 sn_211 7.440895011820338e-19
Rsub_190_203 sn_190 sn_203 2373832.680604677
Csub_190_203 sn_190 sn_203 4.438595688869733e-18
Rsub_190_200 sn_190 sn_200 6035703.664783
Csub_190_200 sn_190 sn_200 1.745692646196011e-18
Rsub_190_226 sn_190 sn_226 304525.2530201943
Csub_190_226 sn_190 sn_226 3.459970362960764e-17
Rsub_190_197 sn_190 sn_197 4946154.803444617
Csub_190_197 sn_190 sn_197 2.13023730977691e-18
Rsub_190_224 sn_190 sn_224 564981.3894288266
Csub_190_224 sn_190 sn_224 1.864925765587068e-17
Rsub_190_214 sn_190 sn_214 1176323.130666201
Csub_190_214 sn_190 sn_214 8.957133654477019e-18
Rsub_190_196 sn_190 sn_196 2438666.828518516
Csub_190_196 sn_190 sn_196 4.32059163597632e-18
Rsub_190_198 sn_190 sn_198 1224745.189006815
Csub_190_198 sn_190 sn_198 8.603000523541044e-18
Rsub_190_215 sn_190 sn_215 540947.7619911315
Csub_190_215 sn_190 sn_215 1.947782067430522e-17
Rsub_190_223 sn_190 sn_223 4152139.44330257
Csub_190_223 sn_190 sn_223 2.537603480351659e-18
Rsub_190_195 sn_190 sn_195 193022.6463340365
Csub_190_195 sn_190 sn_195 5.458677363689248e-17
Rsub_190_212 sn_190 sn_212 402685.3247931566
Csub_190_212 sn_190 sn_212 2.616555124685056e-17
Rsub_190_230 sn_190 0 20137.64791095546
Csub_190_230 sn_190 0 5.232231464578271e-16
Rsub_190_216 sn_190 sn_216 3134.850892892395
Csub_190_216 sn_190 sn_216 3.361079637350289e-15
Rsub_190_210 sn_190 sn_210 256397.3171562311
Csub_190_210 sn_190 sn_210 4.109435940708296e-17
Rsub_190_227 sn_190 sn_227 524355.6158166789
Csub_190_227 sn_190 sn_227 2.00941559209193e-17
Rsub_190_222 sn_190 sn_222 68780.66570500465
Csub_190_222 sn_190 sn_222 1.531896121421712e-16
Rsub_190_208 sn_190 sn_208 399020.9174968759
Csub_190_208 sn_190 sn_208 2.64058425015087e-17
Rsub_190_221 sn_190 sn_221 319781.6829425976
Csub_190_221 sn_190 sn_221 3.294899008997133e-17
Rsub_190_191 sn_190 sn_191 2184313.182564076
Csub_190_191 sn_190 sn_191 4.823705495318055e-18
Rsub_190_228 sn_190 sn_228 40290997.88021901
Csub_190_228 sn_190 sn_228 2.615096189365645e-19
Rsub_190_229 sn_190 sn_229 3768794.04087808
Csub_190_229 sn_190 sn_229 2.795717512802885e-18
Rsub_23_101 sn_23 sn_101 21927375.64736287
Csub_23_101 sn_23 sn_101 4.805173073001642e-19
Rsub_23_159 sn_23 sn_159 10119442.67335984
Csub_23_159 sn_23 sn_159 1.041211837680354e-18
Rsub_23_97 sn_23 sn_97 13501574.18895898
Csub_23_97 sn_23 sn_97 7.803892608942069e-19
Rsub_23_50 sn_23 sn_50 80533511.55465458
Csub_23_50 sn_23 sn_50 1.3083352878608e-19
Rsub_23_122 sn_23 sn_122 44675889.61553839
Csub_23_122 sn_23 sn_122 2.358427239592199e-19
Rsub_23_133 sn_23 sn_133 41840470.28494066
Csub_23_133 sn_23 sn_133 2.518251690402802e-19
Rsub_23_163 sn_23 sn_163 68751959.72389096
Csub_23_163 sn_23 sn_163 1.5325357334605e-19
Rsub_23_66 sn_23 sn_66 68751959.72389096
Csub_23_66 sn_23 sn_66 1.5325357334605e-19
Rsub_23_67 sn_23 sn_67 65164621.63260709
Csub_23_67 sn_23 sn_67 1.616902429301877e-19
Rsub_23_110 sn_23 sn_110 24997319.25956446
Csub_23_110 sn_23 sn_110 4.215045378595363e-19
Rsub_23_167 sn_23 sn_167 34533058.15305455
Csub_23_167 sn_23 sn_167 3.051129574314292e-19
Rsub_23_57 sn_23 sn_57 3095485.894101721
Csub_23_57 sn_23 sn_57 3.403822166434902e-18
Rsub_23_224 sn_23 sn_224 7079814.801841064
Csub_23_224 sn_23 sn_224 1.488242813850166e-18
Rsub_23_175 sn_23 sn_175 64578048.43729349
Csub_23_175 sn_23 sn_175 1.6315890240104e-19
Rsub_23_178 sn_23 sn_178 25850678.41594306
Csub_23_178 sn_23 sn_178 4.075902122449431e-19
Rsub_23_68 sn_23 sn_68 138132232.6122182
Csub_23_68 sn_23 sn_68 7.62782393578573e-20
Rsub_23_42 sn_23 sn_42 21518126.38077211
Csub_23_42 sn_23 sn_42 4.896561771123835e-19
Rsub_23_34 sn_23 sn_34 61493673.74506531
Csub_23_34 sn_23 sn_34 1.713425603080922e-19
Rsub_23_185 sn_23 sn_185 66673693.10306333
Csub_23_185 sn_23 sn_185 1.580305966544082e-19
Rsub_23_156 sn_23 sn_156 65987429.7189732
Csub_23_156 sn_23 sn_156 1.596741007658989e-19
Rsub_23_131 sn_23 sn_131 16124985.14156581
Csub_23_131 sn_23 sn_131 6.534259355731016e-19
Rsub_23_139 sn_23 sn_139 66673693.10306333
Csub_23_139 sn_23 sn_139 1.580305966544082e-19
Rsub_23_32 sn_23 sn_32 67302006.2674996
Csub_23_32 sn_23 sn_32 1.565552661290888e-19
Rsub_23_148 sn_23 sn_148 566839.5144318019
Csub_23_148 sn_23 sn_148 1.858812456430766e-17
Rsub_23_160 sn_23 sn_160 486696.0268471621
Csub_23_160 sn_23 sn_160 2.164900250056652e-17
Rsub_23_182 sn_23 sn_182 56309.28801197567
Csub_23_182 sn_23 sn_182 1.871180381465512e-16
Rsub_23_103 sn_23 sn_103 3990520.765296023
Csub_23_103 sn_23 sn_103 2.640378066407177e-18
Rsub_23_188 sn_23 sn_188 12996498.30986268
Csub_23_188 sn_23 sn_188 8.107171063327237e-19
Rsub_23_162 sn_23 sn_162 25078028.70300553
Csub_23_162 sn_23 sn_162 4.201479959613905e-19
Rsub_23_83 sn_23 sn_83 67302006.2674996
Csub_23_83 sn_23 sn_83 1.565552661290888e-19
Rsub_23_84 sn_23 sn_84 6955136.029066823
Csub_23_84 sn_23 sn_84 1.514921269432553e-18
Rsub_23_218 sn_23 sn_218 874696.7465489975
Csub_23_218 sn_23 sn_218 1.204587023308402e-17
Rsub_23_227 sn_23 sn_227 404794.945152044
Csub_23_227 sn_23 sn_227 2.602918744025427e-17
Rsub_23_138 sn_23 sn_138 3661596.500914245
Csub_23_138 sn_23 sn_138 2.877565427976349e-18
Rsub_23_59 sn_23 sn_59 80462555.18228677
Csub_23_59 sn_23 sn_59 1.309489050945467e-19
Rsub_23_226 sn_23 sn_226 170836.7967160022
Csub_23_226 sn_23 sn_226 6.167572621808037e-17
Rsub_23_62 sn_23 sn_62 34533058.15305455
Csub_23_62 sn_23 sn_62 3.051129574314292e-19
Rsub_23_229 sn_23 sn_229 31745038.65719584
Csub_23_229 sn_23 sn_229 3.319096132157846e-19
Rsub_23_150 sn_23 sn_150 134604012.5349992
Csub_23_150 sn_23 sn_150 7.827763306454441e-20
Rsub_23_71 sn_23 sn_71 67302006.2674996
Csub_23_71 sn_23 sn_71 1.565552661290888e-19
Rsub_23_54 sn_23 sn_54 3817397.984320329
Csub_23_54 sn_23 sn_54 2.760121827880615e-18
Rsub_23_221 sn_23 sn_221 586989.284155869
Csub_23_221 sn_23 sn_221 1.795004404106318e-17
Rsub_23_142 sn_23 sn_142 1006420.981272739
Csub_23_142 sn_23 sn_142 1.046926057613123e-17
Rsub_23_202 sn_23 sn_202 39275338.23986197
Csub_23_202 sn_23 sn_202 2.682722536437928e-19
Rsub_23_35 sn_23 sn_35 549965.3669150181
Csub_23_35 sn_23 sn_35 1.915844912441209e-17
Rsub_23_134 sn_23 sn_134 20174035.49492516
Csub_23_134 sn_23 sn_134 5.222794172678285e-19
Rsub_23_213 sn_23 sn_213 179731.7888823291
Csub_23_213 sn_23 sn_213 5.862337190183015e-17
Rsub_23_154 sn_23 sn_154 40348070.98985032
Csub_23_154 sn_23 sn_154 2.611397086339143e-19
Rsub_23_44 sn_23 sn_44 20966751.83382702
Csub_23_44 sn_23 sn_44 5.025329429058635e-19
Rsub_23_211 sn_23 sn_211 83738.37255875906
Csub_23_211 sn_23 sn_211 1.258262273348646e-16
Rsub_23_132 sn_23 sn_132 11614858.22650629
Csub_23_132 sn_23 sn_132 9.071555844034906e-19
Rsub_23_40 sn_23 sn_40 934476900.8257194
Csub_23_40 sn_23 sn_40 1.127527442670845e-20
Rsub_23_207 sn_23 sn_207 2723442.738474027
Csub_23_207 sn_23 sn_207 3.868810367620838e-18
Rsub_23_128 sn_23 sn_128 63077772.46918796
Csub_23_128 sn_23 sn_128 1.670395622701615e-19
Rsub_23_222 sn_23 sn_222 309117.0417056613
Csub_23_222 sn_23 sn_222 3.408574125868723e-17
Rsub_23_37 sn_23 sn_37 67302006.2674996
Csub_23_37 sn_23 sn_37 1.565552661290888e-19
Rsub_23_212 sn_23 sn_212 399346.5905139236
Csub_23_212 sn_23 sn_212 2.638430814864473e-17
Rsub_23_45 sn_23 sn_45 4919301.028227807
Csub_23_45 sn_23 sn_45 2.141865976847081e-18
Rsub_23_203 sn_23 sn_203 613477.404920942
Csub_23_203 sn_23 sn_203 1.717501478899263e-17
Rsub_23_165 sn_23 sn_165 10656762.11767985
Csub_23_165 sn_23 sn_165 9.887133996122234e-19
Rsub_23_192 sn_23 sn_192 112900.784918718
Csub_23_192 sn_23 sn_192 9.332515721494456e-17
Rsub_23_25 sn_23 sn_25 785313.5132549353
Csub_23_25 sn_23 sn_25 1.341691353120719e-17
Rsub_23_166 sn_23 sn_166 2033018.344804827
Csub_23_166 sn_23 sn_166 5.182679993594215e-18
Rsub_23_95 sn_23 sn_95 7851845.590357159
Csub_23_95 sn_23 sn_95 1.341911704831517e-18
Rsub_23_174 sn_23 sn_174 535895.8789776143
Csub_23_174 sn_23 sn_174 1.966143781947264e-17
Rsub_23_48 sn_23 sn_48 1894575.655567266
Csub_23_48 sn_23 sn_48 5.561394960010297e-18
Rsub_23_215 sn_23 sn_215 3491216.314809578
Csub_23_215 sn_23 sn_215 3.017997898765174e-18
Rsub_23_53 sn_23 sn_53 22882906.33061884
Csub_23_53 sn_23 sn_53 4.604521536729575e-19
Rsub_23_220 sn_23 sn_220 34216497.25081658
Csub_23_220 sn_23 sn_220 3.079357721801446e-19
Rsub_23_141 sn_23 sn_141 16679592.36542067
Csub_23_141 sn_23 sn_141 6.316991009968404e-19
Rsub_23_31 sn_23 sn_31 7437550.265217669
Csub_23_31 sn_23 sn_31 1.416660476434661e-18
Rsub_23_198 sn_23 sn_198 998838.6111889668
Csub_23_198 sn_23 sn_198 1.054873468466333e-17
Rsub_23_214 sn_23 sn_214 71123.08835730073
Csub_23_214 sn_23 sn_214 1.481443472940589e-16
Rsub_23_135 sn_23 sn_135 11942343.95108485
Csub_23_135 sn_23 sn_135 8.82279353650073e-19
Rsub_23_170 sn_23 sn_170 602379.0179166211
Csub_23_170 sn_23 sn_170 1.74914517087121e-17
Rsub_23_153 sn_23 sn_153 18444171.81637334
Csub_23_153 sn_23 sn_153 5.712635735087062e-19
Rsub_23_33 sn_23 sn_33 48672510.8089096
Csub_23_33 sn_23 sn_33 2.164770899861052e-19
Rsub_23_200 sn_23 sn_200 170585.4802105718
Csub_23_200 sn_23 sn_200 6.176659050479382e-17
Rsub_23_196 sn_23 sn_196 1116941.211089522
Csub_23_196 sn_23 sn_196 9.433337580902915e-18
Rsub_23_77 sn_23 sn_77 8482511.330472531
Csub_23_77 sn_23 sn_77 1.242141989764139e-18
Rsub_23_190 sn_23 sn_190 5993152.558672167
Csub_23_190 sn_23 sn_190 1.758086983282876e-18
Rsub_23_126 sn_23 sn_126 14215933.91038465
Csub_23_126 sn_23 sn_126 7.411742041465999e-19
Rsub_23_230 sn_23 0 299052.7377591536
Csub_23_230 sn_23 0 3.523286086989683e-17
Rsub_23_49 sn_23 sn_49 18188273.46094208
Csub_23_49 sn_23 sn_49 5.793009174211224e-19
Rsub_23_216 sn_23 sn_216 25448318.54262547
Csub_23_216 sn_23 sn_216 4.140345651749675e-19
Rsub_23_58 sn_23 sn_58 1655845.680195557
Csub_23_58 sn_23 sn_58 6.363203786590566e-18
Rsub_23_130 sn_23 sn_130 186362017.2718269
Csub_23_130 sn_23 sn_130 5.653771973750169e-20
Rsub_23_169 sn_23 sn_169 67302006.2674996
Csub_23_169 sn_23 sn_169 1.565552661290888e-19
Rsub_23_120 sn_23 sn_120 65421612.53299226
Csub_23_120 sn_23 sn_120 1.610550870618854e-19
Rsub_23_177 sn_23 sn_177 16865967.56728676
Csub_23_177 sn_23 sn_177 6.247185914590856e-19
Rsub_23_155 sn_23 sn_155 16925686.21235064
Csub_23_155 sn_23 sn_155 6.225144062130581e-19
Rsub_23_88 sn_23 sn_88 86297.21448924372
Csub_23_88 sn_23 sn_88 1.220952908456077e-16
Rsub_23_206 sn_23 sn_206 1805240.911992238
Csub_23_206 sn_23 sn_206 5.836607974168992e-18
Rsub_23_39 sn_23 sn_39 11534974.31988568
Csub_23_39 sn_23 sn_39 9.134379678735536e-19
Rsub_23_144 sn_23 sn_144 1677636.648689296
Csub_23_144 sn_23 sn_144 6.280551578592388e-18
Rsub_23_43 sn_23 sn_43 1429864.189439486
Csub_23_43 sn_23 sn_43 7.368870120707305e-18
Rsub_23_52 sn_23 sn_52 845877.8777601024
Csub_23_52 sn_23 sn_52 1.245627031898596e-17
Rsub_23_152 sn_23 sn_152 25468549.80747383
Csub_23_152 sn_23 sn_152 4.137056715784436e-19
Rsub_70_109 sn_70 sn_109 10896035.00711639
Csub_70_109 sn_70 sn_109 9.670016198872741e-19
Rsub_70_204 sn_70 sn_204 13347284.3171857
Csub_70_204 sn_70 sn_204 7.894102839079732e-19
Rsub_70_154 sn_70 sn_154 30566975.14713958
Csub_70_154 sn_70 sn_154 3.447015431363673e-19
Rsub_70_208 sn_70 sn_208 29107007.93983368
Csub_70_208 sn_70 sn_208 3.619912951550941e-19
Rsub_70_206 sn_70 sn_206 29344296.14125399
Csub_70_206 sn_70 sn_206 3.59064107433716e-19
Rsub_70_227 sn_70 sn_227 8147155.532640769
Csub_70_227 sn_70 sn_227 1.293271431976059e-18
Rsub_70_85 sn_70 sn_85 24379289.01596032
Csub_70_85 sn_70 sn_85 4.321899418531898e-19
Rsub_70_151 sn_70 sn_151 15621977.284794
Csub_70_151 sn_70 sn_151 6.744654220234928e-19
Rsub_70_157 sn_70 sn_157 13492970.68220112
Csub_70_157 sn_70 sn_157 7.808868595652485e-19
Rsub_70_138 sn_70 sn_138 8161485.024385381
Csub_70_138 sn_70 sn_138 1.291000776298487e-18
Rsub_70_189 sn_70 sn_189 223349.9865973456
Csub_70_189 sn_70 sn_189 4.717476666441503e-17
Rsub_70_175 sn_70 sn_175 301296875.9679931
Csub_70_175 sn_70 sn_175 3.49704372751256e-20
Rsub_70_96 sn_70 sn_96 470223493.4046317
Csub_70_96 sn_70 sn_96 2.240739488778214e-20
Rsub_70_159 sn_70 sn_159 17937922.73378584
Csub_70_159 sn_70 sn_159 5.873859341798074e-19
Rsub_70_80 sn_70 sn_80 1384470.69914159
Csub_70_80 sn_70 sn_80 7.61047778675483e-18
Rsub_70_93 sn_70 sn_93 27491129.82174641
Csub_70_93 sn_70 sn_93 3.832684786165206e-19
Rsub_70_221 sn_70 sn_221 32997832.72130571
Csub_70_221 sn_70 sn_221 3.193083494670518e-19
Rsub_70_210 sn_70 sn_210 21569.39164089565
Csub_70_210 sn_70 sn_210 4.884923820592505e-16
Rsub_70_131 sn_70 sn_131 1926236.787850939
Csub_70_131 sn_70 sn_131 5.46998352886061e-18
Rsub_70_137 sn_70 sn_137 43028941.53786344
Csub_70_137 sn_70 sn_137 2.448696882994064e-19
Rsub_70_216 sn_70 sn_216 534415.3853850098
Csub_70_216 sn_70 sn_216 1.971590599817628e-17
Rsub_70_176 sn_70 sn_176 336258.9283266431
Csub_70_176 sn_70 sn_176 3.13344349090259e-17
Rsub_70_97 sn_70 sn_97 1800729.327565105
Csub_70_97 sn_70 sn_97 5.851231132264134e-18
Rsub_70_117 sn_70 sn_117 80820393.43673854
Csub_70_117 sn_70 sn_117 1.303691191565077e-19
Rsub_70_228 sn_70 sn_228 791446.3844036907
Csub_70_228 sn_70 sn_228 1.331294666304987e-17
Rsub_70_191 sn_70 sn_191 15463741.89693681
Csub_70_191 sn_70 sn_191 6.813670049884343e-19
Rsub_70_112 sn_70 sn_112 710681.7301448076
Csub_70_112 sn_70 sn_112 1.482588204439011e-17
Rsub_70_71 sn_70 sn_71 301296875.9679931
Csub_70_71 sn_70 sn_71 3.49704372751256e-20
Rsub_70_150 sn_70 sn_150 1643898.405297682
Csub_70_150 sn_70 sn_150 6.409449311633113e-18
Rsub_70_229 sn_70 sn_229 25392872.99437807
Csub_70_229 sn_70 sn_229 4.149386130731546e-19
Rsub_70_126 sn_70 sn_126 496828.4918682009
Csub_70_126 sn_70 sn_126 2.120748643583252e-17
Rsub_70_158 sn_70 sn_158 1661253.185824514
Csub_70_158 sn_70 sn_158 6.342491073689364e-18
Rsub_70_79 sn_70 sn_79 23755106.67793972
Csub_70_79 sn_70 sn_79 4.435460402295205e-19
Rsub_70_169 sn_70 sn_169 3033523.031542819
Csub_70_169 sn_70 sn_169 3.473348773907693e-18
Rsub_70_90 sn_70 sn_90 173252.6168485066
Csub_70_90 sn_70 sn_90 6.081572500254461e-17
Rsub_70_168 sn_70 sn_168 2332556.110858006
Csub_70_168 sn_70 sn_168 4.517140425125409e-18
Rsub_70_180 sn_70 sn_180 827709.0241441968
Csub_70_180 sn_70 sn_180 1.272969509197283e-17
Rsub_70_101 sn_70 sn_101 273126934.228368
Csub_70_101 sn_70 sn_101 3.857724076901253e-20
Rsub_70_118 sn_70 sn_118 27026.18583416455
Csub_70_118 sn_70 sn_118 3.898620237011224e-16
Rsub_70_135 sn_70 sn_135 47226.06711822005
Csub_70_135 sn_70 sn_135 2.231073672904889e-16
Rsub_70_220 sn_70 sn_220 17321946.29778381
Csub_70_220 sn_70 sn_220 6.082736501485431e-19
Rsub_70_141 sn_70 sn_141 418064.5253201911
Csub_70_141 sn_70 sn_141 2.520300782315893e-17
Rsub_70_160 sn_70 sn_160 4489650.165755657
Csub_70_160 sn_70 sn_160 2.34683842019495e-18
Rsub_70_86 sn_70 sn_86 398644.0951279858
Csub_70_86 sn_70 sn_86 2.643080289160494e-17
Rsub_70_165 sn_70 sn_165 7760281.885583261
Csub_70_165 sn_70 sn_165 1.357744945039207e-18
Rsub_70_111 sn_70 sn_111 64192124.4673854
Csub_70_111 sn_70 sn_111 1.641398160545902e-19
Rsub_70_190 sn_70 sn_190 1522253.411086194
Csub_70_190 sn_70 sn_190 6.921635665583275e-18
Rsub_70_222 sn_70 sn_222 950374.5881717253
Csub_70_222 sn_70 sn_222 1.108666375697131e-17
Rsub_70_82 sn_70 sn_82 1346986.243259704
Csub_70_82 sn_70 sn_82 7.822265115886952e-18
Rsub_70_107 sn_70 sn_107 360124.6255968416
Csub_70_107 sn_70 sn_107 2.925788117035229e-17
Rsub_70_181 sn_70 sn_181 462013.3104322497
Csub_70_181 sn_70 sn_181 2.280558430745706e-17
Rsub_70_177 sn_70 sn_177 606003.1372550089
Csub_70_177 sn_70 sn_177 1.738684646082319e-17
Rsub_70_140 sn_70 sn_140 17057.99481871461
Csub_70_140 sn_70 sn_140 6.176859363722074e-16
Rsub_70_155 sn_70 sn_155 968881.941573234
Csub_70_155 sn_70 sn_155 1.087488893138131e-17
Rsub_70_185 sn_70 sn_185 13852009.98297578
Csub_70_185 sn_70 sn_185 7.606465426446716e-19
Rsub_70_115 sn_70 sn_115 282276225.5373241
Csub_70_115 sn_70 sn_115 3.732685415561789e-20
Rsub_70_203 sn_70 sn_203 301296875.9679931
Csub_70_203 sn_70 sn_203 3.49704372751256e-20
Rsub_70_195 sn_70 sn_195 1461349.122377777
Csub_70_195 sn_70 sn_195 7.210106976412299e-18
Rsub_70_134 sn_70 sn_134 37633382.57063977
Csub_70_134 sn_70 sn_134 2.799770518223411e-19
Rsub_70_148 sn_70 sn_148 3748337.52829451
Csub_70_148 sn_70 sn_148 2.810975111684803e-18
Rsub_70_230 sn_70 0 139733.6505111695
Csub_70_230 sn_70 0 7.540405237883469e-17
Rsub_70_202 sn_70 sn_202 211694144.0136651
Csub_70_202 sn_70 sn_202 4.977220107491427e-20
Rsub_70_127 sn_70 sn_127 26888560.83215672
Csub_70_127 sn_70 sn_127 3.918574730719374e-19
Rsub_70_125 sn_70 sn_125 20917591.12108205
Csub_70_125 sn_70 sn_125 5.037140003951352e-19
Rsub_70_226 sn_70 sn_226 18976222.32031601
Csub_70_226 sn_70 sn_226 5.552466304607743e-19
Rsub_70_130 sn_70 sn_130 5132190.419104097
Csub_70_130 sn_70 sn_130 2.053018816879617e-18
Rsub_70_153 sn_70 sn_153 4903712.892063751
Csub_70_153 sn_70 sn_153 2.148674633721403e-18
Rsub_70_224 sn_70 sn_224 34435982.2382087
Csub_70_224 sn_70 sn_224 3.059730786636069e-19
Rsub_70_139 sn_70 sn_139 3947919.930530185
Csub_70_139 sn_70 sn_139 2.668869604155069e-18
Rsub_70_84 sn_70 sn_84 16754063.67173482
Csub_70_84 sn_70 sn_84 6.288912175978969e-19
Rsub_70_167 sn_70 sn_167 25050122.96497726
Csub_70_167 sn_70 sn_167 4.20616039169194e-19
Rsub_70_198 sn_70 sn_198 14667881.23601165
Csub_70_198 sn_70 sn_198 7.183371158174841e-19
Rsub_70_179 sn_70 sn_179 29229220.47011182
Csub_70_179 sn_70 sn_179 3.604777456519589e-19
Rsub_70_152 sn_70 sn_152 9488807.963879608
Csub_70_152 sn_70 sn_152 1.110411712655426e-18
Rsub_70_128 sn_70 sn_128 150720360.2784604
Csub_70_128 sn_70 sn_128 6.9907499443098e-20
Rsub_70_136 sn_70 sn_136 301440720.5569209
Csub_70_136 sn_70 sn_136 3.4953749721549e-20
Rsub_70_215 sn_70 sn_215 4088239.465857269
Csub_70_215 sn_70 sn_215 2.577266715960482e-18
Rsub_70_201 sn_70 sn_201 47942928.71228427
Csub_70_201 sn_70 sn_201 2.19771377870169e-19
Rsub_30_133 sn_30 sn_133 20299242.85373118
Csub_30_133 sn_30 sn_133 5.19057955912543e-19
Rsub_30_73 sn_30 sn_73 26543808.58890905
Csub_30_73 sn_30 sn_73 3.96946936493225e-19
Rsub_30_110 sn_30 sn_110 6812510.277186812
Csub_30_110 sn_30 sn_110 1.546637446920812e-18
Rsub_30_175 sn_30 sn_175 34049740.33425742
Csub_30_175 sn_30 sn_175 3.094438723701294e-19
Rsub_30_94 sn_30 sn_94 48066008.85205716
Csub_30_94 sn_30 sn_94 2.192086206837008e-19
Rsub_30_68 sn_30 sn_68 24033004.42602858
Csub_30_68 sn_30 sn_68 4.384172413674016e-19
Rsub_30_82 sn_30 sn_82 19229368.11875189
Csub_30_82 sn_30 sn_82 5.479370636185982e-19
Rsub_30_151 sn_30 sn_151 15546922.23219887
Csub_30_151 sn_30 sn_151 6.777215030000046e-19
Rsub_30_167 sn_30 sn_167 33421427.16982117
Csub_30_167 sn_30 sn_167 3.152613276713755e-19
Rsub_30_127 sn_30 sn_127 31267766.26729945
Csub_30_127 sn_30 sn_127 3.369758943493606e-19
Rsub_30_99 sn_30 sn_99 8159046.603441305
Csub_30_99 sn_30 sn_99 1.291386606100025e-18
Rsub_30_182 sn_30 sn_182 15410698.49730513
Csub_30_182 sn_30 sn_182 6.837122602893383e-19
Rsub_30_117 sn_30 sn_117 2182654.441965097
Csub_30_117 sn_30 sn_117 4.827371341816138e-18
Rsub_30_95 sn_30 sn_95 25592092.88828371
Csub_30_95 sn_30 sn_95 4.117085518650059e-19
Rsub_30_152 sn_30 sn_152 34775816.67623783
Csub_30_152 sn_30 sn_152 3.029830643612041e-19
Rsub_30_121 sn_30 sn_121 7137936.248846831
Csub_30_121 sn_30 sn_121 1.476124629711035e-18
Rsub_30_108 sn_30 sn_108 27233386.5572492
Csub_30_108 sn_30 sn_108 3.868958228929967e-19
Rsub_30_138 sn_30 sn_138 5204058.404853557
Csub_30_138 sn_30 sn_138 2.024666651012826e-18
Rsub_30_196 sn_30 sn_196 11115125.52608405
Csub_30_196 sn_30 sn_196 9.479410266221337e-19
Rsub_30_172 sn_30 sn_172 1787179.774353812
Csub_30_172 sn_30 sn_172 5.895592403981664e-18
Rsub_30_58 sn_30 sn_58 80424085.04784152
Csub_30_58 sn_30 sn_58 1.31011543320166e-19
Rsub_30_87 sn_30 sn_87 32716697.15589678
Csub_30_87 sn_30 sn_87 3.220521757444862e-19
Rsub_30_185 sn_30 sn_185 4098774.490062025
Csub_30_185 sn_30 sn_185 2.570642402449069e-18
Rsub_30_179 sn_30 sn_179 4386468.533079735
Csub_30_179 sn_30 sn_179 2.402042422684917e-18
Rsub_30_81 sn_30 sn_81 4141999.774777238
Csub_30_81 sn_30 sn_81 2.54381556618908e-18
Rsub_30_156 sn_30 sn_156 14160652.30117104
Csub_30_156 sn_30 sn_156 7.440676656794029e-19
Rsub_30_165 sn_30 sn_165 17850111.79946867
Csub_30_165 sn_30 sn_165 5.902754907419476e-19
Rsub_30_76 sn_30 sn_76 63758347.46189575
Csub_30_76 sn_30 sn_76 1.652565337978212e-19
Rsub_30_131 sn_30 sn_131 1516783.171435306
Csub_30_131 sn_30 sn_131 6.946598367293002e-18
Rsub_30_120 sn_30 sn_120 6715402.025465067
Csub_30_120 sn_30 sn_120 1.569002639346869e-18
Rsub_30_97 sn_30 sn_97 8192877.793820658
Csub_30_97 sn_30 sn_97 1.286054029779007e-18
Rsub_30_100 sn_30 sn_100 19310351.73031939
Csub_30_100 sn_30 sn_100 5.456391291768422e-19
Rsub_30_154 sn_30 sn_154 5891394.863296893
Csub_30_154 sn_30 sn_154 1.788453116234287e-18
Rsub_30_217 sn_30 sn_217 33590588.40640015
Csub_30_217 sn_30 sn_217 3.136736806974909e-19
Rsub_30_50 sn_30 sn_50 3181213.873769944
Csub_30_50 sn_30 sn_50 3.312095294537235e-18
Rsub_30_71 sn_30 sn_71 29229717.190757
Csub_30_71 sn_30 sn_71 3.604716198062238e-19
Rsub_30_191 sn_30 sn_191 8897694.805996913
Csub_30_191 sn_30 sn_191 1.184181266267817e-18
Rsub_30_51 sn_30 sn_51 2798304.891879811
Csub_30_51 sn_30 sn_51 3.765309324514646e-18
Rsub_30_218 sn_30 sn_218 932703.6875577829
Csub_30_218 sn_30 sn_218 1.129671045883717e-17
Rsub_30_144 sn_30 sn_144 10414531.1723424
Csub_30_144 sn_30 sn_144 1.011709824270484e-18
Rsub_30_128 sn_30 sn_128 4150614.147156765
Csub_30_128 sn_30 sn_128 2.538536016277893e-18
Rsub_30_115 sn_30 sn_115 8141073.257870509
Csub_30_115 sn_30 sn_115 1.294237647602998e-18
Rsub_30_229 sn_30 sn_229 5772056.368514387
Csub_30_229 sn_30 sn_229 1.825429765326752e-18
Rsub_30_62 sn_30 sn_62 13545358.43211935
Csub_30_62 sn_30 sn_62 7.778667175942296e-19
Rsub_30_54 sn_30 sn_54 26110130.47432216
Csub_30_54 sn_30 sn_54 4.035400555578241e-19
Rsub_30_134 sn_30 sn_134 57742325.15140032
Csub_30_134 sn_30 sn_134 1.824741811938357e-19
Rsub_30_103 sn_30 sn_103 6089836.325352655
Csub_30_103 sn_30 sn_103 1.730175154029258e-18
Rsub_30_180 sn_30 sn_180 13616435.57584044
Csub_30_180 sn_30 sn_180 7.738062904600979e-19
Rsub_30_36 sn_30 sn_36 5206991.734630789
Csub_30_36 sn_30 sn_36 2.023526066337632e-18
Rsub_30_130 sn_30 sn_130 33001571.98234916
Csub_30_130 sn_30 sn_130 3.19272170061033e-19
Rsub_30_170 sn_30 sn_170 6913088.02067244
Csub_30_170 sn_30 sn_170 1.524135591897919e-18
Rsub_30_40 sn_30 sn_40 487989512.9294769
Csub_30_40 sn_30 sn_40 2.159161871938159e-20
Rsub_30_207 sn_30 sn_207 8528637.853008851
Csub_30_207 sn_30 sn_207 1.235423954425828e-18
Rsub_30_74 sn_30 sn_74 1816286.52791641
Csub_30_74 sn_30 sn_74 5.801113062440177e-18
Rsub_30_113 sn_30 sn_113 33373095.38794145
Csub_30_113 sn_30 sn_113 3.157178972987056e-19
Rsub_30_192 sn_30 sn_192 3289202.361775056
Csub_30_192 sn_30 sn_192 3.203355203887142e-18
Rsub_30_186 sn_30 sn_186 20443786.9255521
Csub_30_186 sn_30 sn_186 5.153880511766025e-19
Rsub_30_160 sn_30 sn_160 2054479.961414413
Csub_30_160 sn_30 sn_160 5.128540409309287e-18
Rsub_30_66 sn_30 sn_66 11338104.33235209
Csub_30_66 sn_30 sn_66 9.292985135235749e-19
Rsub_30_42 sn_30 sn_42 3588413.191706195
Csub_30_42 sn_30 sn_42 2.936251468081406e-18
Rsub_30_140 sn_30 sn_140 769947.6733262743
Csub_30_140 sn_30 sn_140 1.368467477369082e-17
Rsub_30_59 sn_30 sn_59 12064984.58544889
Csub_30_59 sn_30 sn_59 8.733109791899481e-19
Rsub_30_226 sn_30 sn_226 703455.6146114954
Csub_30_226 sn_30 sn_226 1.49781781300432e-17
Rsub_30_107 sn_30 sn_107 255204.1450959613
Csub_30_107 sn_30 sn_107 4.128649046146211e-17
Rsub_30_159 sn_30 sn_159 4192202.356824067
Csub_30_159 sn_30 sn_159 2.51335279297258e-18
Rsub_30_80 sn_30 sn_80 2180879.676964698
Csub_30_80 sn_30 sn_80 4.831299779405737e-18
Rsub_30_215 sn_30 sn_215 5990138.695549426
Csub_30_215 sn_30 sn_215 1.758971542688725e-18
Rsub_30_48 sn_30 sn_48 10845238.28882299
Csub_30_48 sn_30 sn_48 9.715308434567832e-19
Rsub_30_135 sn_30 sn_135 2035232.656662678
Csub_30_135 sn_30 sn_135 5.177041291931437e-18
Rsub_30_56 sn_30 sn_56 17733718.71380303
Csub_30_56 sn_30 sn_56 5.941496914591826e-19
Rsub_30_47 sn_30 sn_47 1804401.543930404
Csub_30_47 sn_30 sn_47 5.839323036312141e-18
Rsub_30_214 sn_30 sn_214 5341316.630667387
Csub_30_214 sn_30 sn_214 1.972637877660042e-18
Rsub_30_205 sn_30 sn_205 19399372.33466288
Csub_30_205 sn_30 sn_205 5.43135278835974e-19
Rsub_30_38 sn_30 sn_38 1661473.218789412
Csub_30_38 sn_30 sn_38 6.341651122072932e-18
Rsub_30_93 sn_30 sn_93 387755.7011364229
Csub_30_93 sn_30 sn_93 2.717299441723226e-17
Rsub_30_158 sn_30 sn_158 180713.400953262
Csub_30_158 sn_30 sn_158 5.83049372467682e-17
Rsub_30_79 sn_30 sn_79 4343917.812820083
Csub_30_79 sn_30 sn_79 2.425571559188798e-18
Rsub_30_195 sn_30 sn_195 581816.107304622
Csub_30_195 sn_30 sn_195 1.810964559067012e-17
Rsub_30_37 sn_30 sn_37 1195508.365529967
Csub_30_37 sn_30 sn_37 8.813391696811084e-18
Rsub_30_116 sn_30 sn_116 17556703.17008023
Csub_30_116 sn_30 sn_116 6.001402085663813e-19
Rsub_30_84 sn_30 sn_84 953263.0528015457
Csub_30_84 sn_30 sn_84 1.105307026351679e-17
Rsub_30_155 sn_30 sn_155 106812.7168461424
Csub_30_155 sn_30 sn_155 9.864446681388322e-17
Rsub_30_90 sn_30 sn_90 74934758.49357814
Csub_30_90 sn_30 sn_90 1.406087603943232e-19
Rsub_30_169 sn_30 sn_169 20744599.12112812
Csub_30_169 sn_30 sn_169 5.079145391389474e-19
Rsub_30_164 sn_30 sn_164 7679662.895640493
Csub_30_164 sn_30 sn_164 1.371998178228791e-18
Rsub_30_188 sn_30 sn_188 5087651.625746213
Csub_30_188 sn_30 sn_188 2.07099154527598e-18
Rsub_30_197 sn_30 sn_197 15206724.69950823
Csub_30_197 sn_30 sn_197 6.928831625768e-19
Rsub_30_150 sn_30 sn_150 2048731.880579912
Csub_30_150 sn_30 sn_150 5.142929439477241e-18
Rsub_30_57 sn_30 sn_57 5573009.552662083
Csub_30_57 sn_30 sn_57 1.890627210067673e-18
Rsub_30_224 sn_30 sn_224 847683.4853113999
Csub_30_224 sn_30 sn_224 1.242973785004126e-17
Rsub_30_190 sn_30 sn_190 111818.456065489
Csub_30_190 sn_30 sn_190 9.422848314109319e-17
Rsub_30_148 sn_30 sn_148 14256523.17434965
Csub_30_148 sn_30 sn_148 7.390640321889456e-19
Rsub_30_168 sn_30 sn_168 182823.3456626468
Csub_30_168 sn_30 sn_168 5.763204619213323e-17
Rsub_30_32 sn_30 sn_32 3845171.385592895
Csub_30_32 sn_30 sn_32 2.740185662909108e-18
Rsub_30_199 sn_30 sn_199 29003096.80748407
Csub_30_199 sn_30 sn_199 3.632882230531716e-19
Rsub_30_49 sn_30 sn_49 5841386.520973114
Csub_30_49 sn_30 sn_49 1.803764134490921e-18
Rsub_30_216 sn_30 sn_216 8664.408898974241
Csub_30_216 sn_30 sn_216 1.216064895491877e-15
Rsub_30_198 sn_30 sn_198 2498068.046611857
Csub_30_198 sn_30 sn_198 4.217852878956076e-18
Rsub_30_31 sn_30 sn_31 1189398.537903587
Csub_30_31 sn_30 sn_31 8.858665255130903e-18
Rsub_30_189 sn_30 sn_189 18044758.51724586
Csub_30_189 sn_30 sn_189 5.839082574676744e-19
Rsub_30_184 sn_30 sn_184 1331097.942694154
Csub_30_184 sn_30 sn_184 7.915633526488715e-18
Rsub_30_202 sn_30 sn_202 14484370.99301399
Csub_30_202 sn_30 sn_202 7.274381129364813e-19
Rsub_30_35 sn_30 sn_35 2784752.867308658
Csub_30_35 sn_30 sn_35 3.78363323579699e-18
Rsub_30_123 sn_30 sn_123 12270944.65367643
Csub_30_123 sn_30 sn_123 8.586530050946997e-19
Rsub_30_211 sn_30 sn_211 11884840.01631986
Csub_30_211 sn_30 sn_211 8.865481981887565e-19
Rsub_30_44 sn_30 sn_44 659221.9210311947
Csub_30_44 sn_30 sn_44 1.598321167134157e-17
Rsub_30_86 sn_30 sn_86 1247660.386926024
Csub_30_86 sn_30 sn_86 8.444993215012387e-18
Rsub_30_52 sn_30 sn_52 27884.00548845981
Csub_30_52 sn_30 sn_52 3.778683627999813e-16
Rsub_30_41 sn_30 sn_41 3268054.09635487
Csub_30_41 sn_30 sn_41 3.224084789166192e-18
Rsub_30_208 sn_30 sn_208 1650649.131590989
Csub_30_208 sn_30 sn_208 6.38323632840999e-18
Rsub_30_129 sn_30 sn_129 10691889.85535922
Csub_30_129 sn_30 sn_129 9.854650248710412e-19
Rsub_30_171 sn_30 sn_171 197263.1923821041
Csub_30_171 sn_30 sn_171 5.341332751941148e-17
Rsub_30_92 sn_30 sn_92 16053200.73366618
Csub_30_92 sn_30 sn_92 6.56347832250878e-19
Rsub_30_118 sn_30 sn_118 717003.7777716097
Csub_30_118 sn_30 sn_118 1.469515758337641e-17
Rsub_30_206 sn_30 sn_206 15693887.25074894
Csub_30_206 sn_30 sn_206 6.713749967667943e-19
Rsub_30_39 sn_30 sn_39 28483310.9046759
Csub_30_39 sn_30 sn_39 3.69917792825844e-19
Rsub_30_63 sn_30 sn_63 10564852.11853021
Csub_30_63 sn_30 sn_63 9.97314811794625e-19
Rsub_30_230 sn_30 0 67139.25969836798
Csub_30_230 sn_30 0 1.569347584344324e-16
Rsub_30_132 sn_30 sn_132 680284.1383267549
Csub_30_132 sn_30 sn_132 1.548835686239255e-17
Rsub_30_220 sn_30 sn_220 11098180.69428696
Csub_30_220 sn_30 sn_220 9.493883540438205e-19
Rsub_30_53 sn_30 sn_53 14495139.35167448
Csub_30_53 sn_30 sn_53 7.268977031954389e-19
Rsub_30_70 sn_30 sn_70 5047103.928095813
Csub_30_70 sn_30 sn_70 2.087629589629877e-18
Rsub_30_61 sn_30 sn_61 25700742.0249612
Csub_30_61 sn_30 sn_61 4.099680659802238e-19
Rsub_30_228 sn_30 sn_228 2929099.66794384
Csub_30_228 sn_30 sn_228 3.597174796590778e-18
Rsub_30_126 sn_30 sn_126 2703116.481135636
Csub_30_126 sn_30 sn_126 3.897902134725398e-18
Rsub_30_176 sn_30 sn_176 898244.2135943911
Csub_30_176 sn_30 sn_176 1.173008781216355e-17
Rsub_30_125 sn_30 sn_125 2155538.045177261
Csub_30_125 sn_30 sn_125 4.888099064548653e-18
Rsub_30_177 sn_30 sn_177 1008532.191986432
Csub_30_177 sn_30 sn_177 1.044734475106547e-17
Rsub_30_146 sn_30 sn_146 675847.0617189442
Csub_30_146 sn_30 sn_146 1.559004114840951e-17
Rsub_30_210 sn_30 sn_210 411272.3233140792
Csub_30_210 sn_30 sn_210 2.561923792324711e-17
Rsub_30_43 sn_30 sn_43 4040872.556180246
Csub_30_43 sn_30 sn_43 2.607477309848624e-18
Rsub_30_122 sn_30 sn_122 22083042.45495376
Csub_30_122 sn_30 sn_122 4.771300659192643e-19
Rsub_30_112 sn_30 sn_112 3525566.489187965
Csub_30_112 sn_30 sn_112 2.988593048675376e-18
Rsub_30_77 sn_30 sn_77 2675661.89833477
Csub_30_77 sn_30 sn_77 3.937897949209318e-18
Rsub_30_212 sn_30 sn_212 2505460.411969626
Csub_30_212 sn_30 sn_212 4.205408096608846e-18
Rsub_30_45 sn_30 sn_45 3496218.832707718
Csub_30_45 sn_30 sn_45 3.013679636886403e-18
Rsub_30_139 sn_30 sn_139 2000878.0885585
Csub_30_139 sn_30 sn_139 5.265929774772453e-18
Rsub_30_141 sn_30 sn_141 935616.3011476452
Csub_30_141 sn_30 sn_141 1.126154331567945e-17
Rsub_30_162 sn_30 sn_162 564450.0828999742
Csub_30_162 sn_30 sn_162 1.866681186066397e-17
Rsub_30_213 sn_30 sn_213 11928607.9477112
Csub_30_213 sn_30 sn_213 8.832953139558659e-19
Rsub_30_222 sn_30 sn_222 93977.70468366328
Csub_30_222 sn_30 sn_222 1.121168423691202e-16
Rsub_30_55 sn_30 sn_55 66584752.31231838
Csub_30_55 sn_30 sn_55 1.582416865171806e-19
Rsub_30_181 sn_30 sn_181 1114844.943731776
Csub_30_181 sn_30 sn_181 9.451075292103589e-18
Rsub_30_33 sn_30 sn_33 9887345.429829082
Csub_30_33 sn_30 sn_33 1.065653423055549e-18
Rsub_30_200 sn_30 sn_200 22024029.86918687
Csub_30_200 sn_30 sn_200 4.78408518550516e-19
Rsub_30_166 sn_30 sn_166 2273067.606032533
Csub_30_166 sn_30 sn_166 4.635358611537575e-18
Rsub_30_157 sn_30 sn_157 18396232.09763128
Csub_30_157 sn_30 sn_157 5.727522596100911e-19
Rsub_227_229 sn_227 sn_229 406303.8964473235
Csub_227_229 sn_227 sn_229 2.593251897006121e-17
Rsub_227_228 sn_227 sn_228 25868632.48288423
Csub_227_228 sn_227 sn_228 4.073073251630669e-19
Rsub_227_230 sn_227 0 18615.63361984784
Csub_227_230 sn_227 0 5.660018733391964e-16
Rsub_31_64 sn_31 sn_64 6729509.368488381
Csub_31_64 sn_31 sn_64 1.565713475571959e-18
Rsub_31_95 sn_31 sn_95 28139643.35532803
Csub_31_95 sn_31 sn_95 3.744355736560889e-19
Rsub_31_120 sn_31 sn_120 30303559.37192145
Csub_31_120 sn_31 sn_120 3.476978850211522e-19
Rsub_31_204 sn_31 sn_204 31391492.33087324
Csub_31_204 sn_31 sn_204 3.356477414699864e-19
Rsub_31_106 sn_31 sn_106 65972882.26580749
Csub_31_106 sn_31 sn_106 1.597093099522023e-19
Rsub_31_89 sn_31 sn_89 24879228.97431679
Csub_31_89 sn_31 sn_89 4.235052265127258e-19
Rsub_31_96 sn_31 sn_96 28479527.10598838
Csub_31_96 sn_31 sn_96 3.699669402170129e-19
Rsub_31_51 sn_31 sn_51 5863680.823049401
Csub_31_51 sn_31 sn_51 1.796906042500198e-18
Rsub_31_213 sn_31 sn_213 74954875.68773426
Csub_31_213 sn_31 sn_213 1.405710223058139e-19
Rsub_31_65 sn_31 sn_65 10757124.55382304
Csub_31_65 sn_31 sn_65 9.79488844766176e-19
Rsub_31_168 sn_31 sn_168 1324767.524028471
Csub_31_168 sn_31 sn_168 7.953458483183315e-18
Rsub_31_70 sn_31 sn_70 3567417.442485378
Csub_31_70 sn_31 sn_70 2.953532540584698e-18
Rsub_31_198 sn_31 sn_198 2694061.509166534
Csub_31_198 sn_31 sn_198 3.911003318365099e-18
Rsub_31_164 sn_31 sn_164 4439225.391392978
Csub_31_164 sn_31 sn_164 2.373495953293728e-18
Rsub_31_35 sn_31 sn_35 1992494.169564759
Csub_31_35 sn_31 sn_35 5.288087495147649e-18
Rsub_31_202 sn_31 sn_202 11014335.82101458
Csub_31_202 sn_31 sn_202 9.566154213427128e-19
Rsub_31_154 sn_31 sn_154 29442696.66358528
Csub_31_154 sn_31 sn_154 3.578640782337551e-19
Rsub_31_125 sn_31 sn_125 238976.7846685346
Csub_31_125 sn_31 sn_125 4.40899877234699e-17
Rsub_31_212 sn_31 sn_212 2022838.54274843
Csub_31_212 sn_31 sn_212 5.208761490135582e-18
Rsub_31_45 sn_31 sn_45 401829.6752444369
Csub_31_45 sn_31 sn_45 2.62212677444008e-17
Rsub_31_185 sn_31 sn_185 1740656.690165654
Csub_31_185 sn_31 sn_185 6.053165774594684e-18
Rsub_31_157 sn_31 sn_157 9716947.403436672
Csub_31_157 sn_31 sn_157 1.084340900981256e-18
Rsub_31_118 sn_31 sn_118 1348969.131047304
Csub_31_118 sn_31 sn_118 7.810766947683787e-18
Rsub_31_191 sn_31 sn_191 762076.5191561191
Csub_31_191 sn_31 sn_191 1.38260177782377e-17
Rsub_31_112 sn_31 sn_112 1519164.519683962
Csub_31_112 sn_31 sn_112 6.935709309760572e-18
Rsub_31_165 sn_31 sn_165 2103423.691957582
Csub_31_165 sn_31 sn_165 5.009206439252413e-18
Rsub_31_140 sn_31 sn_140 385556.7159274828
Csub_31_140 sn_31 sn_140 2.732797294655801e-17
Rsub_31_71 sn_31 sn_71 10229360.25658249
Csub_31_71 sn_31 sn_71 1.03002370020646e-18
Rsub_31_150 sn_31 sn_150 2007925.118932904
Csub_31_150 sn_31 sn_150 5.247448424685046e-18
Rsub_31_152 sn_31 sn_152 4678994.124388048
Csub_31_152 sn_31 sn_152 2.251869359551298e-18
Rsub_31_101 sn_31 sn_101 17548287.1353874
Csub_31_101 sn_31 sn_101 6.004280315759374e-19
Rsub_31_180 sn_31 sn_180 3522590.440541342
Csub_31_180 sn_31 sn_180 2.991117951427468e-18
Rsub_31_74 sn_31 sn_74 1689829.592806077
Csub_31_74 sn_31 sn_74 6.235234337879864e-18
Rsub_31_84 sn_31 sn_84 3197395.926171359
Csub_31_84 sn_31 sn_84 3.295332747498258e-18
Rsub_31_176 sn_31 sn_176 1228930.651410948
Csub_31_176 sn_31 sn_176 8.573700631628774e-18
Rsub_31_160 sn_31 sn_160 671034.0692029519
Csub_31_160 sn_31 sn_160 1.57018607337555e-17
Rsub_31_48 sn_31 sn_48 426871.2170250369
Csub_31_48 sn_31 sn_48 2.468304978644652e-17
Rsub_31_206 sn_31 sn_206 1936495.742084157
Csub_31_206 sn_31 sn_206 5.441005251522056e-18
Rsub_31_39 sn_31 sn_39 14456321.59865254
Csub_31_39 sn_31 sn_39 7.288495507191881e-19
Rsub_31_107 sn_31 sn_107 573778.8332135385
Csub_31_107 sn_31 sn_107 1.836331856861775e-17
Rsub_31_63 sn_31 sn_63 65897241.24237481
Csub_31_63 sn_31 sn_63 1.59892634404467e-19
Rsub_31_230 sn_31 0 41236.19462180605
Csub_31_230 sn_31 0 2.555154179202127e-16
Rsub_31_37 sn_31 sn_37 2927770.87374285
Csub_31_37 sn_31 sn_37 3.598807405567297e-18
Rsub_31_195 sn_31 sn_195 861886.8891366328
Csub_31_195 sn_31 sn_195 1.222490286722493e-17
Rsub_31_170 sn_31 sn_170 8730415.908685731
Csub_31_170 sn_31 sn_170 1.206870739313513e-18
Rsub_31_135 sn_31 sn_135 169862.2119099899
Csub_31_135 sn_31 sn_135 6.202959082985031e-17
Rsub_31_169 sn_31 sn_169 1487871.793307785
Csub_31_169 sn_31 sn_169 7.081580247452409e-18
Rsub_31_128 sn_31 sn_128 1192532.739061294
Csub_31_128 sn_31 sn_128 8.835383010552671e-18
Rsub_31_146 sn_31 sn_146 1032966.229381066
Csub_31_146 sn_31 sn_146 1.020022068731449e-17
Rsub_31_183 sn_31 sn_183 2928802.29682054
Csub_31_183 sn_31 sn_183 3.597540029816363e-18
Rsub_31_44 sn_31 sn_44 101929.7749510178
Csub_31_44 sn_31 sn_44 1.033700261507816e-16
Rsub_31_211 sn_31 sn_211 31343160.54899353
Csub_31_211 sn_31 sn_211 3.361653170158153e-19
Rsub_31_155 sn_31 sn_155 7758.649573819282
Csub_31_155 sn_31 sn_155 1.358030595657293e-15
Rsub_31_190 sn_31 sn_190 121842.9786713733
Csub_31_190 sn_31 sn_190 8.647591857261055e-17
Rsub_31_171 sn_31 sn_171 1193589.2903443
Csub_31_171 sn_31 sn_171 8.827562032825105e-18
Rsub_31_208 sn_31 sn_208 1865415.307706153
Csub_31_208 sn_31 sn_208 5.648331210054455e-18
Rsub_31_41 sn_31 sn_41 2906625.009551761
Csub_31_41 sn_31 sn_41 3.62498893651743e-18
Rsub_31_134 sn_31 sn_134 5698277.359369307
Csub_31_134 sn_31 sn_134 1.849064697580146e-18
Rsub_31_110 sn_31 sn_110 3382284.20564129
Csub_31_110 sn_31 sn_110 3.11519755928738e-18
Rsub_31_80 sn_31 sn_80 1079483.307763833
Csub_31_80 sn_31 sn_80 9.760672931623646e-18
Rsub_31_226 sn_31 sn_226 2291932.573327314
Csub_31_226 sn_31 sn_226 4.597204832659479e-18
Rsub_31_59 sn_31 sn_59 3760048.605706817
Csub_31_59 sn_31 sn_59 2.802220026155578e-18
Rsub_31_220 sn_31 sn_220 4010002.520309777
Csub_31_220 sn_31 sn_220 2.627550344136953e-18
Rsub_31_53 sn_31 sn_53 13650115.77825878
Csub_31_53 sn_31 sn_53 7.718970061053978e-19
Rsub_31_141 sn_31 sn_141 87956.87069915366
Csub_31_141 sn_31 sn_141 1.19791477555731e-16
Rsub_31_158 sn_31 sn_158 45210.78820704542
Csub_31_158 sn_31 sn_158 2.330524177985477e-16
Rsub_31_184 sn_31 sn_184 616022.1018214204
Csub_31_184 sn_31 sn_184 1.710406732335789e-17
Rsub_31_115 sn_31 sn_115 3281691.561079106
Csub_31_115 sn_31 sn_115 3.210686716324227e-18
Rsub_31_36 sn_31 sn_36 335983.5966146339
Csub_31_36 sn_31 sn_36 3.136011284001797e-17
Rsub_31_203 sn_31 sn_203 3118416.38529857
Csub_31_203 sn_31 sn_203 3.37879301555209e-18
Rsub_31_43 sn_31 sn_43 3361103.918665512
Csub_31_43 sn_31 sn_43 3.134828246076185e-18
Rsub_31_210 sn_31 sn_210 2023815.341908855
Csub_31_210 sn_31 sn_210 5.206247469342748e-18
Rsub_31_122 sn_31 sn_122 16033398.09319602
Csub_31_122 sn_31 sn_122 6.571584788817349e-19
Rsub_31_93 sn_31 sn_93 564574.2497638258
Csub_31_93 sn_31 sn_93 1.8662706467108e-17
Rsub_31_38 sn_31 sn_38 568048.4229230139
Csub_31_38 sn_31 sn_38 1.854856571559918e-17
Rsub_31_205 sn_31 sn_205 16249076.99859556
Csub_31_205 sn_31 sn_205 6.484358159630045e-19
Rsub_31_222 sn_31 sn_222 246349.4495418457
Csub_31_222 sn_31 sn_222 4.2770477148723e-17
Rsub_31_55 sn_31 sn_55 253210205.2678135
Csub_31_55 sn_31 sn_55 4.161160681136785e-20
Rsub_31_132 sn_31 sn_132 291475.6171977902
Csub_31_132 sn_31 sn_132 3.614876470123445e-17
Rsub_31_162 sn_31 sn_162 259107.1719200721
Csub_31_162 sn_31 sn_162 4.066457683957987e-17
Rsub_31_218 sn_31 sn_218 1188368.229331404
Csub_31_218 sn_31 sn_218 8.86634566809145e-18
Rsub_31_60 sn_31 sn_60 32672284.55068562
Csub_31_60 sn_31 sn_60 3.224899527881009e-19
Rsub_31_139 sn_31 sn_139 779660.8419339076
Csub_31_139 sn_31 sn_139 1.351418839516784e-17
Rsub_31_216 sn_31 sn_216 121095.1653291421
Csub_31_216 sn_31 sn_216 8.700994357282032e-17
Rsub_31_49 sn_31 sn_49 100570551.0043474
Csub_31_49 sn_31 sn_49 1.047670853645272e-19
Rsub_31_137 sn_31 sn_137 1505996.821205578
Csub_31_137 sn_31 sn_137 6.996351754444844e-18
Rsub_31_57 sn_31 sn_57 4756070.312445623
Csub_31_57 sn_31 sn_57 2.215375890187802e-18
Rsub_31_66 sn_31 sn_66 2203083.8737686
Csub_31_66 sn_31 sn_66 4.782606612342121e-18
Rsub_31_177 sn_31 sn_177 1079620.072277128
Csub_31_177 sn_31 sn_177 9.759436465465587e-18
Rsub_31_181 sn_31 sn_181 224525.5287901703
Csub_31_181 sn_31 sn_181 4.692777502409021e-17
Rsub_31_131 sn_31 sn_131 4533480.214594844
Csub_31_131 sn_31 sn_131 2.324148998888185e-18
Rsub_31_52 sn_31 sn_52 111157.578291576
Csub_31_52 sn_31 sn_52 9.478871044304229e-17
Rsub_31_219 sn_31 sn_219 1951340.677942761
Csub_31_219 sn_31 sn_219 5.399612492749496e-18
Rsub_31_83 sn_31 sn_83 12765427.10684805
Csub_31_83 sn_31 sn_83 8.253921638530746e-19
Rsub_31_207 sn_31 sn_207 912659.8288527646
Csub_31_207 sn_31 sn_207 1.154480910535376e-17
Rsub_31_40 sn_31 sn_40 309668351.6693195
Csub_31_40 sn_31 sn_40 3.402505759930361e-20
Rsub_31_90 sn_31 sn_90 52977439.62761874
Csub_31_90 sn_31 sn_90 1.988862349009599e-19
Rsub_31_199 sn_31 sn_199 6281147.782823109
Csub_31_199 sn_31 sn_199 1.677477408037405e-18
Rsub_31_32 sn_31 sn_32 2501992.589557365
Csub_31_32 sn_31 sn_32 4.211236894228388e-18
Rsub_31_78 sn_31 sn_78 12930497.81373433
Csub_31_78 sn_31 sn_78 8.148552092896618e-19
Rsub_31_166 sn_31 sn_166 3781765.599212753
Csub_31_166 sn_31 sn_166 2.786128126085703e-18
Rsub_31_130 sn_31 sn_130 3513255.408952004
Csub_31_130 sn_31 sn_130 2.999065617427744e-18
Rsub_31_187 sn_31 sn_187 58842777.17615326
Csub_31_187 sn_31 sn_187 1.790616284253156e-19
Rsub_31_159 sn_31 sn_159 2460804.216951044
Csub_31_159 sn_31 sn_159 4.281723604685947e-18
Rsub_31_79 sn_31 sn_79 2035802.702076537
Csub_31_79 sn_31 sn_79 5.17559166783829e-18
Rsub_31_77 sn_31 sn_77 1721177.27790015
Csub_31_77 sn_31 sn_77 6.121672437533333e-18
Rsub_31_179 sn_31 sn_179 13908056.37785645
Csub_31_179 sn_31 sn_179 7.575813051064088e-19
Rsub_31_103 sn_31 sn_103 12140278.5996411
Csub_31_103 sn_31 sn_103 8.678947040425819e-19
Rsub_31_153 sn_31 sn_153 14691241.60476561
Csub_31_153 sn_31 sn_153 7.1719489650297e-19
Rsub_31_156 sn_31 sn_156 1446313.869120534
Csub_31_156 sn_31 sn_156 7.285060129193785e-18
Rsub_31_151 sn_31 sn_151 6522219.019843576
Csub_31_151 sn_31 sn_151 1.615475265423193e-18
Rsub_31_136 sn_31 sn_136 11564713.68689025
Csub_31_136 sn_31 sn_136 9.11089006394871e-19
Rsub_31_214 sn_31 sn_214 3645012.302369568
Csub_31_214 sn_31 sn_214 2.890657871135412e-18
Rsub_31_47 sn_31 sn_47 6289733.09364204
Csub_31_47 sn_31 sn_47 1.675187698009122e-18
Rsub_31_127 sn_31 sn_127 8098814.621486617
Csub_31_127 sn_31 sn_127 1.300990823308402e-18
Rsub_31_62 sn_31 sn_62 28516697.50502432
Csub_31_62 sn_31 sn_62 3.694847027911837e-19
Rsub_31_229 sn_31 sn_229 4956135.65842964
Csub_31_229 sn_31 sn_229 2.125947356648527e-18
Rsub_31_116 sn_31 sn_116 1738559.969647111
Csub_31_116 sn_31 sn_116 6.060465952387406e-18
Rsub_31_196 sn_31 sn_196 4043177.395013716
Csub_31_196 sn_31 sn_196 2.605990900924657e-18
Rsub_31_138 sn_31 sn_138 2045656.990208533
Csub_31_138 sn_31 sn_138 5.150659935982679e-18
Rsub_31_117 sn_31 sn_117 6378352.597850703
Csub_31_117 sn_31 sn_117 1.651912988595277e-18
Rsub_31_100 sn_31 sn_100 26579106.55860792
Csub_31_100 sn_31 sn_100 3.96419777278693e-19
Rsub_31_56 sn_31 sn_56 11161272.10539172
Csub_31_56 sn_31 sn_56 9.440217389861951e-19
Rsub_31_86 sn_31 sn_86 8951860.937657034
Csub_31_86 sn_31 sn_86 1.177015994284168e-18
Rsub_31_161 sn_31 sn_161 7941056.802407973
Csub_31_161 sn_31 sn_161 1.326836435552887e-18
Rsub_31_129 sn_31 sn_129 17176233.16001429
Csub_31_129 sn_31 sn_129 6.134338887969099e-19
Rsub_31_221 sn_31 sn_221 3536542.919316332
Csub_31_221 sn_31 sn_221 2.979317300146569e-18
Rsub_31_143 sn_31 sn_143 7646582.867139016
Csub_31_143 sn_31 sn_143 1.377933605808453e-18
Rsub_31_192 sn_31 sn_192 4120082.612141368
Csub_31_192 sn_31 sn_192 2.557347629676236e-18
Rsub_31_217 sn_31 sn_217 17567722.0208764
Csub_31_217 sn_31 sn_217 5.997637877983891e-19
Rsub_31_97 sn_31 sn_97 4681989.532618175
Csub_31_97 sn_31 sn_97 2.250428675422088e-18
Rsub_31_34 sn_31 sn_34 184323076.0581214
Csub_31_34 sn_31 sn_34 5.716312752347731e-20
Rsub_31_201 sn_31 sn_201 20759127.19729249
Csub_31_201 sn_31 sn_201 5.075590800177872e-19
Rsub_31_178 sn_31 sn_178 1834396.541972799
Csub_31_178 sn_31 sn_178 5.743841781831183e-18
Rsub_31_228 sn_31 sn_228 3408651.132571958
Csub_31_228 sn_31 sn_228 3.091100582733974e-18
Rsub_31_61 sn_31 sn_61 59265960.05486439
Csub_31_61 sn_31 sn_61 1.777830561164628e-19
Rsub_31_126 sn_31 sn_126 11311376.43289036
Csub_31_126 sn_31 sn_126 9.314943733631588e-19
Rsub_31_88 sn_31 sn_88 4101582.979516207
Csub_31_88 sn_31 sn_88 2.568882198617083e-18
Rsub_31_145 sn_31 sn_145 6151221.150465963
Csub_31_145 sn_31 sn_145 1.712909232897901e-18
Rsub_31_46 sn_31 sn_46 10086171.34978364
Csub_31_46 sn_31 sn_46 1.044646490410459e-18
Rsub_31_72 sn_31 sn_72 20420727.11900287
Csub_31_72 sn_31 sn_72 5.159700455732104e-19
Rsub_31_182 sn_31 sn_182 3752843.922639422
Csub_31_182 sn_31 sn_182 2.807599708228623e-18
Rsub_31_69 sn_31 sn_69 15843765.69971337
Csub_31_69 sn_31 sn_69 6.650239407681102e-19
Rsub_31_186 sn_31 sn_186 262082460.6579084
Csub_31_186 sn_31 sn_186 4.020293260289205e-20
Rsub_31_91 sn_31 sn_91 10776385.41365207
Csub_31_91 sn_31 sn_91 9.777381837960106e-19
Rsub_31_225 sn_31 sn_225 4800375.956090761
Csub_31_225 sn_31 sn_225 2.194928813619528e-18
Rsub_31_133 sn_31 sn_133 23442222.2270457
Csub_31_133 sn_31 sn_133 4.494660702462703e-19
Rsub_31_92 sn_31 sn_92 15533255.91741412
Csub_31_92 sn_31 sn_92 6.783177691946539e-19
Rsub_31_172 sn_31 sn_172 14624543.31188539
Csub_31_172 sn_31 sn_172 7.204658140447354e-19
Rsub_31_149 sn_31 sn_149 12983233.44503343
Csub_31_149 sn_31 sn_149 8.115454094573486e-19
Rsub_31_87 sn_31 sn_87 9683432.674307102
Csub_31_87 sn_31 sn_87 1.088093846119908e-18
Rsub_31_102 sn_31 sn_102 22232553.24687138
Csub_31_102 sn_31 sn_102 4.739214333699041e-19
Rsub_31_209 sn_31 sn_209 10216019.58387189
Csub_31_209 sn_31 sn_209 1.03136876507794e-18
Rsub_31_194 sn_31 sn_194 31753980.69497108
Csub_31_194 sn_31 sn_194 3.318161462477262e-19
Rsub_31_121 sn_31 sn_121 31753980.69497108
Csub_31_121 sn_31 sn_121 3.318161462477262e-19
Rsub_31_200 sn_31 sn_200 13268981.95947632
Csub_31_200 sn_31 sn_200 7.940687186408564e-19
Rsub_31_167 sn_31 sn_167 31222331.09429425
Csub_31_167 sn_31 sn_167 3.374662663850714e-19
Rsub_31_175 sn_31 sn_175 8706855.104148196
Csub_31_175 sn_31 sn_175 1.21013653910585e-18
Rsub_31_75 sn_31 sn_75 7154538.622211444
Csub_31_75 sn_31 sn_75 1.4726992275252e-18
Rsub_31_197 sn_31 sn_197 8026918.061481141
Csub_31_197 sn_31 sn_197 1.312643709768453e-18
Rsub_31_81 sn_31 sn_81 26094472.11176011
Csub_31_81 sn_31 sn_81 4.037822055607509e-19
Rsub_31_174 sn_31 sn_174 23235797.23936317
Csub_31_174 sn_31 sn_174 4.534590913188212e-19
Rsub_19_106 sn_19 sn_106 1165470041.08962
Rsub_19_230 sn_19 0 391504.7901989237
Csub_19_230 sn_19 0 2.69127831025424e-17
Rsub_19_55 sn_19 sn_55 231263409.92807
Csub_19_55 sn_19 sn_55 4.556052989751889e-20
Rsub_19_28 sn_19 sn_28 1418199475.696403
Rsub_19_121 sn_19 sn_121 697040745.418101
Csub_19_121 sn_19 sn_121 1.51160223724224e-20
Rsub_19_72 sn_19 sn_72 445365026.5254552
Csub_19_72 sn_19 sn_72 2.365808466019678e-20
Rsub_19_26 sn_19 sn_26 614020329.8571686
Csub_19_26 sn_19 sn_26 1.715982841265364e-20
Rsub_19_99 sn_19 sn_99 280219809.0280231
Csub_19_99 sn_19 sn_99 3.760078039727846e-20
Rsub_19_119 sn_19 sn_119 263979246.5657173
Csub_19_119 sn_19 sn_119 3.991406006080466e-20
Rsub_19_57 sn_19 sn_57 309467363.8983861
Csub_19_57 sn_19 sn_57 3.404715563379946e-20
Rsub_19_92 sn_19 sn_92 340468311.407438
Csub_19_92 sn_19 sn_92 3.094703133655515e-20
Rsub_19_21 sn_19 sn_21 103373021.1466473
Csub_19_21 sn_19 sn_21 1.01926821769896e-19
Rsub_19_161 sn_19 sn_161 129850057.5628002
Csub_19_161 sn_19 sn_161 8.114346423862138e-20
Rsub_19_73 sn_19 sn_73 3983932599.189394
Rsub_19_147 sn_19 sn_147 331270247.0598869
Csub_19_147 sn_19 sn_147 3.180630797889078e-20
Rsub_19_105 sn_19 sn_105 161458163.3779728
Csub_19_105 sn_19 sn_105 6.525828909352908e-20
Rsub_19_199 sn_19 sn_199 262971438.706073
Csub_19_199 sn_19 sn_199 4.006702611535994e-20
Rsub_19_47 sn_19 sn_47 14361157.38229867
Csub_19_47 sn_19 sn_47 7.336792726202627e-19
Rsub_19_149 sn_19 sn_149 644068436.1858032
Csub_19_149 sn_19 sn_149 1.635926077146e-20
Rsub_19_110 sn_19 sn_110 288946924.1844633
Csub_19_110 sn_19 sn_110 3.646511736357341e-20
Rsub_19_76 sn_19 sn_76 1418199475.696403
Rsub_19_201 sn_19 sn_201 195987798.7572887
Csub_19_201 sn_19 sn_201 5.376091557249635e-20
Rsub_19_103 sn_19 sn_103 182752228.3350855
Csub_19_103 sn_19 sn_103 5.76544734814988e-20
Rsub_19_100 sn_19 sn_100 4468954155.172953
Rsub_19_43 sn_19 sn_43 82385317.68116578
Csub_19_43 sn_19 sn_43 1.278927337879133e-19
Rsub_19_228 sn_19 sn_228 45013637.95827363
Csub_19_228 sn_19 sn_228 2.34073138278604e-19
Rsub_19_95 sn_19 sn_95 292650101.5011892
Csub_19_95 sn_19 sn_95 3.600368989513981e-20
Rsub_19_51 sn_19 sn_51 453373108.7948203
Csub_19_51 sn_19 sn_51 2.324020392439821e-20
Rsub_19_108 sn_19 sn_108 178348690.0463082
Csub_19_108 sn_19 sn_108 5.907799771051977e-20
Rsub_19_23 sn_19 sn_23 243260727.5517098
Csub_19_23 sn_19 sn_23 4.331354102355163e-20
Rsub_19_178 sn_19 sn_178 320180359.6381477
Csub_19_178 sn_19 sn_178 3.290796323090468e-20
Rsub_19_48 sn_19 sn_48 28037673.36903455
Csub_19_48 sn_19 sn_48 3.757973553492757e-19
Rsub_19_215 sn_19 sn_215 25046819.30988277
Csub_19_215 sn_19 sn_215 4.206715180826414e-19
Rsub_19_80 sn_19 sn_80 82310263.47886226
Csub_19_80 sn_19 sn_80 1.280093521379121e-19
Rsub_19_65 sn_19 sn_65 376803451.4100666
Csub_19_65 sn_19 sn_65 2.796281048594586e-20
Rsub_19_30 sn_19 sn_30 3593263.513498209
Csub_19_30 sn_19 sn_30 2.932288005777858e-18
Rsub_19_197 sn_19 sn_197 121438528.1782306
Csub_19_197 sn_19 sn_197 8.676392624559825e-20
Rsub_19_192 sn_19 sn_192 4465260.144560585
Csub_19_192 sn_19 sn_192 2.359657256490455e-18
Rsub_19_25 sn_19 sn_25 161776013.1992358
Csub_19_25 sn_19 sn_25 6.513007270894826e-20
Rsub_19_214 sn_19 sn_214 62852625.81278117
Csub_19_214 sn_19 sn_214 1.67637920707004e-19
Rsub_19_81 sn_19 sn_81 160656021.2061543
Csub_19_81 sn_19 sn_81 6.558411831144225e-20
Rsub_19_154 sn_19 sn_154 20584647.46692955
Csub_19_154 sn_19 sn_154 5.118612557809156e-19
Rsub_19_44 sn_19 sn_44 810029.6443625354
Csub_19_44 sn_19 sn_44 1.300752827450141e-17
Rsub_19_211 sn_19 sn_211 313141268.0360841
Csub_19_211 sn_19 sn_211 3.364770018436489e-20
Rsub_19_202 sn_19 sn_202 40465813.26907525
Csub_19_202 sn_19 sn_202 2.603798775071742e-19
Rsub_19_35 sn_19 sn_35 33341117.0782107
Csub_19_35 sn_19 sn_35 3.16020710329345e-19
Rsub_19_128 sn_19 sn_128 12719823.10086215
Csub_19_128 sn_19 sn_128 8.283514179938425e-19
Rsub_19_181 sn_19 sn_181 5323929.362647668
Csub_19_181 sn_19 sn_181 1.979080259057016e-18
Rsub_19_226 sn_19 sn_226 11743597.15789296
Csub_19_226 sn_19 sn_226 8.972109108109477e-19
Rsub_19_68 sn_19 sn_68 265082373.2421656
Csub_19_68 sn_19 sn_68 3.974795975062595e-20
Rsub_19_155 sn_19 sn_155 245558.7771973257
Csub_19_155 sn_19 sn_155 4.290819339665921e-17
Rsub_19_146 sn_19 sn_146 3867927.481722318
Csub_19_146 sn_19 sn_146 2.724064386423888e-18
Rsub_19_67 sn_19 sn_67 221135349.6825317
Csub_19_67 sn_19 sn_67 4.764721478206213e-20
Rsub_19_138 sn_19 sn_138 52736139.46618982
Csub_19_138 sn_19 sn_138 1.997962613282519e-19
Rsub_19_208 sn_19 sn_208 30105534.0210639
Csub_19_208 sn_19 sn_208 3.499849394751793e-19
Rsub_19_41 sn_19 sn_41 102928648.0000205
Csub_19_41 sn_19 sn_41 1.023668697390051e-19
Rsub_19_115 sn_19 sn_115 52876700.40970189
Csub_19_115 sn_19 sn_115 1.992651474201433e-19
Rsub_19_183 sn_19 sn_183 86583384.72385845
Csub_19_183 sn_19 sn_183 1.216917487787541e-19
Rsub_19_134 sn_19 sn_134 31523822.60020513
Csub_19_134 sn_19 sn_134 3.3423876399309e-19
Rsub_19_213 sn_19 sn_213 129743437.7179848
Csub_19_213 sn_19 sn_213 8.121014586597045e-20
Rsub_19_46 sn_19 sn_46 5684593.541234042
Csub_19_46 sn_19 sn_46 1.853515722065625e-18
Rsub_19_29 sn_19 sn_29 865657553.8925827
Csub_19_29 sn_19 sn_29 1.217165316105755e-20
Rsub_19_205 sn_19 sn_205 1483420772.404738
Rsub_19_224 sn_19 sn_224 12005823.65637971
Csub_19_224 sn_19 sn_224 8.776143814698689e-19
Rsub_19_39 sn_19 sn_39 157146260.9864972
Csub_19_39 sn_19 sn_39 6.704889722533933e-20
Rsub_19_206 sn_19 sn_206 160649631.5748303
Csub_19_206 sn_19 sn_206 6.558672683492663e-20
Rsub_19_156 sn_19 sn_156 16529616.97009311
Csub_19_156 sn_19 sn_156 6.374305902728157e-19
Rsub_19_203 sn_19 sn_203 55645622.9322359
Csub_19_203 sn_19 sn_203 1.89349726843046e-19
Rsub_19_36 sn_19 sn_36 3102400.235048794
Csub_19_36 sn_19 sn_36 3.39623604433626e-18
Rsub_19_45 sn_19 sn_45 4784960.413602733
Csub_19_45 sn_19 sn_45 2.202000140330687e-18
Rsub_19_212 sn_19 sn_212 23555168.57985535
Csub_19_212 sn_19 sn_212 4.473108934249328e-19
Rsub_19_216 sn_19 sn_216 799717.7269661126
Csub_19_216 sn_19 sn_216 1.317525315113651e-17
Rsub_19_49 sn_19 sn_49 169030632.1274048
Csub_19_49 sn_19 sn_49 6.233475772774876e-20
Rsub_19_137 sn_19 sn_137 6726518.754586872
Csub_19_137 sn_19 sn_137 1.566409592635876e-18
Rsub_19_151 sn_19 sn_151 43361407.01678573
Csub_19_151 sn_19 sn_151 2.429921957594965e-19
Rsub_19_112 sn_19 sn_112 5300792.110729974
Csub_19_112 sn_19 sn_112 1.987718680931069e-18
Rsub_19_191 sn_19 sn_191 22031625.01225378
Csub_19_191 sn_19 sn_191 4.782435928520802e-19
Rsub_19_33 sn_19 sn_33 8563375.473804804
Csub_19_33 sn_19 sn_33 1.230412415578518e-18
Rsub_19_200 sn_19 sn_200 652353731.8791069
Csub_19_200 sn_19 sn_200 1.615148804603237e-20
Rsub_19_107 sn_19 sn_107 14373648.79641776
Csub_19_107 sn_19 sn_107 7.330416689223638e-19
Rsub_19_139 sn_19 sn_139 11531440.50480318
Csub_19_139 sn_19 sn_139 9.137178913459469e-19
Rsub_19_218 sn_19 sn_218 20297801.30715099
Csub_19_218 sn_19 sn_218 5.190948193249856e-19
Rsub_19_189 sn_19 sn_189 93821525.08118115
Csub_19_189 sn_19 sn_189 1.123034771936725e-19
Rsub_19_22 sn_19 sn_22 171312641.024688
Csub_19_22 sn_19 sn_22 6.15044134467087e-20
Rsub_19_31 sn_19 sn_31 2191645.28445413
Csub_19_31 sn_19 sn_31 4.807567892928581e-18
Rsub_19_198 sn_19 sn_198 34240253.9253236
Csub_19_198 sn_19 sn_198 3.077221192696054e-19
Rsub_19_74 sn_19 sn_74 77990240.19611497
Csub_19_74 sn_19 sn_74 1.351000263075849e-19
Rsub_19_222 sn_19 sn_222 1500237.746158208
Csub_19_222 sn_19 sn_222 7.023209174153704e-18
Rsub_19_185 sn_19 sn_185 29046853.70152988
Csub_19_185 sn_19 sn_185 3.627409567486152e-19
Rsub_19_175 sn_19 sn_175 93268797.01554765
Csub_19_175 sn_19 sn_175 1.129690082790882e-19
Rsub_19_54 sn_19 sn_54 325785385.6116067
Csub_19_54 sn_19 sn_54 3.234179299494834e-20
Rsub_19_221 sn_19 sn_221 83047772.00738236
Csub_19_221 sn_19 sn_221 1.268725607869815e-19
Rsub_19_69 sn_19 sn_69 318492949.0492695
Csub_19_69 sn_19 sn_69 3.308231323073986e-20
Rsub_19_227 sn_19 sn_227 19217436.85675733
Csub_19_227 sn_19 sn_227 5.482772536611776e-19
Rsub_19_79 sn_19 sn_79 30542854.1888715
Csub_19_79 sn_19 sn_79 3.449737682364028e-19
Rsub_19_158 sn_19 sn_158 136253.5853725833
Csub_19_158 sn_19 sn_158 7.7329954095653e-17
Rsub_19_84 sn_19 sn_84 30252864.5260457
Csub_19_84 sn_19 sn_84 3.482805237553221e-19
Rsub_19_177 sn_19 sn_177 12802770.13041122
Csub_19_177 sn_19 sn_177 8.229846662014209e-19
Rsub_19_53 sn_19 sn_53 18376992.53950485
Csub_19_53 sn_19 sn_53 5.733518952886237e-19
Rsub_19_220 sn_19 sn_220 84120082.56741215
Csub_19_220 sn_19 sn_220 1.252552681909968e-19
Rsub_19_132 sn_19 sn_132 3086238.864302779
Csub_19_132 sn_19 sn_132 3.414020743533837e-18
Rsub_19_210 sn_19 sn_210 1482456.783086682
Csub_19_210 sn_19 sn_210 7.107447328273254e-18
Rsub_19_52 sn_19 sn_52 1906067.335280352
Csub_19_52 sn_19 sn_52 5.527865310529679e-18
Rsub_19_219 sn_19 sn_219 92187578.68380623
Csub_19_219 sn_19 sn_219 1.142939607771785e-19
Rsub_19_209 sn_19 sn_209 70523940.61160225
Csub_19_209 sn_19 sn_209 1.494029319810384e-19
Rsub_19_42 sn_19 sn_42 623440967.2543867
Csub_19_42 sn_19 sn_42 1.690053117399764e-20
Rsub_19_130 sn_19 sn_130 53991243.12326577
Csub_19_130 sn_19 sn_130 1.951517115131888e-19
Rsub_19_125 sn_19 sn_125 8844221.420527883
Csub_19_125 sn_19 sn_125 1.191340989923013e-18
Rsub_19_204 sn_19 sn_204 5432452920.053095
Rsub_19_37 sn_19 sn_37 86369576.02562447
Csub_19_37 sn_19 sn_37 1.219929978480385e-19
Rsub_19_87 sn_19 sn_87 119035727.0509594
Csub_19_87 sn_19 sn_87 8.851530345775363e-20
Rsub_19_166 sn_19 sn_166 55008602.84403688
Csub_19_166 sn_19 sn_166 1.915424671319786e-19
Rsub_19_141 sn_19 sn_141 1908748.01558258
Csub_19_141 sn_19 sn_141 5.520101876315036e-18
Rsub_19_62 sn_19 sn_62 132443447.8961282
Csub_19_62 sn_19 sn_62 7.955458476506502e-20
Rsub_19_229 sn_19 sn_229 51287821.76307905
Csub_19_229 sn_19 sn_229 2.054383114748496e-19
Rsub_19_93 sn_19 sn_93 22880689.79547829
Csub_19_93 sn_19 sn_93 4.604967593377466e-19
Rsub_19_172 sn_19 sn_172 265610757.8523854
Csub_19_172 sn_19 sn_172 3.966888836665912e-20
Rsub_19_83 sn_19 sn_83 130826462.079085
Csub_19_83 sn_19 sn_83 8.053786164346986e-20
Rsub_19_77 sn_19 sn_77 23133162.19639725
Csub_19_77 sn_19 sn_77 4.554709560576611e-19
Rsub_19_190 sn_19 sn_190 129143.5875719579
Csub_19_190 sn_19 sn_190 8.158735327341859e-17
Rsub_19_217 sn_19 sn_217 57062806.04781616
Csub_19_217 sn_19 sn_217 1.846471323790296e-19
Rsub_19_118 sn_19 sn_118 15182742.14403548
Csub_19_118 sn_19 sn_118 6.939776360734181e-19
Rsub_19_135 sn_19 sn_135 3103305.906655083
Csub_19_135 sn_19 sn_135 3.395244883733299e-18
Rsub_19_133 sn_19 sn_133 2150463964.999894
Rsub_19_159 sn_19 sn_159 35083158.77948496
Csub_19_159 sn_19 sn_159 3.003288149866157e-19
Rsub_19_117 sn_19 sn_117 111028989.4835752
Csub_19_117 sn_19 sn_117 9.489849048647509e-20
Rsub_19_114 sn_19 sn_114 228454433.0680259
Csub_19_114 sn_19 sn_114 4.612072245975021e-20
Rsub_19_86 sn_19 sn_86 18104254.39748462
Csub_19_86 sn_19 sn_86 5.819893639858447e-19
Rsub_19_176 sn_19 sn_176 101520245.3583632
Csub_19_176 sn_19 sn_176 1.037870177030853e-19
Rsub_19_160 sn_19 sn_160 21395286.99070166
Csub_19_160 sn_19 sn_160 4.924675002868216e-19
Rsub_19_170 sn_19 sn_170 59809275.70668033
Csub_19_170 sn_19 sn_170 1.761680504860744e-19
Rsub_19_153 sn_19 sn_153 161185061.0557877
Csub_19_153 sn_19 sn_153 6.536885883353185e-20
Rsub_19_58 sn_19 sn_58 662432315.8995378
Csub_19_58 sn_19 sn_58 1.590575104706686e-20
Rsub_19_225 sn_19 sn_225 1257850461.743843
Rsub_19_223 sn_19 sn_223 142820635.6297852
Csub_19_223 sn_19 sn_223 7.377423756565766e-20
Rsub_19_56 sn_19 sn_56 162832220.9303758
Csub_19_56 sn_19 sn_56 6.47076078802316e-20
Rsub_19_165 sn_19 sn_165 50065053.30994698
Csub_19_165 sn_19 sn_165 2.104558530478305e-19
Rsub_19_169 sn_19 sn_169 27651976.21246925
Csub_19_169 sn_19 sn_169 3.810390773256462e-19
Rsub_19_96 sn_19 sn_96 62385796.59196941
Csub_19_96 sn_19 sn_96 1.688923453385271e-19
Rsub_19_195 sn_19 sn_195 30696378.19862689
Csub_19_195 sn_19 sn_195 3.43248426053772e-19
Rsub_19_164 sn_19 sn_164 45102406.40941677
Csub_19_164 sn_19 sn_164 2.336124464531925e-19
Rsub_19_171 sn_19 sn_171 22003797.92803622
Csub_19_171 sn_19 sn_171 4.788484032024717e-19
Rsub_19_98 sn_19 sn_98 384168865.4993877
Csub_19_98 sn_19 sn_98 2.742669812279932e-20
Rsub_19_140 sn_19 sn_140 4737013.101153112
Csub_19_140 sn_19 sn_140 2.224288444476783e-18
Rsub_19_63 sn_19 sn_63 162496867.1557048
Csub_19_63 sn_19 sn_63 6.48411485504759e-20
Rsub_19_150 sn_19 sn_150 47943379.69454904
Csub_19_150 sn_19 sn_150 2.197693105775761e-19
Rsub_19_20 sn_19 sn_20 1227430206.299118
Rsub_19_207 sn_19 sn_207 43240008.96391195
Csub_19_207 sn_19 sn_207 2.436744060581425e-19
Rsub_19_186 sn_19 sn_186 99373742.21471654
Csub_19_186 sn_19 sn_186 1.060288489434548e-19
Rsub_19_120 sn_19 sn_120 85342042.96555395
Csub_19_120 sn_19 sn_120 1.234618147878505e-19
Rsub_19_179 sn_19 sn_179 636023.428127183
Csub_19_179 sn_19 sn_179 1.65661877161592e-17
Rsub_19_131 sn_19 sn_131 4382341.687289336
Csub_19_131 sn_19 sn_131 2.404304423087389e-18
Rsub_19_174 sn_19 sn_174 50227335.51750685
Csub_19_174 sn_19 sn_174 2.097758798803389e-19
Rsub_19_123 sn_19 sn_123 91163395.0444302
Csub_19_123 sn_19 sn_123 1.155780069083084e-19
Rsub_19_27 sn_19 sn_27 261771929.6973154
Csub_19_27 sn_19 sn_27 4.025062394739285e-20
Rsub_19_101 sn_19 sn_101 113360290.0650162
Csub_19_101 sn_19 sn_101 9.29468643401225e-20
Rsub_19_152 sn_19 sn_152 76976255.92490147
Csub_19_152 sn_19 sn_152 1.368796569231616e-19
Rsub_19_66 sn_19 sn_66 66671752.88171501
Csub_19_66 sn_19 sn_66 1.580351955186058e-19
Rsub_19_71 sn_19 sn_71 167222029.23968
Csub_19_71 sn_19 sn_71 6.300894415727978e-20
Rsub_19_82 sn_19 sn_82 233688323.5608342
Csub_19_82 sn_19 sn_82 4.508776194582577e-20
Rsub_19_180 sn_19 sn_180 61300607.92396795
Csub_19_180 sn_19 sn_180 1.718822024619814e-19
Rsub_19_148 sn_19 sn_148 66491047.10806132
Csub_19_148 sn_19 sn_148 1.584646950303865e-19
Rsub_19_145 sn_19 sn_145 221237486.4446619
Csub_19_145 sn_19 sn_145 4.762521791199924e-20
Rsub_19_157 sn_19 sn_157 61970178.35192199
Csub_19_157 sn_19 sn_157 1.700250633844306e-19
Rsub_19_122 sn_19 sn_122 112724832.9642518
Csub_19_122 sn_19 sn_122 9.34708282563738e-20
Rsub_19_182 sn_19 sn_182 421827815.1714767
Csub_19_182 sn_19 sn_182 2.497816199708601e-20
Rsub_19_163 sn_19 sn_163 248687437.8446901
Csub_19_163 sn_19 sn_163 4.236837852988068e-20
Rsub_19_34 sn_19 sn_34 869240850.4382952
Csub_19_34 sn_19 sn_34 1.212147760533483e-20
Rsub_19_168 sn_19 sn_168 1144289.939732587
Csub_19_168 sn_19 sn_168 9.207879171508146e-18
Rsub_19_64 sn_19 sn_64 196715728.3850967
Csub_19_64 sn_19 sn_64 5.356197792991651e-20
Rsub_19_167 sn_19 sn_167 462366921.1321384
Csub_19_167 sn_19 sn_167 2.278814296756063e-20
Rsub_19_162 sn_19 sn_162 3131221.011471704
Csub_19_162 sn_19 sn_162 3.364975983371341e-18
Rsub_19_142 sn_19 sn_142 121471057.9196671
Csub_19_142 sn_19 sn_142 8.674069101462942e-20
Rsub_19_75 sn_19 sn_75 471640667.1862848
Csub_19_75 sn_19 sn_75 2.234006572225543e-20
Rsub_19_188 sn_19 sn_188 285725709.2679431
Csub_19_188 sn_19 sn_188 3.687621785671822e-20
Rsub_19_78 sn_19 sn_78 683944945.4374135
Csub_19_78 sn_19 sn_78 1.54054556182025e-20
Rsub_19_111 sn_19 sn_111 150896273.4555046
Csub_19_111 sn_19 sn_111 6.982600206715468e-20
Rsub_19_89 sn_19 sn_89 163726836.2603875
Csub_19_89 sn_19 sn_89 6.435404080900342e-20
Rsub_19_104 sn_19 sn_104 682075920.7939131
Csub_19_104 sn_19 sn_104 1.544766965232535e-20
Rsub_19_116 sn_19 sn_116 46301422.09749585
Csub_19_116 sn_19 sn_116 2.275628485026565e-19
Rsub_19_136 sn_19 sn_136 140100069.8588918
Csub_19_136 sn_19 sn_136 7.520683974563539e-20
Rsub_19_126 sn_19 sn_126 65617693.99188074
Csub_19_126 sn_19 sn_126 1.605738157079056e-19
Rsub_19_97 sn_19 sn_97 273688867.1419523
Csub_19_97 sn_19 sn_97 3.849803469267575e-20
Rsub_19_127 sn_19 sn_127 50037989.8683975
Csub_19_127 sn_19 sn_127 2.105696797561512e-19
Rsub_19_129 sn_19 sn_129 340191514.0601167
Csub_19_129 sn_19 sn_129 3.097221143607966e-20
Rsub_19_184 sn_19 sn_184 11613599.45457027
Csub_19_184 sn_19 sn_184 9.07253908957882e-19
Rsub_19_61 sn_19 sn_61 160307717.9945855
Csub_19_61 sn_19 sn_61 6.57266140023644e-20
Rsub_19_109 sn_19 sn_109 107468349.6173519
Csub_19_109 sn_19 sn_109 9.804266595463535e-20
Rsub_222_225 sn_222 sn_225 832567.1531362503
Csub_222_225 sn_222 sn_225 1.265541579743982e-17
Rsub_222_228 sn_222 sn_228 1025076.814400386
Csub_222_228 sn_222 sn_228 1.027872580299582e-17
Rsub_222_230 sn_222 0 4353.567837454038
Csub_222_230 sn_222 0 2.420195089550213e-15
Rsub_222_229 sn_222 sn_229 148585.2904896008
Csub_222_229 sn_222 sn_229 7.091202276827956e-17
Rsub_222_224 sn_222 sn_224 212122.7373760774
Csub_222_224 sn_222 sn_224 4.967163649010253e-17
Rsub_222_226 sn_222 sn_226 45654.25351094869
Csub_222_226 sn_222 sn_226 2.307886492920789e-16
Rsub_222_227 sn_222 sn_227 23449.64733523253
Csub_222_227 sn_222 sn_227 4.49323751082567e-16
Rsub_158_167 sn_158 sn_167 6377511.816852137
Csub_158_167 sn_158 sn_167 1.652130768991767e-18
Rsub_158_209 sn_158 sn_209 6428126.990001757
Csub_158_209 sn_158 sn_209 1.639121865298918e-18
Rsub_158_194 sn_158 sn_194 4497051.421532134
Csub_158_194 sn_158 sn_194 2.342975989062684e-18
Rsub_158_170 sn_158 sn_170 7123043.520188648
Csub_158_170 sn_158 sn_170 1.479210883994564e-18
Rsub_158_159 sn_158 sn_159 3326333.633028489
Csub_158_159 sn_158 sn_159 3.167596718984851e-18
Rsub_158_163 sn_158 sn_163 6250973.883978086
Csub_158_163 sn_158 sn_163 1.685574711683908e-18
Rsub_158_214 sn_158 sn_214 4113557.335482269
Csub_158_214 sn_158 sn_214 2.561404313328895e-18
Rsub_158_199 sn_158 sn_199 11115910.04975368
Csub_158_199 sn_158 sn_199 9.478741241220721e-19
Rsub_158_176 sn_158 sn_176 712042.4842839018
Csub_158_176 sn_158 sn_176 1.479754893112382e-17
Rsub_158_191 sn_158 sn_191 787850.1214333589
Csub_158_191 sn_158 sn_191 1.337371565426768e-17
Rsub_158_196 sn_158 sn_196 6329238.453740228
Csub_158_196 sn_158 sn_196 1.664731638607094e-18
Rsub_158_179 sn_158 sn_179 9385896.242070571
Csub_158_179 sn_158 sn_179 1.122586829268593e-18
Rsub_158_197 sn_158 sn_197 7849378.480184379
Csub_158_197 sn_158 sn_197 1.342333476316523e-18
Rsub_158_227 sn_158 sn_227 1387096.934629753
Csub_158_227 sn_158 sn_227 7.596068623021234e-18
Rsub_158_185 sn_158 sn_185 1172739.256882563
Csub_158_185 sn_158 sn_185 8.98450652213915e-18
Rsub_158_224 sn_158 sn_224 360589.7023338535
Csub_158_224 sn_158 sn_224 2.922014531761297e-17
Rsub_158_211 sn_158 sn_211 6409303.887299053
Csub_158_211 sn_158 sn_211 1.643935704641738e-18
Rsub_158_228 sn_158 sn_228 9421309.586428586
Csub_158_228 sn_158 sn_228 1.118367187233485e-18
Rsub_158_223 sn_158 sn_223 3019143.828331321
Csub_158_223 sn_158 sn_223 3.489891208016251e-18
Rsub_158_175 sn_158 sn_175 1243015.223661315
Csub_158_175 sn_158 sn_175 8.476552259106428e-18
Rsub_158_180 sn_158 sn_180 1371260.802736742
Csub_158_180 sn_158 sn_180 7.683792522327953e-18
Rsub_158_212 sn_158 sn_212 476736.5347157327
Csub_158_212 sn_158 sn_212 2.210127132067332e-17
Rsub_158_168 sn_158 sn_168 254652.9731621388
Csub_158_168 sn_158 sn_168 4.137585110982141e-17
Rsub_158_177 sn_158 sn_177 233764.7749818168
Csub_158_177 sn_158 sn_177 4.507301625340932e-17
Rsub_158_215 sn_158 sn_215 777197.4839014339
Csub_158_215 sn_158 sn_215 1.355702214749613e-17
Rsub_158_178 sn_158 sn_178 1608874.357757887
Csub_158_178 sn_158 sn_178 6.548978452806936e-18
Rsub_158_222 sn_158 sn_222 100729.4094357422
Csub_158_222 sn_158 sn_222 1.046018591913962e-16
Rsub_158_195 sn_158 sn_195 770663.5655320822
Csub_158_195 sn_158 sn_195 1.367196267408255e-17
Rsub_158_226 sn_158 sn_226 518366.1900021667
Csub_158_226 sn_158 sn_226 2.032633243727945e-17
Rsub_158_230 sn_158 0 22196.3391381989
Csub_158_230 sn_158 0 4.746946528717066e-16
Rsub_158_162 sn_158 sn_162 65702.42930293125
Csub_158_162 sn_158 sn_162 1.603667263755181e-16
Rsub_158_207 sn_158 sn_207 890064.2433686611
Csub_158_207 sn_158 sn_207 1.183789100700435e-17
Rsub_158_190 sn_158 sn_190 3692.241610781108
Csub_158_190 sn_158 sn_190 2.853682021096384e-15
Rsub_158_184 sn_158 sn_184 16824.13114696931
Csub_158_184 sn_158 sn_184 6.2627207373666e-16
Rsub_158_221 sn_158 sn_221 3799978.68799431
Csub_158_221 sn_158 sn_221 2.772774367266604e-18
Rsub_158_216 sn_158 sn_216 15567.3123530907
Csub_158_216 sn_158 sn_216 6.768338209734779e-16
Rsub_158_169 sn_158 sn_169 221308.6009326216
Csub_158_169 sn_158 sn_169 4.760991420047827e-17
Rsub_158_206 sn_158 sn_206 1042664.535543851
Csub_158_206 sn_158 sn_206 1.010534370648197e-17
Rsub_158_186 sn_158 sn_186 1497831.200035045
Csub_158_186 sn_158 sn_186 7.034493273997413e-18
Rsub_158_218 sn_158 sn_218 653039.6721123956
Csub_158_218 sn_158 sn_218 1.61345228355691e-17
Rsub_158_181 sn_158 sn_181 218947.8621125296
Csub_158_181 sn_158 sn_181 4.812325363932858e-17
Rsub_158_171 sn_158 sn_171 139731.3748953006
Csub_158_171 sn_158 sn_171 7.540528038262622e-17
Rsub_158_208 sn_158 sn_208 291610.1022852308
Csub_158_208 sn_158 sn_208 3.613209357172412e-17
Rsub_158_160 sn_158 sn_160 346087.6742416842
Csub_158_160 sn_158 sn_160 3.044454999825285e-17
Rsub_158_192 sn_158 sn_192 4340714.849166376
Csub_158_192 sn_158 sn_192 2.427361360595596e-18
Rsub_158_166 sn_158 sn_166 768781.6855802677
Csub_158_166 sn_158 sn_166 1.370542990273914e-17
Rsub_158_203 sn_158 sn_203 1757955.95887469
Csub_158_203 sn_158 sn_203 5.993599241800494e-18
Rsub_158_210 sn_158 sn_210 228853.9971054792
Csub_158_210 sn_158 sn_210 4.604019870963284e-17
Rsub_158_188 sn_158 sn_188 6289343.939543824
Csub_158_188 sn_158 sn_188 1.675291350498829e-18
Rsub_158_174 sn_158 sn_174 20503199.01478497
Csub_158_174 sn_158 sn_174 5.138946119886993e-19
Rsub_158_164 sn_158 sn_164 407934.9360845293
Csub_158_164 sn_158 sn_164 2.582883340015454e-17
Rsub_158_165 sn_158 sn_165 881162.6629689639
Csub_158_165 sn_158 sn_165 1.195747839193354e-17
Rsub_158_182 sn_158 sn_182 15281630.67069454
Csub_158_182 sn_158 sn_182 6.894868570823226e-19
Rsub_158_219 sn_158 sn_219 530095.2600998182
Csub_158_219 sn_158 sn_219 1.987658501275027e-17
Rsub_158_213 sn_158 sn_213 1966419.474362426
Csub_158_213 sn_158 sn_213 5.35820746265049e-18
Rsub_116_228 sn_116 sn_228 51400850.0290742
Csub_116_228 sn_116 sn_228 2.049865614337152e-19
Rsub_116_185 sn_116 sn_185 190245.3822081472
Csub_116_185 sn_116 sn_185 5.538364915844343e-17
Rsub_116_153 sn_116 sn_153 3203614.770645822
Csub_116_153 sn_116 sn_153 3.288935860445523e-18
Rsub_116_213 sn_116 sn_213 5862461.39232144
Csub_116_213 sn_116 sn_213 1.797279810836882e-18
Rsub_116_186 sn_116 sn_186 26731327.05781215
Csub_116_186 sn_116 sn_186 3.941623803203868e-19
Rsub_116_165 sn_116 sn_165 12135117.64332689
Csub_116_165 sn_116 sn_165 8.682638118489129e-19
Rsub_116_159 sn_116 sn_159 5595201.757148725
Csub_116_159 sn_116 sn_159 1.883128430314069e-18
Rsub_116_188 sn_116 sn_188 158471396.1754638
Csub_116_188 sn_116 sn_188 6.648823545773347e-20
Rsub_116_156 sn_116 sn_156 8883834.640862601
Csub_116_156 sn_116 sn_156 1.186028773404424e-18
Rsub_116_221 sn_116 sn_221 4193249.866966431
Csub_116_221 sn_116 sn_221 2.512724935672037e-18
Rsub_116_174 sn_116 sn_174 2324031.007824305
Csub_116_174 sn_116 sn_174 4.533710379404092e-18
Rsub_116_130 sn_116 sn_130 6605722.582449982
Csub_116_130 sn_116 sn_130 1.595053890125998e-18
Rsub_116_209 sn_116 sn_209 42992541.69689896
Csub_116_209 sn_116 sn_209 2.450770083916671e-19
Rsub_116_187 sn_116 sn_187 21496270.84844948
Csub_116_187 sn_116 sn_187 4.901540167833341e-19
Rsub_116_169 sn_116 sn_169 18400983.40120386
Csub_116_169 sn_116 sn_169 5.726043696958428e-19
Rsub_116_135 sn_116 sn_135 4214204.836024029
Csub_116_135 sn_116 sn_135 2.500230509006498e-18
Rsub_116_166 sn_116 sn_166 8072880.600077758
Csub_116_166 sn_116 sn_166 1.305170239000997e-18
Rsub_116_154 sn_116 sn_154 367042.2379196969
Csub_116_154 sn_116 sn_154 2.870646049334306e-17
Rsub_116_191 sn_116 sn_191 36801966.80240771
Csub_116_191 sn_116 sn_191 2.863021848479214e-19
Rsub_116_148 sn_116 sn_148 11393412.04844422
Csub_116_148 sn_116 sn_148 9.247873646129362e-19
Rsub_116_171 sn_116 sn_171 1979072.589410981
Csub_116_171 sn_116 sn_171 5.323949994863963e-18
Rsub_116_208 sn_116 sn_208 84865.46051568571
Csub_116_208 sn_116 sn_208 1.241551443685684e-16
Rsub_116_226 sn_116 sn_226 2289691.032892227
Csub_116_226 sn_116 sn_226 4.601705361496228e-18
Rsub_116_158 sn_116 sn_158 418824.2839721891
Csub_116_158 sn_116 sn_158 2.515728888091324e-17
Rsub_116_203 sn_116 sn_203 4907253.947120659
Csub_116_203 sn_116 sn_203 2.147124158596337e-18
Rsub_116_146 sn_116 sn_146 505496.4629655485
Csub_116_146 sn_116 sn_146 2.084383229986735e-17
Rsub_116_183 sn_116 sn_183 18799720.60171149
Csub_116_183 sn_116 sn_183 5.604595794509191e-19
Rsub_116_198 sn_116 sn_198 6647603.4662342
Csub_116_198 sn_116 sn_198 1.585004815005732e-18
Rsub_116_164 sn_116 sn_164 63511.79380627663
Csub_116_164 sn_116 sn_164 1.658980619311168e-16
Rsub_116_155 sn_116 sn_155 289085.1304605601
Csub_116_155 sn_116 sn_155 3.644768406262768e-17
Rsub_116_224 sn_116 sn_224 13815.76210292335
Csub_116_224 sn_116 sn_224 7.626422215246838e-16
Rsub_116_190 sn_116 sn_190 508886.8069498801
Csub_116_190 sn_116 sn_190 2.070496495160216e-17
Rsub_116_162 sn_116 sn_162 20356.82397108278
Csub_116_162 sn_116 sn_162 5.175897535488471e-16
Rsub_116_125 sn_116 sn_125 3523264.435556555
Csub_116_125 sn_116 sn_125 2.990545755208294e-18
Rsub_116_202 sn_116 sn_202 16878320.08228416
Csub_116_202 sn_116 sn_202 6.242613868479313e-19
Rsub_116_123 sn_116 sn_123 556581.7136259009
Csub_116_123 sn_116 sn_123 1.893070369414249e-17
Rsub_116_160 sn_116 sn_160 2268126.783769491
Csub_116_160 sn_116 sn_160 4.645456143645989e-18
Rsub_116_118 sn_116 sn_118 18548663.84583631
Csub_116_118 sn_116 sn_118 5.680454177078186e-19
Rsub_116_197 sn_116 sn_197 4116449.259439012
Csub_116_197 sn_116 sn_197 2.559604853155875e-18
Rsub_116_184 sn_116 sn_184 228733.0818166115
Csub_116_184 sn_116 sn_184 4.606453696399591e-17
Rsub_116_230 sn_116 0 226861.7447160806
Csub_116_230 sn_116 0 4.644451410446701e-17
Rsub_116_216 sn_116 sn_216 1454465.23679341
Csub_116_216 sn_116 sn_216 7.24423192503334e-18
Rsub_116_137 sn_116 sn_137 5706148.757344391
Csub_116_137 sn_116 sn_137 1.846513988733378e-18
Rsub_116_222 sn_116 sn_222 3778326.279765116
Csub_116_222 sn_116 sn_222 2.788664271441643e-18
Rsub_116_210 sn_116 sn_210 3972622.296343014
Csub_116_210 sn_116 sn_210 2.652274169615705e-18
Rsub_116_131 sn_116 sn_131 15141793.19039087
Csub_116_131 sn_116 sn_131 6.958544057329059e-19
Rsub_116_177 sn_116 sn_177 5466988.405905313
Csub_116_177 sn_116 sn_177 1.927292088428199e-18
Rsub_116_139 sn_116 sn_139 4457821.225743547
Csub_116_139 sn_116 sn_139 2.363594897297066e-18
Rsub_116_218 sn_116 sn_218 4392413.430811243
Csub_116_218 sn_116 sn_218 2.398791386147819e-18
Rsub_116_138 sn_116 sn_138 18090854.4674757
Csub_116_138 sn_116 sn_138 5.824204446049143e-19
Rsub_116_217 sn_116 sn_217 18799720.60171149
Csub_116_217 sn_116 sn_217 5.604595794509191e-19
Rsub_116_141 sn_116 sn_141 3455319.008535324
Csub_116_141 sn_116 sn_141 3.04935187639775e-18
Rsub_116_196 sn_116 sn_196 17426292.46662966
Csub_116_196 sn_116 sn_196 6.046313937635765e-19
Rsub_116_128 sn_116 sn_128 18400983.40120386
Csub_116_128 sn_116 sn_128 5.726043696958428e-19
Rsub_116_207 sn_116 sn_207 1510379.340488909
Csub_116_207 sn_116 sn_207 6.976051128201572e-18
Rsub_47_172 sn_47 sn_172 8094673.12670661
Csub_47_172 sn_47 sn_172 1.301656452002635e-18
Rsub_47_103 sn_47 sn_103 32648118.65974576
Csub_47_103 sn_47 sn_103 3.227286574163673e-19
Rsub_47_189 sn_47 sn_189 26747946.6134109
Csub_47_189 sn_47 sn_189 3.939174716666742e-19
Rsub_47_196 sn_47 sn_196 25574019.01453901
Csub_47_196 sn_47 sn_196 4.119995178012472e-19
Rsub_47_65 sn_47 sn_65 32164800.84094864
Csub_47_65 sn_47 sn_65 3.275780737562076e-19
Rsub_47_91 sn_47 sn_91 6737045.818944877
Csub_47_91 sn_47 sn_91 1.563961977607594e-18
Rsub_47_156 sn_47 sn_156 24039930.91842871
Csub_47_156 sn_47 sn_156 4.382909226312653e-19
Rsub_47_142 sn_47 sn_142 8482739.849872528
Csub_47_142 sn_47 sn_142 1.242108527280645e-18
Rsub_47_136 sn_47 sn_136 33010607.02384361
Csub_47_136 sn_47 sn_136 3.19184784897154e-19
Rsub_47_85 sn_47 sn_85 15913661.85602344
Csub_47_85 sn_47 sn_85 6.621030154817487e-19
Rsub_47_179 sn_47 sn_179 33010607.02384361
Csub_47_179 sn_47 sn_179 3.19184784897154e-19
Rsub_47_152 sn_47 sn_152 27656755.40024695
Csub_47_152 sn_47 sn_152 3.809732323892166e-19
Rsub_47_184 sn_47 sn_184 20257493.69575235
Csub_47_184 sn_47 sn_184 5.201276949892041e-19
Rsub_47_115 sn_47 sn_115 16172370.29423303
Csub_47_115 sn_47 sn_115 6.515113932301715e-19
Rsub_47_119 sn_47 sn_119 30944014.89135645
Csub_47_119 sn_47 sn_119 3.405015005073935e-19
Rsub_47_66 sn_47 sn_66 9276584.824160216
Csub_47_66 sn_47 sn_66 1.135814925638201e-18
Rsub_47_159 sn_47 sn_159 3277971.773583109
Csub_47_159 sn_47 sn_159 3.214330149863587e-18
Rsub_47_197 sn_47 sn_197 54719474.93892156
Csub_47_197 sn_47 sn_197 1.925545432223341e-19
Rsub_47_148 sn_47 sn_148 7871202.844831619
Csub_47_148 sn_47 sn_148 1.33861160866264e-18
Rsub_47_161 sn_47 sn_161 65827886.92016837
Csub_47_161 sn_47 sn_161 1.600610925732424e-19
Rsub_47_200 sn_47 sn_200 21383614.05202068
Csub_47_200 sn_47 sn_200 4.927363296306003e-19
Rsub_47_191 sn_47 sn_191 28718287.48271369
Csub_47_191 sn_47 sn_191 3.668910797195757e-19
Rsub_47_121 sn_47 sn_121 13619187.5408437
Csub_47_121 sn_47 sn_121 7.736499310719732e-19
Rsub_47_134 sn_47 sn_134 10227849.2280477
Csub_47_134 sn_47 sn_134 1.030175872492913e-18
Rsub_47_211 sn_47 sn_211 29562820.91771873
Csub_47_211 sn_47 sn_211 3.564099492249357e-19
Rsub_47_225 sn_47 sn_225 12238734.87497954
Csub_47_225 sn_47 sn_225 8.609127993915808e-19
Rsub_47_169 sn_47 sn_169 5996589.482554715
Csub_47_169 sn_47 sn_169 1.757079341996438e-18
Rsub_47_140 sn_47 sn_140 7038048.712947473
Csub_47_140 sn_47 sn_140 1.497074534713957e-18
Rsub_47_212 sn_47 sn_212 4305478.418299245
Csub_47_212 sn_47 sn_212 2.447227108942782e-18
Rsub_47_192 sn_47 sn_192 7746794.020199023
Csub_47_192 sn_47 sn_192 1.36010890114764e-18
Rsub_47_170 sn_47 sn_170 1393545.15977804
Csub_47_170 sn_47 sn_170 7.56092002350912e-18
Rsub_47_166 sn_47 sn_166 8768286.911482321
Csub_47_166 sn_47 sn_166 1.201658158383501e-18
Rsub_47_71 sn_47 sn_71 19980906.01136512
Csub_47_71 sn_47 sn_71 5.273276144853922e-19
Rsub_47_165 sn_47 sn_165 11959357.10145159
Csub_47_165 sn_47 sn_165 8.81024240086544e-19
Rsub_47_89 sn_47 sn_89 55751909.50019711
Csub_47_89 sn_47 sn_89 1.889887466938285e-19
Rsub_47_193 sn_47 sn_193 26996239.67764755
Csub_47_193 sn_47 sn_193 3.902944864930221e-19
Rsub_47_178 sn_47 sn_178 31512321.78557252
Csub_47_178 sn_47 sn_178 3.343607485962518e-19
Rsub_47_82 sn_47 sn_82 2534031.232251663
Csub_47_82 sn_47 sn_82 4.157992754046524e-18
Rsub_47_118 sn_47 sn_118 2928352.048620761
Csub_47_118 sn_47 sn_118 3.598093168884059e-18
Rsub_47_86 sn_47 sn_86 78615779.59508671
Csub_47_86 sn_47 sn_86 1.340250463265584e-19
Rsub_47_183 sn_47 sn_183 37747121.64805543
Csub_47_183 sn_47 sn_183 2.791334290457825e-19
Rsub_47_202 sn_47 sn_202 12793896.25011955
Csub_47_202 sn_47 sn_202 8.235554905435117e-19
Rsub_47_154 sn_47 sn_154 13446302.68245385
Csub_47_154 sn_47 sn_154 7.835970787701448e-19
Rsub_47_137 sn_47 sn_137 3019270.355870689
Csub_47_137 sn_47 sn_137 3.489744958328357e-18
Rsub_47_158 sn_47 sn_158 1312277.02927992
Csub_47_158 sn_47 sn_158 8.029160967643882e-18
Rsub_47_174 sn_47 sn_174 41749190.00140371
Csub_47_174 sn_47 sn_174 2.523757587123424e-19
Rsub_47_190 sn_47 sn_190 1891687.011681027
Csub_47_190 sn_47 sn_190 5.569887321299981e-18
Rsub_47_218 sn_47 sn_218 5542924.779477837
Csub_47_218 sn_47 sn_218 1.900888776488606e-18
Rsub_47_51 sn_47 sn_51 3609258.448276327
Csub_47_51 sn_47 sn_51 2.919293160416902e-18
Rsub_47_59 sn_47 sn_59 9368171.502859291
Csub_47_59 sn_47 sn_59 1.12471078256991e-18
Rsub_47_112 sn_47 sn_112 506400.5295295106
Csub_47_112 sn_47 sn_112 2.080662023007617e-17
Rsub_47_213 sn_47 sn_213 15804492.67466597
Csub_47_213 sn_47 sn_213 6.666764773234135e-19
Rsub_47_77 sn_47 sn_77 13309600.65072016
Csub_47_77 sn_47 sn_77 7.916453527596928e-19
Rsub_47_203 sn_47 sn_203 5179457.805935035
Csub_47_203 sn_47 sn_203 2.034283103948923e-18
Rsub_47_168 sn_47 sn_168 734485.4114256537
Csub_47_168 sn_47 sn_168 1.434539520911441e-17
Rsub_47_139 sn_47 sn_139 3920602.717318335
Csub_47_139 sn_47 sn_139 2.687465234793513e-18
Rsub_47_72 sn_47 sn_72 8593367.20813532
Csub_47_72 sn_47 sn_72 1.226118149851101e-18
Rsub_47_97 sn_47 sn_97 1056239.270737125
Csub_47_97 sn_47 sn_97 9.975470325844665e-18
Rsub_47_177 sn_47 sn_177 937677.2735411036
Csub_47_177 sn_47 sn_177 1.123679095094132e-17
Rsub_47_98 sn_47 sn_98 72310058.36752695
Csub_47_98 sn_47 sn_98 1.457125570093819e-19
Rsub_47_87 sn_47 sn_87 12882440.91040684
Csub_47_87 sn_47 sn_87 8.178949607071982e-19
Rsub_47_129 sn_47 sn_129 250355.711670461
Csub_47_129 sn_47 sn_129 4.208605200946642e-17
Rsub_47_208 sn_47 sn_208 29395078.44510668
Csub_47_208 sn_47 sn_208 3.584437960220508e-19
Rsub_47_69 sn_47 sn_69 13437038.54019069
Csub_47_69 sn_47 sn_69 7.841373283789414e-19
Rsub_47_80 sn_47 sn_80 329032.4290042869
Csub_47_80 sn_47 sn_80 3.202262930166292e-17
Rsub_47_117 sn_47 sn_117 3130230.738755928
Csub_47_117 sn_47 sn_117 3.366040519561698e-18
Rsub_47_150 sn_47 sn_150 187986.005504622
Csub_47_150 sn_47 sn_150 5.604929725458176e-17
Rsub_47_155 sn_47 sn_155 3398777.250659102
Csub_47_155 sn_47 sn_155 3.100080624638385e-18
Rsub_47_76 sn_47 sn_76 609433.1428932307
Csub_47_76 sn_47 sn_76 1.728898998208231e-17
Rsub_47_207 sn_47 sn_207 4873946.997179408
Csub_47_207 sn_47 sn_207 2.161796898556252e-18
Rsub_47_114 sn_47 sn_114 16715901.96416798
Csub_47_114 sn_47 sn_114 6.303269500393032e-19
Rsub_47_107 sn_47 sn_107 1686055.896629216
Csub_47_107 sn_47 sn_107 6.249189913154523e-18
Rsub_47_210 sn_47 sn_210 1172284.782030163
Csub_47_210 sn_47 sn_210 8.987989662360806e-18
Rsub_47_131 sn_47 sn_131 7245.24942688093
Csub_47_131 sn_47 sn_131 1.454260975907622e-15
Rsub_47_219 sn_47 sn_219 41770.6462115449
Csub_47_219 sn_47 sn_219 2.522461215674907e-16
Rsub_47_52 sn_47 sn_52 31717.55492686373
Csub_47_52 sn_47 sn_52 3.321972178033794e-16
Rsub_47_99 sn_47 sn_99 1197141.899453497
Csub_47_99 sn_47 sn_99 8.801365574991548e-18
Rsub_47_206 sn_47 sn_206 2835473.222957965
Csub_47_206 sn_47 sn_206 3.715952390916372e-18
Rsub_47_127 sn_47 sn_127 3375213.682610392
Csub_47_127 sn_47 sn_127 3.121723390882049e-18
Rsub_47_133 sn_47 sn_133 2671189.903201267
Csub_47_133 sn_47 sn_133 3.944490614314854e-18
Rsub_47_110 sn_47 sn_110 1162458.2828583
Csub_47_110 sn_47 sn_110 9.063966989269037e-18
Rsub_47_126 sn_47 sn_126 895688.730236434
Csub_47_126 sn_47 sn_126 1.176355484505058e-17
Rsub_47_195 sn_47 sn_195 76986.47729066861
Csub_47_195 sn_47 sn_195 1.368614836401549e-16
Rsub_47_199 sn_47 sn_199 4453961.262348135
Csub_47_199 sn_47 sn_199 2.365643273842743e-18
Rsub_47_143 sn_47 sn_143 52899135.26734528
Csub_47_143 sn_47 sn_143 1.991806378115634e-19
Rsub_47_153 sn_47 sn_153 75346.17288526114
Csub_47_153 sn_47 sn_153 1.398409912375403e-16
Rsub_47_74 sn_47 sn_74 6469747.565275449
Csub_47_74 sn_47 sn_74 1.628577219732902e-18
Rsub_47_49 sn_47 sn_49 4830458.176052836
Csub_47_49 sn_47 sn_49 2.181259648301063e-18
Rsub_47_216 sn_47 sn_216 1811290.871022349
Csub_47_216 sn_47 sn_216 5.817112905937016e-18
Rsub_47_105 sn_47 sn_105 5637454.51116576
Csub_47_105 sn_47 sn_105 1.869014371887353e-18
Rsub_47_138 sn_47 sn_138 1142296.421479987
Csub_47_138 sn_47 sn_138 9.223948621478374e-18
Rsub_47_50 sn_47 sn_50 414754.2199037423
Csub_47_50 sn_47 sn_50 2.540416226428112e-17
Rsub_47_217 sn_47 sn_217 4297296.946263201
Csub_47_217 sn_47 sn_217 2.451886298290885e-18
Rsub_47_141 sn_47 sn_141 1227028.510462788
Csub_47_141 sn_47 sn_141 8.586991591789539e-18
Rsub_47_229 sn_47 sn_229 5106674.260161298
Csub_47_229 sn_47 sn_229 2.063276991138494e-18
Rsub_47_62 sn_47 sn_62 5012614.61272951
Csub_47_62 sn_47 sn_62 2.101993533568819e-18
Rsub_47_53 sn_47 sn_53 5072071.339465014
Csub_47_53 sn_47 sn_53 2.077353175269289e-18
Rsub_47_220 sn_47 sn_220 6412075.220609525
Csub_47_220 sn_47 sn_220 1.643225186810646e-18
Rsub_47_67 sn_47 sn_67 539726.9794258103
Csub_47_67 sn_47 sn_67 1.952187662258289e-17
Rsub_47_48 sn_47 sn_48 116921.9607407427
Csub_47_48 sn_47 sn_48 9.011552180170077e-17
Rsub_47_215 sn_47 sn_215 908610.4240297824
Csub_47_215 sn_47 sn_215 1.159626086557492e-17
Rsub_47_181 sn_47 sn_181 1019543.703406635
Csub_47_181 sn_47 sn_181 1.03345089249476e-17
Rsub_47_180 sn_47 sn_180 4574212.770828423
Csub_47_180 sn_47 sn_180 2.30345286284568e-18
Rsub_47_101 sn_47 sn_101 1506632.246149902
Csub_47_101 sn_47 sn_101 6.993401030115533e-18
Rsub_47_227 sn_47 sn_227 16938273.46771621
Csub_47_227 sn_47 sn_227 6.220518001620528e-19
Rsub_47_60 sn_47 sn_60 2635107.686151958
Csub_47_60 sn_47 sn_60 3.998502056519901e-18
Rsub_47_230 sn_47 0 84526.53564890163
Csub_47_230 sn_47 0 1.246529675130122e-16
Rsub_47_221 sn_47 sn_221 12904949.31564482
Csub_47_221 sn_47 sn_221 8.164684141344513e-19
Rsub_47_135 sn_47 sn_135 3255585.1685632
Csub_47_135 sn_47 sn_135 3.236433070150676e-18
Rsub_47_214 sn_47 sn_214 3684559.433438318
Csub_47_214 sn_47 sn_214 2.859631848141388e-18
Rsub_47_188 sn_47 sn_188 5222602.35063958
Csub_47_188 sn_47 sn_188 2.0174776471235e-18
Rsub_47_70 sn_47 sn_70 4851708.089442157
Csub_47_70 sn_47 sn_70 2.171705986425385e-18
Rsub_47_61 sn_47 sn_61 2146653.143420766
Csub_47_61 sn_47 sn_61 4.908330688878666e-18
Rsub_47_228 sn_47 sn_228 2779413.11563435
Csub_47_228 sn_47 sn_228 3.790902274642696e-18
Rsub_47_90 sn_47 sn_90 226900018.9318572
Csub_47_90 sn_47 sn_90 4.64366796963306e-20
Rsub_47_78 sn_47 sn_78 2118167.133211799
Csub_47_78 sn_47 sn_78 4.974340002270464e-18
Rsub_47_157 sn_47 sn_157 205493.0578770274
Csub_47_157 sn_47 sn_157 5.127415792574034e-17
Rsub_47_163 sn_47 sn_163 17012787.22165878
Csub_47_163 sn_47 sn_163 6.193272956953301e-19
Rsub_47_84 sn_47 sn_84 4740010.463973884
Csub_47_84 sn_47 sn_84 2.22288190760586e-18
Rsub_47_204 sn_47 sn_204 1755964.677134981
Csub_47_204 sn_47 sn_204 6.000396044082873e-18
Rsub_47_125 sn_47 sn_125 4326678.533789744
Csub_47_125 sn_47 sn_125 2.435236040751352e-18
Rsub_47_160 sn_47 sn_160 23525052.9527301
Csub_47_160 sn_47 sn_160 4.478835190467545e-19
Rsub_47_209 sn_47 sn_209 4945925.973324723
Csub_47_209 sn_47 sn_209 2.13033586815842e-18
Rsub_47_130 sn_47 sn_130 8349606.24162881
Csub_47_130 sn_47 sn_130 1.26191381932456e-18
Rsub_47_132 sn_47 sn_132 2619939.914634823
Csub_47_132 sn_47 sn_132 4.021650818545056e-18
Rsub_47_83 sn_47 sn_83 24385627.61628706
Csub_47_83 sn_47 sn_83 4.320776019392968e-19
Rsub_47_198 sn_47 sn_198 1195110.107077553
Csub_47_198 sn_47 sn_198 8.816328671167594e-18
Rsub_47_222 sn_47 sn_222 127236.8394511515
Csub_47_222 sn_47 sn_222 8.281000650189168e-17
Rsub_47_55 sn_47 sn_55 86649999.05399358
Csub_47_55 sn_47 sn_55 1.215981952367302e-19
Rsub_47_96 sn_47 sn_96 7897743.579813154
Csub_47_96 sn_47 sn_96 1.334113142032306e-18
Rsub_47_224 sn_47 sn_224 10448778.52834536
Csub_47_224 sn_47 sn_224 1.008393801595729e-18
Rsub_144_178 sn_144 sn_178 33288655.56873814
Csub_144_178 sn_144 sn_178 3.165187455670324e-19
Rsub_144_171 sn_144 sn_171 5452558.767180819
Csub_144_171 sn_144 sn_171 1.932392469687725e-18
Rsub_144_219 sn_144 sn_219 55251270.97555279
Csub_144_219 sn_144 sn_219 1.907011968447226e-19
Rsub_144_159 sn_144 sn_159 124861935.3439043
Csub_144_159 sn_144 sn_159 8.438507278627076e-20
Rsub_144_195 sn_144 sn_195 20068773.62722208
Csub_144_195 sn_144 sn_195 5.250188027402881e-19
Rsub_144_175 sn_144 sn_175 61181856.40589608
Csub_144_175 sn_144 sn_175 1.722158188912784e-19
Rsub_144_169 sn_144 sn_169 31625650.59860472
Csub_144_169 sn_144 sn_169 3.331625848890791e-19
Rsub_144_217 sn_144 sn_217 17342242.8184875
Csub_144_217 sn_144 sn_217 6.07561756141351e-19
Rsub_144_150 sn_144 sn_150 62430967.67195217
Csub_144_150 sn_144 sn_150 1.687701455725415e-19
Rsub_144_155 sn_144 sn_155 43497817.11515272
Csub_144_155 sn_144 sn_155 2.42230166960713e-19
Rsub_144_199 sn_144 sn_199 27268522.85593709
Csub_144_199 sn_144 sn_199 3.863972961753565e-19
Rsub_144_191 sn_144 sn_191 7050756.030793279
Csub_144_191 sn_144 sn_191 1.494376412431979e-18
Rsub_144_224 sn_144 sn_224 9221873.415530641
Csub_144_224 sn_144 sn_224 1.142553473406544e-18
Rsub_144_172 sn_144 sn_172 35973688.52764365
Csub_144_172 sn_144 sn_172 2.928941660828952e-19
Rsub_144_207 sn_144 sn_207 42501013.01779024
Csub_144_207 sn_144 sn_207 2.479113497322899e-19
Rsub_144_216 sn_144 sn_216 8550224.872560589
Csub_144_216 sn_144 sn_216 1.232304841015787e-18
Rsub_144_210 sn_144 sn_210 18006647.53084858
Csub_144_210 sn_144 sn_210 5.851440965998328e-19
Rsub_144_209 sn_144 sn_209 64635703.13016422
Csub_144_209 sn_144 sn_209 1.630133655545062e-19
Rsub_144_179 sn_144 sn_179 43475924.40400053
Csub_144_179 sn_144 sn_179 2.423521442423997e-19
Rsub_144_200 sn_144 sn_200 657542.9721875309
Csub_144_200 sn_144 sn_200 1.602402268429234e-17
Rsub_144_218 sn_144 sn_218 2882900.318634896
Csub_144_218 sn_144 sn_218 3.654820610384203e-18
Rsub_144_223 sn_144 sn_223 32026319.72497166
Csub_144_223 sn_144 sn_223 3.289945142842767e-19
Rsub_144_181 sn_144 sn_181 5012513.39402224
Csub_144_181 sn_144 sn_181 2.102035979553784e-18
Rsub_144_186 sn_144 sn_186 5873332.728220037
Csub_144_186 sn_144 sn_186 1.793953108020694e-18
Rsub_144_203 sn_144 sn_203 406329.561191329
Csub_144_203 sn_144 sn_203 2.593088101032519e-17
Rsub_144_166 sn_144 sn_166 727883.1134427842
Csub_144_166 sn_144 sn_166 1.447551579043224e-17
Rsub_144_174 sn_144 sn_174 568816.3536056231
Csub_144_174 sn_144 sn_174 1.852352421909313e-17
Rsub_144_211 sn_144 sn_211 1750498.566674656
Csub_144_211 sn_144 sn_211 6.019132893233775e-18
Rsub_144_198 sn_144 sn_198 704558.131681032
Csub_144_198 sn_144 sn_198 1.495473975595258e-17
Rsub_144_215 sn_144 sn_215 637693.7616805545
Csub_144_215 sn_144 sn_215 1.652279532178979e-17
Rsub_144_160 sn_144 sn_160 714009.443579775
Csub_144_160 sn_144 sn_160 1.475678451730839e-17
Rsub_144_197 sn_144 sn_197 33415286.10705033
Csub_144_197 sn_144 sn_197 3.153192664122334e-19
Rsub_144_222 sn_144 sn_222 18206.91400163202
Csub_144_222 sn_144 sn_222 5.78707819528644e-16
Rsub_144_213 sn_144 sn_213 104813.9104466038
Csub_144_213 sn_144 sn_213 1.005256216215469e-16
Rsub_144_206 sn_144 sn_206 526353898.1899788
Csub_144_206 sn_144 sn_206 2.001786922916838e-20
Rsub_144_147 sn_144 sn_147 62430967.67195217
Csub_144_147 sn_144 sn_147 1.687701455725415e-19
Rsub_144_226 sn_144 sn_226 921814.5888269953
Csub_144_226 sn_144 sn_226 1.143015485970734e-17
Rsub_144_192 sn_144 sn_192 91287.27518351348
Csub_144_192 sn_144 sn_192 1.15421163366402e-16
Rsub_144_182 sn_144 sn_182 556689.7584663851
Csub_144_182 sn_144 sn_182 1.89270295384215e-17
Rsub_144_148 sn_144 sn_148 79079.23946763563
Csub_144_148 sn_144 sn_148 1.332395654429911e-16
Rsub_144_227 sn_144 sn_227 1384148.194279129
Csub_144_227 sn_144 sn_227 7.612251018914529e-18
Rsub_144_190 sn_144 sn_190 16281609.79881812
Csub_144_190 sn_144 sn_190 6.47140155821376e-19
Rsub_144_153 sn_144 sn_153 21023448.47245963
Csub_144_153 sn_144 sn_153 5.011776976566248e-19
Rsub_144_170 sn_144 sn_170 1554404.995518451
Csub_144_170 sn_144 sn_170 6.778467344487464e-18
Rsub_144_196 sn_144 sn_196 951180.320725322
Csub_144_196 sn_144 sn_196 1.10772723874222e-17
Rsub_144_157 sn_144 sn_157 19753021.26668776
Csub_144_157 sn_144 sn_157 5.33411236690112e-19
Rsub_144_220 sn_144 sn_220 37427400.55528796
Csub_144_220 sn_144 sn_220 2.815179078938557e-19
Rsub_144_151 sn_144 sn_151 31517931.59187407
Csub_144_151 sn_144 sn_151 3.343012364728437e-19
Rsub_144_230 sn_144 0 218497.403757182
Csub_144_230 sn_144 0 4.822246544375093e-17
Rsub_144_212 sn_144 sn_212 450879.810641615
Csub_144_212 sn_144 sn_212 2.336871878835355e-17
Rsub_144_214 sn_144 sn_214 656561.8808511938
Csub_144_214 sn_144 sn_214 1.604796715972921e-17
Rsub_144_177 sn_144 sn_177 12872141.62353034
Csub_144_177 sn_144 sn_177 8.185493766607769e-19
Rsub_144_168 sn_144 sn_168 27803465.63342283
Csub_144_168 sn_144 sn_168 3.789629552354793e-19
Rsub_144_221 sn_144 sn_221 672990.4994849514
Csub_144_221 sn_144 sn_221 1.565621433035639e-17
Rsub_144_158 sn_144 sn_158 27392533.0026034
Csub_144_158 sn_144 sn_158 3.846480170792752e-19
Rsub_144_164 sn_144 sn_164 61349141.95405416
Csub_144_164 sn_144 sn_164 1.717462244234977e-19
Rsub_84_96 sn_84 sn_96 265472181.5182403
Csub_84_96 sn_84 sn_96 3.968959550477816e-20
Rsub_84_153 sn_84 sn_153 304975960.4245183
Csub_84_153 sn_84 sn_153 3.454857060721606e-20
Rsub_84_214 sn_84 sn_214 182000242.4004291
Csub_84_214 sn_84 sn_214 5.789268939020467e-20
Rsub_84_156 sn_84 sn_156 304975960.4245183
Csub_84_156 sn_84 sn_156 3.454857060721606e-20
Rsub_84_133 sn_84 sn_133 32908446.79236802
Csub_84_133 sn_84 sn_133 3.201756548617657e-19
Rsub_84_212 sn_84 sn_212 1104568.285712325
Csub_84_212 sn_84 sn_212 9.539005997655572e-18
Rsub_84_211 sn_84 sn_211 29472330.08291281
Csub_84_211 sn_84 sn_211 3.575042581495361e-19
Rsub_84_226 sn_84 sn_226 434180.0683777271
Csub_84_226 sn_84 sn_226 2.426754305327413e-17
Rsub_84_222 sn_84 sn_222 315326.9761932148
Csub_84_222 sn_84 sn_222 3.341446909944626e-17
Rsub_84_148 sn_84 sn_148 2660071.727689997
Csub_84_148 sn_84 sn_148 3.960977214467772e-18
Rsub_84_227 sn_84 sn_227 2000168.992849441
Csub_84_227 sn_84 sn_227 5.267796641132671e-18
Rsub_84_126 sn_84 sn_126 3383769.262013437
Csub_84_126 sn_84 sn_126 3.113830372689331e-18
Rsub_84_186 sn_84 sn_186 600106.8134001771
Csub_84_186 sn_84 sn_186 1.755768017785164e-17
Rsub_84_146 sn_84 sn_146 199082.963446201
Csub_84_146 sn_84 sn_146 5.292508871597804e-17
Rsub_84_220 sn_84 sn_220 6043083.797816542
Csub_84_220 sn_84 sn_220 1.743560714156734e-18
Rsub_84_141 sn_84 sn_141 326686.3004417902
Csub_84_141 sn_84 sn_141 3.225260284248564e-17
Rsub_84_218 sn_84 sn_218 948438.1206668012
Csub_84_218 sn_84 sn_218 1.110929988223407e-17
Rsub_84_181 sn_84 sn_181 3678558.019329092
Csub_84_181 sn_84 sn_181 2.864297218330046e-18
Rsub_84_175 sn_84 sn_175 6817197.83803271
Csub_84_175 sn_84 sn_175 1.545573966395347e-18
Rsub_84_230 sn_84 0 63011.06485451593
Csub_84_230 sn_84 0 1.672164012234569e-16
Rsub_84_151 sn_84 sn_151 5868283.853251601
Csub_84_151 sn_84 sn_151 1.795496565216722e-18
Rsub_84_162 sn_84 sn_162 336349.1420164169
Csub_84_162 sn_84 sn_162 3.132603056176585e-17
Rsub_84_120 sn_84 sn_120 127632.7485348192
Csub_84_120 sn_84 sn_120 8.255313485908019e-17
Rsub_84_195 sn_84 sn_195 197802190.3313654
Csub_84_195 sn_84 sn_195 5.32677797176002e-20
Rsub_84_116 sn_84 sn_116 1173482.66606954
Csub_84_116 sn_84 sn_116 8.978814776634812e-18
Rsub_84_158 sn_84 sn_158 288463.6204435861
Csub_84_158 sn_84 sn_158 3.652621251174578e-17
Rsub_84_97 sn_84 sn_97 3572620.698247838
Csub_84_97 sn_84 sn_97 2.949230940580267e-18
Rsub_84_171 sn_84 sn_171 246178.0043312356
Csub_84_171 sn_84 sn_171 4.28002636988357e-17
Rsub_84_208 sn_84 sn_208 7750.234827568693
Csub_84_208 sn_84 sn_208 1.359505064898192e-15
Rsub_84_197 sn_84 sn_197 395235.1214829643
Csub_84_197 sn_84 sn_197 2.665877329599655e-17
Rsub_84_118 sn_84 sn_118 1947197.368614672
Csub_84_118 sn_84 sn_118 5.411101962265979e-18
Rsub_84_160 sn_84 sn_160 472921.7992967013
Csub_84_160 sn_84 sn_160 2.227954710038568e-17
Rsub_84_123 sn_84 sn_123 47250.14464316618
Csub_84_123 sn_84 sn_123 2.229936772003914e-16
Rsub_84_202 sn_84 sn_202 304975960.4245183
Csub_84_202 sn_84 sn_202 3.454857060721606e-20
Rsub_84_93 sn_84 sn_93 5299.910216900329
Csub_84_93 sn_84 sn_93 1.988049433107624e-15
Rsub_84_224 sn_84 sn_224 33883.75595269661
Csub_84_224 sn_84 sn_224 3.10959727042641e-16
Rsub_84_190 sn_84 sn_190 558513.3155823386
Csub_84_190 sn_84 sn_190 1.886523240944408e-17
Rsub_84_216 sn_84 sn_216 369925.6794010803
Csub_84_216 sn_84 sn_216 2.848270365898592e-17
Rsub_84_184 sn_84 sn_184 1578704.455184151
Csub_84_184 sn_84 sn_184 6.674133000404407e-18
Rsub_84_164 sn_84 sn_164 133964.1711204249
Csub_84_164 sn_84 sn_164 7.865150371257403e-17
Rsub_84_198 sn_84 sn_198 2147556.218769876
Csub_84_198 sn_84 sn_198 4.906266671922244e-18
Rsub_84_192 sn_84 sn_192 1253771.414038596
Csub_84_192 sn_84 sn_192 8.403831339789699e-18
Rsub_84_155 sn_84 sn_155 204491.3551615499
Csub_84_155 sn_84 sn_155 5.152532484273524e-17
Rsub_84_86 sn_84 sn_86 11601486.76589916
Csub_84_86 sn_84 sn_86 9.082011396332777e-19
Rsub_84_142 sn_84 sn_142 12272462.54939323
Csub_84_142 sn_84 sn_142 8.585468042639038e-19
Rsub_84_221 sn_84 sn_221 1329838.233263783
Csub_84_221 sn_84 sn_221 7.923131730368904e-18
Rsub_84_207 sn_84 sn_207 198796.7970771404
Csub_84_207 sn_84 sn_207 5.300127394980848e-17
Rsub_84_128 sn_84 sn_128 6492569.369554962
Csub_84_128 sn_84 sn_128 1.622852664715115e-18
Rsub_84_166 sn_84 sn_166 357161.7638937943
Csub_84_166 sn_84 sn_166 2.950059207727268e-17
Rsub_84_177 sn_84 sn_177 3263991.312833533
Csub_84_177 sn_84 sn_177 3.228097899893942e-18
Rsub_84_135 sn_84 sn_135 1644820.214116291
Csub_84_135 sn_84 sn_135 6.405857255281188e-18
Rsub_84_185 sn_84 sn_185 3720156.453555676
Csub_84_185 sn_84 sn_185 2.832268920345909e-18
Rsub_84_117 sn_84 sn_117 2192446.36838062
Csub_84_117 sn_84 sn_117 4.805811286509341e-18
Rsub_84_196 sn_84 sn_196 5831746.718371822
Csub_84_196 sn_84 sn_196 1.806745733492984e-18
Rsub_84_179 sn_84 sn_179 4622877.352370778
Csub_84_179 sn_84 sn_179 2.279204637957032e-18
Rsub_84_178 sn_84 sn_178 15447850.89708583
Csub_84_178 sn_84 sn_178 6.820679182123425e-19
Rsub_84_99 sn_84 sn_99 6219466.255056078
Csub_84_99 sn_84 sn_99 1.694113782459135e-18
Rsub_84_134 sn_84 sn_134 3692087.634625668
Csub_84_134 sn_84 sn_134 2.85380103208148e-18
Rsub_84_131 sn_84 sn_131 5100485.141879304
Csub_84_131 sn_84 sn_131 2.065780648141986e-18
Rsub_84_110 sn_84 sn_110 12216922.04395546
Csub_84_110 sn_84 sn_110 8.62449925138314e-19
Rsub_84_101 sn_84 sn_101 3709967.773024086
Csub_84_101 sn_84 sn_101 2.840047177456061e-18
Rsub_84_194 sn_84 sn_194 6957287.613860314
Csub_84_194 sn_84 sn_194 1.514452770536496e-18
Rsub_84_144 sn_84 sn_144 39964180.90973008
Csub_84_144 sn_84 sn_144 2.636481785033828e-19
Rsub_84_203 sn_84 sn_203 7131297.873473866
Csub_84_203 sn_84 sn_203 1.477498723117755e-18
Rsub_84_130 sn_84 sn_130 1676471.686767058
Csub_84_130 sn_84 sn_130 6.284915865503682e-18
Rsub_84_112 sn_84 sn_112 2171787.651716779
Csub_84_112 sn_84 sn_112 4.851525651645086e-18
Rsub_84_127 sn_84 sn_127 5892328.568392591
Csub_84_127 sn_84 sn_127 1.788169715916626e-18
Rsub_84_174 sn_84 sn_174 33831495.01380783
Csub_84_174 sn_84 sn_174 3.114400796633341e-19
Rsub_84_95 sn_84 sn_95 52473815.58680381
Csub_84_95 sn_84 sn_95 2.007950705395194e-19
Rsub_84_170 sn_84 sn_170 5970096.998081902
Csub_84_170 sn_84 sn_170 1.764876434271538e-18
Rsub_59_200 sn_59 sn_200 3266763.411684461
Csub_59_200 sn_59 sn_200 3.225358611689914e-18
Rsub_59_134 sn_59 sn_134 25902766.42556546
Csub_59_134 sn_59 sn_134 4.067705869374139e-19
Rsub_59_80 sn_59 sn_80 25195729.67683164
Csub_59_80 sn_59 sn_80 4.181852892285422e-19
Rsub_59_89 sn_59 sn_89 21695826.16119246
Csub_59_89 sn_59 sn_89 4.856456455701473e-19
Rsub_59_117 sn_59 sn_117 25898399.42877515
Csub_59_117 sn_59 sn_117 4.068391767300933e-19
Rsub_59_182 sn_59 sn_182 8940348.686342986
Csub_59_182 sn_59 sn_182 1.178531606751001e-18
Rsub_59_219 sn_59 sn_219 7147384.953748666
Csub_59_219 sn_59 sn_219 1.474173221452668e-18
Rsub_59_90 sn_59 sn_90 226748554.688671
Csub_59_90 sn_59 sn_90 4.646769862192394e-20
Rsub_59_156 sn_59 sn_156 24999890.46017064
Csub_59_156 sn_59 sn_156 4.214611867606592e-19
Rsub_59_167 sn_59 sn_167 25597255.24937079
Csub_59_167 sn_59 sn_167 4.116255199857415e-19
Rsub_59_101 sn_59 sn_101 3013434.406956942
Csub_59_101 sn_59 sn_101 3.496503351095027e-18
Rsub_59_196 sn_59 sn_196 12454159.88627215
Csub_59_196 sn_59 sn_196 8.460212168822442e-19
Rsub_59_107 sn_59 sn_107 13916067.4408097
Csub_59_107 sn_59 sn_107 7.571451882542e-19
Rsub_59_114 sn_59 sn_114 5307808.257949628
Csub_59_114 sn_59 sn_114 1.98509120717563e-18
Rsub_59_81 sn_59 sn_81 7738913.362000153
Csub_59_81 sn_59 sn_81 1.36149392161005e-18
Rsub_59_165 sn_59 sn_165 20444773.85411915
Csub_59_165 sn_59 sn_165 5.153631718996562e-19
Rsub_59_108 sn_59 sn_108 14552466.15990727
Csub_59_108 sn_59 sn_108 7.240342211726637e-19
Rsub_59_181 sn_59 sn_181 3124365.816735665
Csub_59_181 sn_59 sn_181 3.372359102698963e-18
Rsub_59_153 sn_59 sn_153 8623646.948134437
Csub_59_153 sn_59 sn_153 1.221812948234085e-18
Rsub_59_175 sn_59 sn_175 63089705.58521388
Csub_59_175 sn_59 sn_175 1.67007967535981e-19
Rsub_59_174 sn_59 sn_174 63089705.58521388
Csub_59_174 sn_59 sn_174 1.67007967535981e-19
Rsub_59_169 sn_59 sn_169 16374349.22979853
Csub_59_169 sn_59 sn_169 6.43474946964939e-19
Rsub_59_112 sn_59 sn_112 35478954.77633396
Csub_59_112 sn_59 sn_112 2.969784078661276e-19
Rsub_59_98 sn_59 sn_98 25346301.76653382
Csub_59_98 sn_59 sn_98 4.157010201836201e-19
Rsub_59_88 sn_59 sn_88 25346301.76653382
Csub_59_88 sn_59 sn_88 4.157010201836201e-19
Rsub_59_185 sn_59 sn_185 9946473.137184173
Csub_59_185 sn_59 sn_185 1.059318550093914e-18
Rsub_59_128 sn_59 sn_128 11779281.68657777
Csub_59_128 sn_59 sn_128 8.944928716864024e-19
Rsub_59_207 sn_59 sn_207 84414.8425891465
Csub_59_207 sn_59 sn_207 1.248179014383984e-16
Rsub_59_216 sn_59 sn_216 666599.301031413
Csub_59_216 sn_59 sn_216 1.580632245777509e-17
Rsub_59_141 sn_59 sn_141 1931630.865086516
Csub_59_141 sn_59 sn_141 5.454708605392926e-18
Rsub_59_140 sn_59 sn_140 11104997.73491831
Csub_59_140 sn_59 sn_140 9.488055516751093e-19
Rsub_59_177 sn_59 sn_177 32031264.06805996
Csub_59_177 sn_59 sn_177 3.289437307201521e-19
Rsub_59_168 sn_59 sn_168 9076815.597401129
Csub_59_168 sn_59 sn_168 1.160812775049303e-18
Rsub_59_132 sn_59 sn_132 3936475.039674105
Csub_59_132 sn_59 sn_132 2.676629064337292e-18
Rsub_59_211 sn_59 sn_211 2916849.278190351
Csub_59_211 sn_59 sn_211 3.612282465539997e-18
Rsub_59_155 sn_59 sn_155 591723.9567183388
Csub_59_155 sn_59 sn_155 1.780641696622295e-17
Rsub_59_192 sn_59 sn_192 2674189.402145606
Csub_59_192 sn_59 sn_192 3.940066284675338e-18
Rsub_59_229 sn_59 sn_229 25120443.63198055
Csub_59_229 sn_59 sn_229 4.194385917936626e-19
Rsub_59_71 sn_59 sn_71 20054249.7555187
Csub_59_71 sn_59 sn_71 5.253990366471068e-19
Rsub_59_150 sn_59 sn_150 24894585.49742728
Csub_59_150 sn_59 sn_150 4.232439822434034e-19
Rsub_59_230 sn_59 0 82996.07480022387
Csub_59_230 sn_59 0 1.269515881033157e-16
Rsub_59_72 sn_59 sn_72 34156938.3050198
Csub_59_72 sn_59 sn_72 3.084727152105882e-19
Rsub_59_206 sn_59 sn_206 12144842.31016053
Csub_59_206 sn_59 sn_206 8.675685721678776e-19
Rsub_59_224 sn_59 sn_224 196652.6675691345
Csub_59_224 sn_59 sn_224 5.35791537052292e-17
Rsub_59_66 sn_59 sn_66 209205882.1672488
Csub_59_66 sn_59 sn_66 5.036418380342984e-20
Rsub_59_186 sn_59 sn_186 19981.73279641147
Csub_59_186 sn_59 sn_186 5.273057952272413e-16
Rsub_59_208 sn_59 sn_208 219897.7460656691
Csub_59_208 sn_59 sn_208 4.791537744585815e-17
Rsub_59_166 sn_59 sn_166 30983.09335831441
Csub_59_166 sn_59 sn_166 3.40072031555316e-16
Rsub_59_64 sn_59 sn_64 257430.0557586385
Csub_59_64 sn_59 sn_64 4.092950013617994e-17
Rsub_59_222 sn_59 sn_222 888805.3567643919
Csub_59_222 sn_59 sn_222 1.185465796536942e-17
Rsub_59_218 sn_59 sn_218 76818.92142885657
Csub_59_218 sn_59 sn_218 1.371600031118379e-16
Rsub_59_139 sn_59 sn_139 26299925.0013143
Csub_59_139 sn_59 sn_139 4.006278915891758e-19
Rsub_59_157 sn_59 sn_157 11857530.06167229
Csub_59_157 sn_59 sn_157 8.885900729265383e-19
Rsub_59_226 sn_59 sn_226 93175.13404463329
Csub_59_226 sn_59 sn_226 1.130825687589862e-16
Rsub_59_84 sn_59 sn_84 179091.6058841239
Csub_59_84 sn_59 sn_84 5.883292770878013e-17
Rsub_59_158 sn_59 sn_158 1964558.274951457
Csub_59_158 sn_59 sn_158 5.363283765400318e-18
Rsub_59_197 sn_59 sn_197 24974.41559775199
Csub_59_197 sn_59 sn_197 4.218910933466814e-16
Rsub_59_160 sn_59 sn_160 32740.54245535684
Csub_59_160 sn_59 sn_160 3.218176215802458e-16
Rsub_59_116 sn_59 sn_116 47426847.76824635
Csub_59_116 sn_59 sn_116 2.221628465319275e-19
Rsub_59_227 sn_59 sn_227 954461.6037238464
Csub_59_227 sn_59 sn_227 1.103919053539897e-17
Rsub_59_148 sn_59 sn_148 2483016.13605216
Csub_59_148 sn_59 sn_148 4.243421276747057e-18
Rsub_59_69 sn_59 sn_69 11409940.51122709
Csub_59_69 sn_59 sn_69 9.234477157757633e-19
Rsub_59_204 sn_59 sn_204 6124072.899687751
Csub_59_204 sn_59 sn_204 1.720502625428778e-18
Rsub_59_93 sn_59 sn_93 92425.40637770774
Csub_59_93 sn_59 sn_93 1.13999861241306e-16
Rsub_59_179 sn_59 sn_179 16700164.48867206
Csub_59_179 sn_59 sn_179 6.309209414899496e-19
Rsub_59_188 sn_59 sn_188 4016222.294800374
Csub_59_188 sn_59 sn_188 2.623481154385085e-18
Rsub_59_191 sn_59 sn_191 3656124.093537932
Csub_59_191 sn_59 sn_191 2.881872505600359e-18
Rsub_59_221 sn_59 sn_221 763048.8265271317
Csub_59_221 sn_59 sn_221 1.380840011272248e-17
Rsub_59_142 sn_59 sn_142 9726368.241307355
Csub_59_142 sn_59 sn_142 1.083290622031164e-18
Rsub_59_212 sn_59 sn_212 1528569.189791886
Csub_59_212 sn_59 sn_212 6.893036685938003e-18
Rsub_59_133 sn_59 sn_133 28612468.60563228
Csub_59_133 sn_59 sn_133 3.682479707520212e-19
Rsub_59_203 sn_59 sn_203 1324978.565172967
Csub_59_203 sn_59 sn_203 7.952191664968207e-18
Rsub_59_171 sn_59 sn_171 4326743.816239896
Csub_59_171 sn_59 sn_171 2.435199297606347e-18
Rsub_59_190 sn_59 sn_190 1343274.441263815
Csub_59_190 sn_59 sn_190 7.843879983539914e-18
Rsub_59_178 sn_59 sn_178 4693654.035507886
Csub_59_178 sn_59 sn_178 2.244835989725834e-18
Rsub_59_103 sn_59 sn_103 8648589.360815007
Csub_59_103 sn_59 sn_103 1.218289256507964e-18
Rsub_59_159 sn_59 sn_159 5237626.857371155
Csub_59_159 sn_59 sn_159 2.011690368396809e-18
Rsub_59_198 sn_59 sn_198 5573077.05264158
Csub_59_198 sn_59 sn_198 1.890604311174169e-18
Rsub_59_162 sn_59 sn_162 6661944.755054423
Csub_59_162 sn_59 sn_162 1.581592746507837e-18
Rsub_59_83 sn_59 sn_83 6713237.00039204
Csub_59_83 sn_59 sn_83 1.569508644133179e-18
Rsub_59_77 sn_59 sn_77 10192430.08186568
Csub_59_77 sn_59 sn_77 1.033755779299037e-18
Rsub_59_161 sn_59 sn_161 16491240.51621479
Csub_59_161 sn_59 sn_161 6.389139429426276e-19
Rsub_59_82 sn_59 sn_82 23382724.76648895
Csub_59_82 sn_59 sn_82 4.506097389184688e-19
Rsub_59_146 sn_59 sn_146 3655741.452996045
Csub_59_146 sn_59 sn_146 2.882174146531855e-18
Rsub_59_144 sn_59 sn_144 24858755.62091069
Csub_59_144 sn_59 sn_144 4.238540200044011e-19
Rsub_59_65 sn_59 sn_65 3356618.50019602
Csub_59_65 sn_59 sn_65 3.139017288266358e-18
Rsub_59_135 sn_59 sn_135 2402632.419304064
Csub_59_135 sn_59 sn_135 4.385391380543326e-18
Rsub_59_214 sn_59 sn_214 6987877.110878559
Csub_59_214 sn_59 sn_214 1.507823239453805e-18
Rsub_59_123 sn_59 sn_123 9944951.33446819
Csub_59_123 sn_59 sn_123 1.059480649815914e-18
Rsub_59_202 sn_59 sn_202 3212136.747726232
Csub_59_202 sn_59 sn_202 3.280210131056356e-18
Rsub_59_152 sn_59 sn_152 24869490.14914358
Csub_59_152 sn_59 sn_152 4.236710700155967e-19
Rsub_59_213 sn_59 sn_213 8182150.021686201
Csub_59_213 sn_59 sn_213 1.287740199617925e-18
Rsub_57_135 sn_57 sn_135 27752109.21048394
Csub_57_135 sn_57 sn_135 3.796642418173254e-19
Rsub_57_174 sn_57 sn_174 7417919.049043952
Csub_57_174 sn_57 sn_174 1.420409609833634e-18
Rsub_57_200 sn_57 sn_200 26901469.84771049
Csub_57_200 sn_57 sn_200 3.916694352344741e-19
Rsub_57_177 sn_57 sn_177 23260921.90207105
Csub_57_177 sn_57 sn_177 4.529692996085369e-19
Rsub_57_227 sn_57 sn_227 1659672.831610685
Csub_57_227 sn_57 sn_227 6.348530446211207e-18
Rsub_57_185 sn_57 sn_185 49049.97640777401
Csub_57_185 sn_57 sn_185 2.148111838961059e-16
Rsub_57_198 sn_57 sn_198 28017934.01135065
Csub_57_198 sn_57 sn_198 3.760621142858518e-19
Rsub_57_168 sn_57 sn_168 27990295.01673662
Csub_57_168 sn_57 sn_168 3.764334565223332e-19
Rsub_57_182 sn_57 sn_182 18161360.99352786
Csub_57_182 sn_57 sn_182 5.801593562280314e-19
Rsub_57_103 sn_57 sn_103 28177428.89187067
Csub_57_103 sn_57 sn_103 3.73933460808762e-19
Rsub_57_191 sn_57 sn_191 37288495.7350098
Csub_57_191 sn_57 sn_191 2.825666011605129e-19
Rsub_57_178 sn_57 sn_178 14920488.79318865
Csub_57_178 sn_57 sn_178 7.061754911836408e-19
Rsub_57_91 sn_57 sn_91 41268078.91947699
Csub_57_91 sn_57 sn_91 2.553180031178329e-19
Rsub_57_189 sn_57 sn_189 7064570.488073695
Csub_57_189 sn_57 sn_189 1.491454224997477e-18
Rsub_57_211 sn_57 sn_211 33421427.16982117
Csub_57_211 sn_57 sn_211 3.152613276713755e-19
Rsub_57_212 sn_57 sn_212 14820164.0100177
Csub_57_212 sn_57 sn_212 7.10955931061752e-19
Rsub_57_203 sn_57 sn_203 2607934.205764291
Csub_57_203 sn_57 sn_203 4.040164617244299e-18
Rsub_57_114 sn_57 sn_114 16278604.42513492
Csub_57_114 sn_57 sn_114 6.472596315419509e-19
Rsub_57_195 sn_57 sn_195 3331383.109303886
Csub_57_195 sn_57 sn_195 3.162795498603483e-18
Rsub_57_116 sn_57 sn_116 3240348.339957822
Csub_57_116 sn_57 sn_116 3.251651488298678e-18
Rsub_57_82 sn_57 sn_82 12711901.96262408
Csub_57_82 sn_57 sn_82 8.288675867080859e-19
Rsub_57_162 sn_57 sn_162 3028460.3553772
Csub_57_162 sn_57 sn_162 3.47915516989413e-18
Rsub_57_171 sn_57 sn_171 9384767.659222564
Csub_57_171 sn_57 sn_171 1.122721828054595e-18
Rsub_57_176 sn_57 sn_176 1482920.93213432
Csub_57_176 sn_57 sn_176 7.105222722202175e-18
Rsub_57_213 sn_57 sn_213 9697920.322770793
Csub_57_213 sn_57 sn_213 1.08646835110516e-18
Rsub_57_226 sn_57 sn_226 459383.7898960928
Csub_57_226 sn_57 sn_226 2.293612385542213e-17
Rsub_57_197 sn_57 sn_197 388695.9453600426
Csub_57_197 sn_57 sn_197 2.710726373147585e-17
Rsub_57_202 sn_57 sn_202 11586344.78351263
Csub_57_202 sn_57 sn_202 9.093880511154322e-19
Rsub_57_160 sn_57 sn_160 799074.7095705165
Csub_57_160 sn_57 sn_160 1.318585530994105e-17
Rsub_57_164 sn_57 sn_164 65717571.1633255
Csub_57_164 sn_57 sn_164 1.603297765835573e-19
Rsub_57_127 sn_57 sn_127 8716853.241592642
Csub_57_127 sn_57 sn_127 1.208748525437477e-18
Rsub_57_172 sn_57 sn_172 27196382.97977577
Csub_57_172 sn_57 sn_172 3.874222358931083e-19
Rsub_57_93 sn_57 sn_93 1981380.195361794
Csub_57_93 sn_57 sn_93 5.317749479324976e-18
Rsub_57_207 sn_57 sn_207 35390.16003067776
Csub_57_207 sn_57 sn_207 2.977235336911873e-16
Rsub_57_190 sn_57 sn_190 120628399.1108567
Csub_57_190 sn_57 sn_190 8.73466246745681e-20
Rsub_57_224 sn_57 sn_224 31253.11847371265
Csub_57_224 sn_57 sn_224 3.371338290958822e-16
Rsub_57_208 sn_57 sn_208 373056.3615960422
Csub_57_208 sn_57 sn_208 2.824367732841199e-17
Rsub_57_166 sn_57 sn_166 5430211.36251641
Csub_57_166 sn_57 sn_166 1.94034500663475e-18
Rsub_57_64 sn_57 sn_64 14001230.72681696
Csub_57_64 sn_57 sn_64 7.525398093789836e-19
Rsub_57_222 sn_57 sn_222 4033573.08967713
Csub_57_222 sn_57 sn_222 2.612196002892662e-18
Rsub_57_153 sn_57 sn_153 24538264.39717197
Csub_57_153 sn_57 sn_153 4.293899247187314e-19
Rsub_57_74 sn_57 sn_74 4399460.418530655
Csub_57_74 sn_57 sn_74 2.394949039170809e-18
Rsub_57_120 sn_57 sn_120 146448.6894911415
Csub_57_120 sn_57 sn_120 7.194658783796997e-17
Rsub_57_78 sn_57 sn_78 27893855.6573245
Csub_57_78 sn_57 sn_78 3.777349259876621e-19
Rsub_57_157 sn_57 sn_157 10621436.63359431
Csub_57_157 sn_57 sn_157 9.920017287401956e-19
Rsub_57_223 sn_57 sn_223 13118994.84599568
Csub_57_223 sn_57 sn_223 8.031471637818398e-19
Rsub_57_184 sn_57 sn_184 8430272.874074299
Csub_57_184 sn_57 sn_184 1.249838962465017e-18
Rsub_57_215 sn_57 sn_215 25420641.80333862
Csub_57_215 sn_57 sn_215 4.144853455606376e-19
Rsub_57_72 sn_57 sn_72 47578254.72945948
Csub_57_72 sn_57 sn_72 2.214558638634978e-19
Rsub_57_230 sn_57 0 331370.3322958204
Csub_57_230 sn_57 0 3.17967013800858e-17
Rsub_57_155 sn_57 sn_155 1341141.613343003
Csub_57_155 sn_57 sn_155 7.856354166780486e-18
Rsub_57_192 sn_57 sn_192 6429521.138100438
Csub_57_192 sn_57 sn_192 1.63876644557435e-18
Rsub_57_158 sn_57 sn_158 7369950.791680686
Csub_57_158 sn_57 sn_158 1.42965452552597e-18
Rsub_57_84 sn_57 sn_84 1680147.993031149
Csub_57_84 sn_57 sn_84 6.271163936708438e-18
Rsub_57_58 sn_57 sn_58 27191460.37871474
Csub_57_58 sn_57 sn_58 3.874923728067903e-19
Rsub_57_137 sn_57 sn_137 13493145.06587104
Csub_57_137 sn_57 sn_137 7.808767674839957e-19
Rsub_57_186 sn_57 sn_186 1174411.427386146
Csub_57_186 sn_57 sn_186 8.971714048866806e-18
Rsub_57_107 sn_57 sn_107 21204942.16501864
Csub_57_107 sn_57 sn_107 4.968881037370534e-19
Rsub_57_218 sn_57 sn_218 661388.3167696729
Csub_57_218 sn_57 sn_218 1.593085821910475e-17
Rsub_57_181 sn_57 sn_181 3508450.55499193
Csub_57_181 sn_57 sn_181 3.003172864225882e-18
Rsub_57_146 sn_57 sn_146 24016248.24258036
Csub_57_146 sn_57 sn_146 4.387231259355912e-19
Rsub_57_59 sn_57 sn_59 602343.1747692621
Csub_57_59 sn_57 sn_59 1.749249255835958e-17
Rsub_57_138 sn_57 sn_138 62829548.27485631
Csub_57_138 sn_57 sn_138 1.67699494768556e-19
Rsub_57_141 sn_57 sn_141 3608115.757615035
Csub_57_141 sn_57 sn_141 2.920217700885134e-18
Rsub_57_142 sn_57 sn_142 15460317.57027142
Csub_57_142 sn_57 sn_142 6.815179218886526e-19
Rsub_224_227 sn_224 sn_227 422492.1861266688
Csub_224_227 sn_224 sn_227 2.493888371954652e-17
Rsub_224_230 sn_224 0 29471.16876158782
Csub_224_230 sn_224 0 3.575183457251637e-16
Rsub_224_226 sn_224 sn_226 103921.8702912295
Csub_224_226 sn_224 sn_226 1.01388509201217e-16
Rsub_99_115 sn_99 sn_115 16941420.66844666
Csub_99_115 sn_99 sn_115 6.219362418556887e-19
Rsub_99_172 sn_99 sn_172 15371575.5591371
Csub_99_172 sn_99 sn_172 6.85452409331388e-19
Rsub_99_165 sn_99 sn_165 11004385.94035592
Csub_99_165 sn_99 sn_165 9.574803682220927e-19
Rsub_99_122 sn_99 sn_122 11958703.46809277
Csub_99_122 sn_99 sn_122 8.81072394707552e-19
Rsub_99_137 sn_99 sn_137 5715735.616648042
Csub_99_137 sn_99 sn_137 1.843416877355335e-18
Rsub_99_149 sn_99 sn_149 43645846.28220963
Csub_99_149 sn_99 sn_149 2.414086195992664e-19
Rsub_99_159 sn_99 sn_159 3649590.174024906
Csub_99_159 sn_99 sn_159 2.887031967923666e-18
Rsub_99_133 sn_99 sn_133 650706.9873000274
Csub_99_133 sn_99 sn_133 1.61923626269159e-17
Rsub_99_212 sn_99 sn_212 2571638.422832628
Csub_99_212 sn_99 sn_212 4.097186995139151e-18
Rsub_99_198 sn_99 sn_198 571070.5123560437
Csub_99_198 sn_99 sn_198 1.84504072163699e-17
Rsub_99_217 sn_99 sn_217 2375526.551563153
Csub_99_217 sn_99 sn_217 4.435430744942313e-18
Rsub_99_138 sn_99 sn_138 372938.7997245942
Csub_99_138 sn_99 sn_138 2.82525806111108e-17
Rsub_99_229 sn_99 sn_229 3642256.507946532
Csub_99_229 sn_99 sn_229 2.892844992998685e-18
Rsub_99_155 sn_99 sn_155 2355685.579114017
Csub_99_155 sn_99 sn_155 4.472788557033497e-18
Rsub_99_131 sn_99 sn_131 275343.5218433163
Csub_99_131 sn_99 sn_131 3.82666838561968e-17
Rsub_99_218 sn_99 sn_218 1778208.675400117
Csub_99_218 sn_99 sn_218 5.925335787634244e-18
Rsub_99_152 sn_99 sn_152 5515739.229037156
Csub_99_152 sn_99 sn_152 1.910257730597841e-18
Rsub_99_226 sn_99 sn_226 4577787.482676464
Csub_99_226 sn_99 sn_226 2.301654137965729e-18
Rsub_99_219 sn_99 sn_219 553786.4473207707
Csub_99_219 sn_99 sn_219 1.902625741963478e-17
Rsub_99_140 sn_99 sn_140 34904334.15237144
Csub_99_140 sn_99 sn_140 3.018674831679647e-19
Rsub_99_153 sn_99 sn_153 15642255.11751915
Csub_99_153 sn_99 sn_153 6.735910789761549e-19
Rsub_99_199 sn_99 sn_199 513430.2014404032
Csub_99_199 sn_99 sn_199 2.052174467468102e-17
Rsub_99_206 sn_99 sn_206 339616.8567522763
Csub_99_206 sn_99 sn_206 3.102461875122864e-17
Rsub_99_179 sn_99 sn_179 8368504.464830763
Csub_99_179 sn_99 sn_179 1.259064095204863e-18
Rsub_99_100 sn_99 sn_100 16503106.63095507
Csub_99_100 sn_99 sn_100 6.384545490645133e-19
Rsub_99_105 sn_99 sn_105 154533.1228725623
Csub_99_105 sn_99 sn_105 6.818268670412522e-17
Rsub_99_204 sn_99 sn_204 148017.4487895702
Csub_99_204 sn_99 sn_204 7.118406369244514e-17
Rsub_99_125 sn_99 sn_125 7388867.487532653
Csub_99_125 sn_99 sn_125 1.425994378706665e-18
Rsub_99_178 sn_99 sn_178 363580.6014894089
Csub_99_178 sn_99 sn_178 2.897977356071052e-17
Rsub_99_201 sn_99 sn_201 75193.30641051935
Csub_99_201 sn_99 sn_201 1.401252851511258e-16
Rsub_99_101 sn_99 sn_101 13874.38364020102
Csub_99_101 sn_99 sn_101 7.594199335601866e-16
Rsub_99_222 sn_99 sn_222 368742.993786187
Csub_99_222 sn_99 sn_222 2.85740574866068e-17
Rsub_99_114 sn_99 sn_114 837744.3623652671
Csub_99_114 sn_99 sn_114 1.25772060971936e-17
Rsub_99_188 sn_99 sn_188 269017.468930391
Csub_99_188 sn_99 sn_188 3.91665401660453e-17
Rsub_99_230 sn_99 0 75375.96901180586
Csub_99_230 sn_99 0 1.397857120825831e-16
Rsub_99_128 sn_99 sn_128 2081028.560514215
Csub_99_128 sn_99 sn_128 5.063113357572792e-18
Rsub_99_207 sn_99 sn_207 10935641.02864065
Csub_99_207 sn_99 sn_207 9.634993938292915e-19
Rsub_99_135 sn_99 sn_135 4519604.743531899
Csub_99_135 sn_99 sn_135 2.331284282615418e-18
Rsub_99_177 sn_99 sn_177 1515854.529152996
Csub_99_177 sn_99 sn_177 6.950853990004836e-18
Rsub_99_195 sn_99 sn_195 359546.3919666378
Csub_99_195 sn_99 sn_195 2.930493459994914e-17
Rsub_99_110 sn_99 sn_110 1046571.715351454
Csub_99_110 sn_99 sn_110 1.006761729528654e-17
Rsub_99_189 sn_99 sn_189 7026309.886075567
Csub_99_189 sn_99 sn_189 1.499575690948494e-18
Rsub_99_215 sn_99 sn_215 384089.0412415932
Csub_99_215 sn_99 sn_215 2.74323981443733e-17
Rsub_99_141 sn_99 sn_141 2043608.012142912
Csub_99_141 sn_99 sn_141 5.155824130470854e-18
Rsub_99_220 sn_99 sn_220 9932097.269101836
Csub_99_220 sn_99 sn_220 1.060851823814531e-18
Rsub_99_203 sn_99 sn_203 8311505.15444777
Csub_99_203 sn_99 sn_203 1.267698606502286e-18
Rsub_99_129 sn_99 sn_129 340091.7438360167
Csub_99_129 sn_99 sn_129 3.098129752691208e-17
Rsub_99_216 sn_99 sn_216 17380059.01407226
Csub_99_216 sn_99 sn_216 6.062398000892191e-19
Rsub_99_162 sn_99 sn_162 3157139.828889383
Csub_99_162 sn_99 sn_162 3.337350916743058e-18
Rsub_99_142 sn_99 sn_142 15896762.45761328
Csub_99_142 sn_99 sn_142 6.628068784649839e-19
Rsub_99_118 sn_99 sn_118 5847883.015653254
Csub_99_118 sn_99 sn_118 1.801760307794563e-18
Rsub_99_197 sn_99 sn_197 38487361.04421313
Csub_99_197 sn_99 sn_197 2.737647689101366e-19
Rsub_99_132 sn_99 sn_132 4782821.43892831
Csub_99_132 sn_99 sn_132 2.202984919418384e-18
Rsub_99_211 sn_99 sn_211 4799346.561132113
Csub_99_211 sn_99 sn_211 2.195399596178476e-18
Rsub_99_148 sn_99 sn_148 29589746.12278954
Csub_99_148 sn_99 sn_148 3.560856338038999e-19
Rsub_99_227 sn_99 sn_227 1110190.532144923
Csub_99_227 sn_99 sn_227 9.490698395592678e-18
Rsub_99_107 sn_99 sn_107 5287626.497093628
Csub_99_107 sn_99 sn_107 1.992667883788962e-18
Rsub_99_225 sn_99 sn_225 6904821.226970662
Csub_99_225 sn_99 sn_225 1.52596036246005e-18
Rsub_99_167 sn_99 sn_167 7928135.549294769
Csub_99_167 sn_99 sn_167 1.328998909859362e-18
Rsub_99_103 sn_99 sn_103 5087505.154259043
Csub_99_103 sn_99 sn_103 2.07105117002374e-18
Rsub_99_182 sn_99 sn_182 4464097.32339494
Csub_99_182 sn_99 sn_182 2.360271906934372e-18
Rsub_99_134 sn_99 sn_134 7090892.265949299
Csub_99_134 sn_99 sn_134 1.485917865770792e-18
Rsub_99_213 sn_99 sn_213 5988290.003067289
Csub_99_213 sn_99 sn_213 1.759514568738832e-18
Rsub_99_130 sn_99 sn_130 6555950.186029011
Csub_99_130 sn_99 sn_130 1.607163447441023e-18
Rsub_99_126 sn_99 sn_126 1856222.133781902
Csub_99_126 sn_99 sn_126 5.676305281826789e-18
Rsub_99_112 sn_99 sn_112 5353235.304971214
Csub_99_112 sn_99 sn_112 1.968245911485607e-18
Rsub_99_228 sn_99 sn_228 71313544.16351573
Csub_99_228 sn_99 sn_228 1.477487008368391e-19
Rsub_99_160 sn_99 sn_160 2087101.522285777
Csub_99_160 sn_99 sn_160 5.048380919530225e-18
Rsub_99_117 sn_99 sn_117 2182654.441965097
Csub_99_117 sn_99 sn_117 4.827371341816138e-18
Rsub_99_192 sn_99 sn_192 2245171.581377342
Csub_99_192 sn_99 sn_192 4.6929524627985e-18
Rsub_99_108 sn_99 sn_108 16244621.27034397
Csub_99_108 sn_99 sn_108 6.486136750670395e-19
Rsub_99_202 sn_99 sn_202 11785362.79385754
Csub_99_202 sn_99 sn_202 8.9403132398449e-19
Rsub_78_145 sn_78 sn_145 37227358.03580655
Csub_78_145 sn_78 sn_145 2.83030654286443e-19
Rsub_78_212 sn_78 sn_212 3828304.156807469
Csub_78_212 sn_78 sn_212 2.752258721004204e-18
Rsub_78_127 sn_78 sn_127 20304799.76847467
Csub_78_127 sn_78 sn_127 5.189159027605383e-19
Rsub_78_98 sn_78 sn_98 12764456.77369382
Csub_78_98 sn_78 sn_98 8.25454908817159e-19
Rsub_78_229 sn_78 sn_229 5040276.842123238
Csub_78_229 sn_78 sn_229 2.090457296744729e-18
Rsub_78_150 sn_78 sn_150 5205833.373144771
Csub_78_150 sn_78 sn_150 2.023976325593583e-18
Rsub_78_80 sn_78 sn_80 3496544.182202911
Csub_78_80 sn_78 sn_80 3.013399217392915e-18
Rsub_78_228 sn_78 sn_228 46813793.16289403
Csub_78_228 sn_78 sn_228 2.250722018095625e-19
Rsub_78_213 sn_78 sn_213 4781019.456301456
Csub_78_213 sn_78 sn_213 2.20381523198839e-18
Rsub_78_201 sn_78 sn_201 4258776.137326104
Csub_78_201 sn_78 sn_201 2.474063712784253e-18
Rsub_78_217 sn_78 sn_217 10021046.7930983
Csub_78_217 sn_78 sn_217 1.051435415857622e-18
Rsub_78_138 sn_78 sn_138 2243432.063632858
Csub_78_138 sn_78 sn_138 4.696591295556304e-18
Rsub_78_177 sn_78 sn_177 1528081.394745707
Csub_78_177 sn_78 sn_177 6.89523708518381e-18
Rsub_78_214 sn_78 sn_214 4381739.960731015
Csub_78_214 sn_78 sn_214 2.404634596451994e-18
Rsub_78_135 sn_78 sn_135 4848966.987324105
Csub_78_135 sn_78 sn_135 2.172933643345867e-18
Rsub_78_178 sn_78 sn_178 5227844.319899428
Csub_78_178 sn_78 sn_178 2.015454718520138e-18
Rsub_78_99 sn_78 sn_99 39546.76384676519
Csub_78_99 sn_78 sn_99 2.66430991497977e-16
Rsub_78_160 sn_78 sn_160 13416913.96448006
Csub_78_160 sn_78 sn_160 7.853134878947788e-19
Rsub_78_209 sn_78 sn_209 5359504.277250779
Csub_78_209 sn_78 sn_209 1.96594366888626e-18
Rsub_78_130 sn_78 sn_130 11182220.83735325
Csub_78_130 sn_78 sn_130 9.422532120841135e-19
Rsub_78_206 sn_78 sn_206 1810668.54228284
Csub_78_206 sn_78 sn_206 5.819112253944558e-18
Rsub_78_199 sn_78 sn_199 7186047.283814382
Csub_78_199 sn_78 sn_199 1.466241883206368e-18
Rsub_78_230 sn_78 0 131570.7542931917
Csub_78_230 sn_78 0 8.008226112887175e-17
Rsub_78_133 sn_78 sn_133 5328752.313292086
Csub_78_133 sn_78 sn_133 1.977289031795999e-18
Rsub_78_101 sn_78 sn_101 140332.8483865382
Csub_78_101 sn_78 sn_101 7.50820896416775e-17
Rsub_78_220 sn_78 sn_220 29313225.7100456
Csub_78_220 sn_78 sn_220 3.594446959352946e-19
Rsub_78_141 sn_78 sn_141 13753781.31720951
Csub_78_141 sn_78 sn_141 7.660790337742361e-19
Rsub_78_110 sn_78 sn_110 42609.01807753601
Csub_78_110 sn_78 sn_110 2.472829456679023e-16
Rsub_78_189 sn_78 sn_189 13575122.01836661
Csub_78_189 sn_78 sn_189 7.761612372967663e-19
Rsub_78_195 sn_78 sn_195 347371.9697237463
Csub_78_195 sn_78 sn_195 3.033199112354784e-17
Rsub_78_116 sn_78 sn_116 16894642.86595282
Csub_78_116 sn_78 sn_116 6.236582558050875e-19
Rsub_78_157 sn_78 sn_157 28201594.72681222
Csub_78_157 sn_78 sn_157 3.736130387056661e-19
Rsub_78_129 sn_78 sn_129 92607.13938835837
Csub_78_129 sn_78 sn_129 1.137761469776545e-16
Rsub_78_208 sn_78 sn_208 9359292.249830572
Csub_78_208 sn_78 sn_208 1.125777806801656e-18
Rsub_78_190 sn_78 sn_190 28322424.1815115
Csub_78_190 sn_78 sn_190 3.720191264244986e-19
Rsub_78_153 sn_78 sn_153 362763.9790015668
Csub_78_153 sn_78 sn_153 2.904501028803771e-17
Rsub_78_204 sn_78 sn_204 457360.1112893325
Csub_78_204 sn_78 sn_204 2.303760918836333e-17
Rsub_78_131 sn_78 sn_131 314830.3633307616
Csub_78_131 sn_78 sn_131 3.346717702434674e-17
Rsub_78_210 sn_78 sn_210 27935769.9264738
Csub_78_210 sn_78 sn_210 3.771681800774328e-19
Rsub_78_97 sn_78 sn_97 396352.768090036
Csub_78_97 sn_78 sn_97 2.658360014237751e-17
Rsub_78_105 sn_78 sn_105 80949.58588799828
Csub_78_105 sn_78 sn_105 1.301610550152568e-16
Rsub_78_198 sn_78 sn_198 1985134.621550733
Csub_78_198 sn_78 sn_198 5.307692177570906e-18
Rsub_78_87 sn_78 sn_87 12664708.80676925
Csub_78_87 sn_78 sn_87 8.319562386304756e-19
Rsub_78_219 sn_78 sn_219 667594.1568284319
Csub_78_219 sn_78 sn_219 1.578276771067939e-17
Rsub_78_222 sn_78 sn_222 1882283.888847273
Csub_78_222 sn_78 sn_222 5.59771220731355e-18
Rsub_78_114 sn_78 sn_114 8120270.328983903
Csub_78_114 sn_78 sn_114 1.297553292606755e-18
Rsub_78_188 sn_78 sn_188 4254945.922114086
Csub_78_188 sn_78 sn_188 2.476290814289576e-18
Rsub_78_109 sn_78 sn_109 24719071.94238102
Csub_78_109 sn_78 sn_109 4.262491539646005e-19
Rsub_78_227 sn_78 sn_227 772167.9459080748
Csub_78_227 sn_78 sn_227 1.364532619887378e-17
Rsub_78_148 sn_78 sn_148 27669945.12613538
Csub_78_148 sn_78 sn_148 3.807916298423688e-19
Rsub_78_202 sn_78 sn_202 2686687.220232135
Csub_78_202 sn_78 sn_202 3.9217380508177e-18
Rsub_78_155 sn_78 sn_155 3629320.844907505
Csub_78_155 sn_78 sn_155 2.903155701159435e-18
Rsub_78_115 sn_78 sn_115 3857703.730291937
Csub_78_115 sn_78 sn_115 2.731283747762724e-18
Rsub_78_194 sn_78 sn_194 47418860.85702346
Csub_78_194 sn_78 sn_194 2.222002661345962e-19
Rsub_78_216 sn_78 sn_216 2283219.156235617
Csub_78_216 sn_78 sn_216 4.614749080680317e-18
Rsub_78_200 sn_78 sn_200 27935769.9264738
Csub_78_200 sn_78 sn_200 3.771681800774328e-19
Rsub_78_132 sn_78 sn_132 7057529.56848476
Csub_78_132 sn_78 sn_132 1.492942169067266e-18
Rsub_78_126 sn_78 sn_126 5067058.706114237
Csub_78_126 sn_78 sn_126 2.079408215562217e-18
Rsub_78_86 sn_78 sn_86 2892686.276062221
Csub_78_86 sn_78 sn_86 3.642456352568309e-18
Rsub_78_165 sn_78 sn_165 27210793.19827811
Csub_78_165 sn_78 sn_165 3.872170658699044e-19
Rsub_78_175 sn_78 sn_175 329926771.7476752
Csub_78_175 sn_78 sn_175 3.193582456621072e-20
Rsub_78_224 sn_78 sn_224 979063.436581081
Csub_78_224 sn_78 sn_224 1.076179858071681e-17
Rsub_78_117 sn_78 sn_117 12199075.28429696
Csub_78_117 sn_78 sn_117 8.637116549147707e-19
Rsub_78_196 sn_78 sn_196 13264762.30247524
Csub_78_196 sn_78 sn_196 7.94321320048371e-19
Rsub_78_179 sn_78 sn_179 8446372.892575184
Csub_78_179 sn_78 sn_179 1.247456587133649e-18
Rsub_78_107 sn_78 sn_107 13324203.21590991
Csub_78_107 sn_78 sn_107 7.907777546989675e-19
Rsub_78_139 sn_78 sn_139 7716934.776554503
Csub_78_139 sn_78 sn_139 1.36537158953861e-18
Rsub_78_174 sn_78 sn_174 26056109.55778555
Csub_78_174 sn_78 sn_174 4.043766963315407e-19
Rsub_78_92 sn_78 sn_92 27959935.81741365
Csub_78_92 sn_78 sn_92 3.768421920220504e-19
Rsub_78_226 sn_78 sn_226 4077820.237679721
Csub_78_226 sn_78 sn_226 2.583851883629195e-18
Rsub_78_225 sn_78 sn_225 14715763.29620264
Csub_78_225 sn_78 sn_225 7.159997949239175e-19
Rsub_78_185 sn_78 sn_185 54421586.39655622
Csub_78_185 sn_78 sn_185 1.936085329349522e-19
Rsub_78_191 sn_78 sn_191 108843172.7931124
Csub_78_191 sn_78 sn_191 9.68042664674761e-20
Rsub_78_112 sn_78 sn_112 9562946.668181311
Csub_78_112 sn_78 sn_112 1.101803018235784e-18
Rsub_78_83 sn_78 sn_83 6663655.351811216
Csub_78_83 sn_78 sn_83 1.581186743003767e-18
Rsub_78_94 sn_78 sn_94 27476617.99861653
Csub_78_94 sn_78 sn_94 3.834709025237576e-19
Rsub_78_89 sn_78 sn_89 23580338.06515417
Csub_78_89 sn_78 sn_89 4.468334369556934e-19
Rsub_78_203 sn_78 sn_203 19932403.84488995
Csub_78_203 sn_78 sn_203 5.286107779183506e-19
Rsub_61_225 sn_61 sn_225 27434119.31966237
Csub_61_225 sn_61 sn_225 3.840649440741615e-19
Rsub_61_207 sn_61 sn_207 10614004.52779828
Csub_61_207 sn_61 sn_207 9.926963451574518e-19
Rsub_61_160 sn_61 sn_160 11467310.1000038
Csub_61_160 sn_61 sn_160 9.188278166670066e-19
Rsub_61_69 sn_61 sn_69 6731621.756412707
Csub_61_69 sn_61 sn_69 1.565222153516378e-18
Rsub_61_175 sn_61 sn_175 12607727.66087267
Csub_61_175 sn_61 sn_175 8.357162992130097e-19
Rsub_61_200 sn_61 sn_200 3795785.972048551
Csub_61_200 sn_61 sn_200 2.775837094034982e-18
Rsub_61_130 sn_61 sn_130 9173554.309004102
Csub_61_130 sn_61 sn_130 1.148571551147645e-18
Rsub_61_83 sn_61 sn_83 6312251.442435913
Csub_61_83 sn_61 sn_83 1.669211627311847e-18
Rsub_61_185 sn_61 sn_185 2528152.714975057
Csub_61_185 sn_61 sn_185 4.167661011860179e-18
Rsub_61_95 sn_61 sn_95 51955457.2261439
Csub_61_95 sn_61 sn_95 2.027983981811262e-19
Rsub_61_223 sn_61 sn_223 6105109.615580164
Csub_61_223 sn_61 sn_223 1.725846735878587e-18
Rsub_61_68 sn_61 sn_68 2497756.184671008
Csub_61_68 sn_61 sn_68 4.218379506732286e-18
Rsub_61_179 sn_61 sn_179 11877368.36519146
Csub_61_179 sn_61 sn_179 8.87105895705724e-19
Rsub_61_213 sn_61 sn_213 6794268.443110991
Csub_61_213 sn_61 sn_213 1.55078999166031e-18
Rsub_61_62 sn_61 sn_62 5584006.762234477
Csub_61_62 sn_61 sn_62 1.886903786272235e-18
Rsub_61_229 sn_61 sn_229 7269938.764072579
Csub_61_229 sn_61 sn_229 1.449322180580173e-18
Rsub_61_157 sn_61 sn_157 5924943.55931888
Csub_61_157 sn_61 sn_157 1.778326391929589e-18
Rsub_61_72 sn_61 sn_72 136417.8205800314
Csub_61_72 sn_61 sn_72 7.723685554739258e-17
Rsub_61_151 sn_61 sn_151 14414537.26965311
Csub_61_151 sn_61 sn_151 7.309623129153398e-19
Rsub_61_222 sn_61 sn_222 482757.3653462555
Csub_61_222 sn_61 sn_222 2.182562972327259e-17
Rsub_61_74 sn_61 sn_74 13484567.12322387
Csub_61_74 sn_61 sn_74 7.813735069095012e-19
Rsub_61_153 sn_61 sn_153 10565.2789386243
Csub_61_153 sn_61 sn_153 9.972745218974739e-16
Rsub_61_112 sn_61 sn_112 1427853.814884026
Csub_61_112 sn_61 sn_112 7.379245264744279e-18
Rsub_61_152 sn_61 sn_152 2787625.88596482
Csub_61_152 sn_61 sn_152 3.779733699302782e-18
Rsub_61_78 sn_61 sn_78 78517.95002549239
Csub_61_78 sn_61 sn_78 1.34192035054521e-16
Rsub_61_105 sn_61 sn_105 19842.20503681292
Csub_61_105 sn_61 sn_105 5.310137397875807e-16
Rsub_61_67 sn_61 sn_67 546887.0537659621
Csub_61_67 sn_61 sn_67 1.926628803822268e-17
Rsub_61_215 sn_61 sn_215 1429966.070413603
Csub_61_215 sn_61 sn_215 7.368345109882522e-18
Rsub_61_178 sn_61 sn_178 2422869.426748985
Csub_61_178 sn_61 sn_178 4.348762416127349e-18
Rsub_61_99 sn_61 sn_99 176447.607111486
Csub_61_99 sn_61 sn_99 5.971451625055291e-17
Rsub_61_141 sn_61 sn_141 1768820.033322214
Csub_61_141 sn_61 sn_141 5.956786616917878e-18
Rsub_61_129 sn_61 sn_129 197791.2163897608
Csub_61_129 sn_61 sn_129 5.327073514461409e-17
Rsub_61_208 sn_61 sn_208 9194102.057062114
Csub_61_208 sn_61 sn_208 1.146004627405325e-18
Rsub_61_166 sn_61 sn_166 11497452.96258414
Csub_61_166 sn_61 sn_166 9.16418926567354e-19
Rsub_61_131 sn_61 sn_131 212385.1307221031
Csub_61_131 sn_61 sn_131 4.961026916717886e-17
Rsub_61_228 sn_61 sn_228 24970968.40935737
Csub_61_228 sn_61 sn_228 4.219493345032493e-19
Rsub_61_219 sn_61 sn_219 178159.1319999789
Csub_61_219 sn_61 sn_219 5.914085561570456e-17
Rsub_61_198 sn_61 sn_198 935474.3135355947
Csub_61_198 sn_61 sn_198 1.126325260862343e-17
Rsub_61_183 sn_61 sn_183 28829074.53930621
Csub_61_183 sn_61 sn_183 3.654811564576699e-19
Rsub_61_110 sn_61 sn_110 24174.65725467873
Csub_61_110 sn_61 sn_110 4.358483097083325e-16
Rsub_61_76 sn_61 sn_76 652601.0753978653
Csub_61_76 sn_61 sn_76 1.614536644121575e-17
Rsub_61_195 sn_61 sn_195 96917.58934299016
Csub_61_195 sn_61 sn_195 1.087159056849992e-16
Rsub_61_133 sn_61 sn_133 2899709.276316202
Csub_61_133 sn_61 sn_133 3.633634443386536e-18
Rsub_61_212 sn_61 sn_212 6931716.793997925
Csub_61_212 sn_61 sn_212 1.520039524891351e-18
Rsub_61_170 sn_61 sn_170 1490036.408795982
Csub_61_170 sn_61 sn_170 7.071292647636688e-18
Rsub_61_204 sn_61 sn_204 213966.7035094856
Csub_61_204 sn_61 sn_204 4.924356607551743e-17
Rsub_61_125 sn_61 sn_125 5427890.293498392
Csub_61_125 sn_61 sn_125 1.941174735025643e-18
Rsub_61_114 sn_61 sn_114 4161827.524559621
Csub_61_114 sn_61 sn_114 2.53169633773925e-18
Rsub_61_199 sn_61 sn_199 3428711.473520036
Csub_61_199 sn_61 sn_199 3.073015499730245e-18
Rsub_61_120 sn_61 sn_120 54017356.72980167
Csub_61_120 sn_61 sn_120 1.950573693365667e-19
Rsub_61_97 sn_61 sn_97 12988.41214306877
Csub_61_97 sn_61 sn_97 8.112218326743481e-16
Rsub_61_176 sn_61 sn_176 6980246.059997425
Csub_61_176 sn_61 sn_176 1.509471644934231e-18
Rsub_61_182 sn_61 sn_182 6133887.979805331
Csub_61_182 sn_61 sn_182 1.717749580187866e-18
Rsub_61_206 sn_61 sn_206 873568.2752086479
Csub_61_206 sn_61 sn_206 1.206143103092132e-17
Rsub_61_127 sn_61 sn_127 3577798.321883175
Csub_61_127 sn_61 sn_127 2.944962950478473e-18
Rsub_61_101 sn_61 sn_101 115427.5957088972
Csub_61_101 sn_61 sn_101 9.128218808960122e-17
Rsub_61_177 sn_61 sn_177 640321.9137976875
Csub_61_177 sn_61 sn_177 1.645497877737642e-17
Rsub_61_181 sn_61 sn_181 2071730.430466089
Csub_61_181 sn_61 sn_181 5.085837108575728e-18
Rsub_61_126 sn_61 sn_126 3684576.961886721
Csub_61_126 sn_61 sn_126 2.859618244161929e-18
Rsub_61_132 sn_61 sn_132 2106048.940094698
Csub_61_132 sn_61 sn_132 5.002962325156713e-18
Rsub_61_227 sn_61 sn_227 6784431.938803799
Csub_61_227 sn_61 sn_227 1.553038426395909e-18
Rsub_61_100 sn_61 sn_100 7973826.898026844
Csub_61_100 sn_61 sn_100 1.321383526000207e-18
Rsub_61_201 sn_61 sn_201 26814636.52378682
Csub_61_201 sn_61 sn_201 3.929377708656712e-19
Rsub_61_159 sn_61 sn_159 14496694.24244299
Csub_61_159 sn_61 sn_159 7.268197373840996e-19
Rsub_61_117 sn_61 sn_117 6890330.199262014
Csub_61_117 sn_61 sn_117 1.529169603999313e-18
Rsub_61_196 sn_61 sn_196 8204614.550951026
Csub_61_196 sn_61 sn_196 1.284214320709153e-18
Rsub_61_79 sn_61 sn_79 2870736.442371799
Csub_61_79 sn_61 sn_79 3.670306805846925e-18
Rsub_61_226 sn_61 sn_226 525516.9575875297
Csub_61_226 sn_61 sn_226 2.004974977515365e-17
Rsub_61_138 sn_61 sn_138 2437723.545936544
Csub_61_138 sn_61 sn_138 4.322263498579782e-18
Rsub_61_217 sn_61 sn_217 7191171.481935132
Csub_61_217 sn_61 sn_217 1.465197086274273e-18
Rsub_61_139 sn_61 sn_139 2110049.979303156
Csub_61_139 sn_61 sn_139 4.993475797056557e-18
Rsub_61_188 sn_61 sn_188 10748757.62870096
Csub_61_188 sn_61 sn_188 9.802512872832714e-19
Rsub_61_202 sn_61 sn_202 122925.2907946927
Csub_61_202 sn_61 sn_202 8.571452981004387e-17
Rsub_61_77 sn_61 sn_77 31128167.40131181
Csub_61_77 sn_61 sn_77 3.3848711253673e-19
Rsub_61_137 sn_61 sn_137 10855780.58699678
Csub_61_137 sn_61 sn_137 9.705873675128216e-19
Rsub_61_216 sn_61 sn_216 2684068.607336707
Csub_61_216 sn_61 sn_216 3.92556415042048e-18
Rsub_61_165 sn_61 sn_165 6648926.610110277
Csub_61_165 sn_61 sn_165 1.584689397264267e-18
Rsub_61_86 sn_61 sn_86 25398351.37778889
Csub_61_86 sn_61 sn_86 4.148491114838367e-19
Rsub_61_221 sn_61 sn_221 3152637.344344613
Csub_61_221 sn_61 sn_221 3.342117202643357e-18
Rsub_61_230 sn_61 0 103072.1557058517
Csub_61_230 sn_61 0 1.022243440051755e-16
Rsub_61_63 sn_61 sn_63 83131837.81339084
Csub_61_63 sn_61 sn_63 1.267442628404492e-19
Rsub_61_128 sn_61 sn_128 13381237.10695396
Csub_61_128 sn_61 sn_128 7.874072791636286e-19
Rsub_61_66 sn_61 sn_66 123367.9367157056
Csub_61_66 sn_61 sn_66 8.540698485142639e-17
Rsub_61_82 sn_61 sn_82 10269166.14224497
Csub_61_82 sn_61 sn_82 1.026031067788976e-18
Rsub_61_174 sn_61 sn_174 57780645.23719624
Csub_61_174 sn_61 sn_174 1.823531644372699e-19
Rsub_61_88 sn_61 sn_88 11028498.44141011
Csub_61_88 sn_61 sn_88 9.553869511979366e-19
Rsub_61_107 sn_61 sn_107 16408639.94816238
Csub_61_107 sn_61 sn_107 6.421302152717412e-19
Rsub_67_211 sn_67 sn_211 35258034.88125023
Csub_67_211 sn_67 sn_211 2.988392160174862e-19
Rsub_67_189 sn_67 sn_189 25035862.83095007
Csub_67_189 sn_67 sn_189 4.208556171351319e-19
Rsub_67_112 sn_67 sn_112 1260645.913825263
Csub_67_112 sn_67 sn_112 8.358003930111062e-18
Rsub_67_118 sn_67 sn_118 2356193.38558596
Csub_67_118 sn_67 sn_118 4.471824582263519e-18
Rsub_67_149 sn_67 sn_149 185058516.5548838
Csub_67_149 sn_67 sn_149 5.693595570947495e-20
Rsub_67_115 sn_67 sn_115 23678769.58357335
Csub_67_115 sn_67 sn_115 4.449759716205636e-19
Rsub_67_154 sn_67 sn_154 12722780.76625597
Csub_67_154 sn_67 sn_154 8.281588511039519e-19
Rsub_67_103 sn_67 sn_103 21027077.42755267
Csub_67_103 sn_67 sn_103 5.010912019767235e-19
Rsub_67_101 sn_67 sn_101 883632.0244511309
Csub_67_101 sn_67 sn_101 1.192406251773724e-17
Rsub_67_180 sn_67 sn_180 21188492.09979797
Csub_67_180 sn_67 sn_180 4.972738717131487e-19
Rsub_67_105 sn_67 sn_105 682038.9558171814
Csub_67_105 sn_67 sn_105 1.54485068812613e-17
Rsub_67_75 sn_67 sn_75 25390296.266137
Csub_67_75 sn_67 sn_75 4.149807230206484e-19
Rsub_67_201 sn_67 sn_201 7817667.920708833
Csub_67_201 sn_67 sn_201 1.347778341200588e-18
Rsub_67_198 sn_67 sn_198 1486675.784811207
Csub_67_198 sn_67 sn_198 7.087277273146701e-18
Rsub_67_188 sn_67 sn_188 5174062.860003098
Csub_67_188 sn_67 sn_188 2.036404231514051e-18
Rsub_67_199 sn_67 sn_199 12634274.72830807
Csub_67_199 sn_67 sn_199 8.339602967966335e-19
Rsub_67_127 sn_67 sn_127 12879810.30748577
Csub_67_127 sn_67 sn_127 8.180620095084925e-19
Rsub_67_206 sn_67 sn_206 3335387.508470849
Csub_67_206 sn_67 sn_206 3.158998309932685e-18
Rsub_67_107 sn_67 sn_107 8071585.19710661
Csub_67_107 sn_67 sn_107 1.305379704844963e-18
Rsub_67_181 sn_67 sn_181 4177601.596265931
Csub_67_181 sn_67 sn_181 2.522136986841406e-18
Rsub_67_96 sn_67 sn_96 7259025.50996631
Csub_67_96 sn_67 sn_96 1.45150109856535e-18
Rsub_67_175 sn_67 sn_175 23682572.94819601
Csub_67_175 sn_67 sn_175 4.449045095428537e-19
Rsub_67_133 sn_67 sn_133 8601990.468621235
Csub_67_133 sn_67 sn_133 1.224888999896652e-18
Rsub_67_195 sn_67 sn_195 6151294.862535965
Csub_67_195 sn_67 sn_195 1.712888706799234e-18
Rsub_67_72 sn_67 sn_72 2960100.1581644
Csub_67_72 sn_67 sn_72 3.559502361151125e-18
Rsub_67_230 sn_67 0 170047.6876679273
Csub_67_230 sn_67 0 6.196193342426312e-17
Rsub_67_76 sn_67 sn_76 71990.12984171427
Csub_67_76 sn_67 sn_76 1.463601124959313e-16
Rsub_67_155 sn_67 sn_155 5362111.84996166
Csub_67_155 sn_67 sn_155 1.964987638649376e-18
Rsub_67_110 sn_67 sn_110 186995.3022954352
Csub_67_110 sn_67 sn_110 5.634624706017125e-17
Rsub_67_227 sn_67 sn_227 8517962.474903315
Csub_67_227 sn_67 sn_227 1.236972284542683e-18
Rsub_67_148 sn_67 sn_148 1835207.919770626
Csub_67_148 sn_67 sn_148 5.741302328047333e-18
Rsub_67_153 sn_67 sn_153 473225.6713264248
Csub_67_153 sn_67 sn_153 2.226524075225428e-17
Rsub_67_204 sn_67 sn_204 818221.5304316113
Csub_67_204 sn_67 sn_204 1.287729925252885e-17
Rsub_67_215 sn_67 sn_215 911817.4379988217
Csub_67_215 sn_67 sn_215 1.155547488251e-17
Rsub_67_99 sn_67 sn_99 211069.2520199316
Csub_67_99 sn_67 sn_99 4.9919556739771e-17
Rsub_67_178 sn_67 sn_178 1054599.530063771
Csub_67_178 sn_67 sn_178 9.990980653663735e-18
Rsub_67_131 sn_67 sn_131 170573.1913308345
Csub_67_131 sn_67 sn_131 6.177104045496817e-17
Rsub_67_208 sn_67 sn_208 12632308.24745944
Csub_67_208 sn_67 sn_208 8.340901200181733e-19
Rsub_67_129 sn_67 sn_129 36116.80453663016
Csub_67_129 sn_67 sn_129 2.917335472340516e-16
Rsub_67_97 sn_67 sn_97 406366.6630482967
Csub_67_97 sn_67 sn_97 2.592851348383797e-17
Rsub_67_78 sn_67 sn_78 94527.60902914238
Csub_67_78 sn_67 sn_78 1.114646145231671e-16
Rsub_67_157 sn_67 sn_157 7267766.525722838
Csub_67_157 sn_67 sn_157 1.449755363623498e-18
Rsub_67_177 sn_67 sn_177 2943190.543972184
Csub_67_177 sn_67 sn_177 3.579952892893495e-18
Rsub_67_98 sn_67 sn_98 3796586.192715411
Csub_67_98 sn_67 sn_98 2.77525202047212e-18
Rsub_67_141 sn_67 sn_141 3208024.460478181
Csub_67_141 sn_67 sn_141 3.284414951330968e-18
Rsub_67_219 sn_67 sn_219 429549.6091531605
Csub_67_219 sn_67 sn_219 2.452914233352987e-17
Rsub_67_222 sn_67 sn_222 596123.8834040671
Csub_67_222 sn_67 sn_222 1.767498970526588e-17
Rsub_67_159 sn_67 sn_159 24505564.07339448
Csub_67_159 sn_67 sn_159 4.29962904370334e-19
Rsub_67_165 sn_67 sn_165 12297755.46244206
Csub_67_165 sn_67 sn_165 8.567810227166193e-19
Rsub_67_138 sn_67 sn_138 2629080.509123795
Csub_67_138 sn_67 sn_138 4.007668637633901e-18
Rsub_67_132 sn_67 sn_132 2677751.918957594
Csub_67_132 sn_67 sn_132 3.934824368021249e-18
Rsub_67_170 sn_67 sn_170 2834794.171324065
Csub_67_170 sn_67 sn_170 3.71684251675622e-18
Rsub_67_166 sn_67 sn_166 13112420.43642954
Csub_67_166 sn_67 sn_166 8.035498520896301e-19
Rsub_67_68 sn_67 sn_68 19904585.79430128
Csub_67_68 sn_67 sn_68 5.293495484466007e-19
Rsub_67_213 sn_67 sn_213 61944821.99529053
Csub_67_213 sn_67 sn_213 1.700946610683788e-19
Rsub_67_216 sn_67 sn_216 7827034.202843173
Csub_67_216 sn_67 sn_216 1.346165511631803e-18
Rsub_67_202 sn_67 sn_202 9268917.68455879
Csub_67_202 sn_67 sn_202 1.136754458374667e-18
Rsub_67_79 sn_67 sn_79 5359706.540522133
Csub_67_79 sn_67 sn_79 1.965869478593422e-18
Rsub_67_117 sn_67 sn_117 2731422.600098528
Csub_67_117 sn_67 sn_117 3.857507623261931e-18
Rsub_67_229 sn_67 sn_229 13748099.52956226
Csub_67_229 sn_67 sn_229 7.663956374169111e-19
Rsub_67_71 sn_67 sn_71 18633617.68396828
Csub_67_71 sn_67 sn_71 5.654556018553085e-19
Rsub_67_150 sn_67 sn_150 19110338.79678362
Csub_67_150 sn_67 sn_150 5.513499061567319e-19
Rsub_67_160 sn_67 sn_160 1507939.307031863
Csub_67_160 sn_67 sn_160 6.98733924707446e-18
Rsub_67_174 sn_67 sn_174 9492025.604590267
Csub_67_174 sn_67 sn_174 1.110035301330692e-18
Rsub_67_192 sn_67 sn_192 8551040.323423011
Csub_67_192 sn_67 sn_192 1.232187325016871e-18
Rsub_67_183 sn_67 sn_183 12839708.96283207
Csub_67_183 sn_67 sn_183 8.206170040715591e-19
Rsub_67_85 sn_67 sn_85 4783889.968441095
Csub_67_85 sn_67 sn_85 2.202492860776118e-18
Rsub_67_214 sn_67 sn_214 15852693.24760065
Csub_67_214 sn_67 sn_214 6.646494281862625e-19
Rsub_67_135 sn_67 sn_135 23682572.94819601
Csub_67_135 sn_67 sn_135 4.449045095428537e-19
Rsub_67_130 sn_67 sn_130 23827568.64061968
Csub_67_130 sn_67 sn_130 4.421971734148357e-19
Rsub_67_200 sn_67 sn_200 2004996.613353946
Csub_67_200 sn_67 sn_200 5.255112867549754e-18
Rsub_67_152 sn_67 sn_152 10959910.75377935
Csub_67_152 sn_67 sn_152 9.613658120889955e-19
Rsub_67_93 sn_67 sn_93 249005257.0314009
Csub_67_93 sn_67 sn_93 4.231430142417151e-20
Rsub_67_168 sn_67 sn_168 24262554.68071213
Csub_67_168 sn_67 sn_168 4.342693356444502e-19
Rsub_67_139 sn_67 sn_139 11145962.20440949
Csub_67_139 sn_67 sn_139 9.453184309257415e-19
Rsub_67_182 sn_67 sn_182 23682572.94819601
Csub_67_182 sn_67 sn_182 4.449045095428537e-19
Rsub_67_224 sn_67 sn_224 16934861.4751592
Csub_67_224 sn_67 sn_224 6.221771295670402e-19
Rsub_21_37 sn_21 sn_37 46519340.05922324
Csub_21_37 sn_21 sn_37 2.264968395685778e-19
Rsub_21_69 sn_21 sn_69 30868341.23909553
Csub_21_69 sn_21 sn_69 3.413362389840787e-19
Rsub_21_67 sn_21 sn_67 25688562.99157912
Csub_21_67 sn_21 sn_67 4.101624332074911e-19
Rsub_21_161 sn_21 sn_161 78539145.55453274
Csub_21_161 sn_21 sn_161 1.341558203598499e-19
Rsub_21_68 sn_21 sn_68 78539145.55453274
Csub_21_68 sn_21 sn_68 1.341558203598499e-19
Rsub_21_205 sn_21 sn_205 46129808.60498089
Csub_21_205 sn_21 sn_205 2.284094346121419e-19
Rsub_21_127 sn_21 sn_127 75755401.8172594
Csub_21_127 sn_21 sn_127 1.390855734307447e-19
Rsub_21_164 sn_21 sn_164 49477549.6574611
Csub_21_164 sn_21 sn_164 2.129548365910462e-19
Rsub_21_110 sn_21 sn_110 34871380.62621254
Csub_21_110 sn_21 sn_110 3.021527485582206e-19
Rsub_21_146 sn_21 sn_146 9685143.251608316
Csub_21_146 sn_21 sn_146 1.087901668411596e-18
Rsub_21_58 sn_21 sn_58 22571137.04536654
Csub_21_58 sn_21 sn_58 4.668122603239855e-19
Rsub_21_135 sn_21 sn_135 11968706.57022807
Csub_21_135 sn_21 sn_135 8.803360196363491e-19
Rsub_21_64 sn_21 sn_64 3302545.319966209
Csub_21_64 sn_21 sn_64 3.190412994041157e-18
Rsub_21_117 sn_21 sn_117 39311475.43365254
Csub_21_117 sn_21 sn_117 2.680256435557302e-19
Rsub_21_78 sn_21 sn_78 11925856.56945865
Csub_21_78 sn_21 sn_78 8.834990963427529e-19
Rsub_21_95 sn_21 sn_95 16925547.0280388
Csub_21_95 sn_21 sn_95 6.225195253527286e-19
Rsub_21_154 sn_21 sn_154 12276788.66052787
Csub_21_154 sn_21 sn_154 8.582442683978693e-19
Rsub_21_97 sn_21 sn_97 16414935.04263867
Csub_21_97 sn_21 sn_97 6.418839596295036e-19
Rsub_21_76 sn_21 sn_76 78974131.59145015
Csub_21_76 sn_21 sn_76 1.334168960127027e-19
Rsub_21_184 sn_21 sn_184 78974131.59145015
Csub_21_184 sn_21 sn_184 1.334168960127027e-19
Rsub_21_86 sn_21 sn_86 29493779.99389366
Csub_21_86 sn_21 sn_86 3.572442563961438e-19
Rsub_21_206 sn_21 sn_206 78974131.59145015
Csub_21_206 sn_21 sn_206 1.334168960127027e-19
Rsub_21_39 sn_21 sn_39 120348631.5490182
Csub_21_39 sn_21 sn_39 8.754967436367132e-20
Rsub_21_70 sn_21 sn_70 45806721.35975686
Csub_21_70 sn_21 sn_70 2.300204683823266e-19
Rsub_21_96 sn_21 sn_96 112712573.7273686
Csub_21_96 sn_21 sn_96 9.348099465562603e-20
Rsub_21_79 sn_21 sn_79 20973284.21796204
Csub_21_79 sn_21 sn_79 5.023764229164595e-19
Rsub_21_120 sn_21 sn_120 39816574.00673477
Csub_21_120 sn_21 sn_120 2.646255677459293e-19
Rsub_21_182 sn_21 sn_182 5132160.954307684
Csub_21_182 sn_21 sn_182 2.053030603684827e-18
Rsub_21_183 sn_21 sn_183 9720956.872908631
Csub_21_183 sn_21 sn_183 1.083893657793521e-18
Rsub_21_156 sn_21 sn_156 13908417.13205569
Csub_21_156 sn_21 sn_156 7.575616550891214e-19
Rsub_21_148 sn_21 sn_148 7725604.406634317
Csub_21_148 sn_21 sn_148 1.363839377173113e-18
Rsub_21_24 sn_21 sn_24 144253594.6179291
Csub_21_24 sn_21 sn_24 7.304139304214214e-20
Rsub_21_191 sn_21 sn_191 38960571.58511541
Csub_21_191 sn_21 sn_191 2.704396540798027e-19
Rsub_21_131 sn_21 sn_131 32285568.79822381
Csub_21_131 sn_21 sn_131 3.263527295455196e-19
Rsub_21_103 sn_21 sn_103 31084675.22158026
Csub_21_103 sn_21 sn_103 3.38960707394335e-19
Rsub_21_115 sn_21 sn_115 186797699.0870493
Csub_21_115 sn_21 sn_115 5.640585271513387e-20
Rsub_21_123 sn_21 sn_123 76895864.97062251
Csub_21_123 sn_21 sn_123 1.370227580671e-19
Rsub_21_179 sn_21 sn_179 73176716.16345769
Csub_21_179 sn_21 sn_179 1.439868315311423e-19
Rsub_21_174 sn_21 sn_174 36226037.23187015
Csub_21_174 sn_21 sn_174 2.908538804503973e-19
Rsub_21_77 sn_21 sn_77 28312180.06834079
Csub_21_77 sn_21 sn_77 3.721537330151447e-19
Rsub_21_209 sn_21 sn_209 21542555.85081369
Csub_21_209 sn_21 sn_209 4.891009021955035e-19
Rsub_21_42 sn_21 sn_42 6584429.306464901
Csub_21_42 sn_21 sn_42 1.600212108266511e-18
Rsub_21_162 sn_21 sn_162 3140312.118703145
Csub_21_162 sn_21 sn_162 3.355234481144905e-18
Rsub_21_130 sn_21 sn_130 3785065.029326726
Csub_21_130 sn_21 sn_130 2.783699466348189e-18
Rsub_21_153 sn_21 sn_153 13429159.40231546
Csub_21_153 sn_21 sn_153 7.845973963503103e-19
Rsub_21_199 sn_21 sn_199 49643381.19872605
Csub_21_199 sn_21 sn_199 2.122434702836153e-19
Rsub_21_32 sn_21 sn_32 2601810.865872306
Csub_21_32 sn_21 sn_32 4.049673110538511e-18
Rsub_21_171 sn_21 sn_171 7223928.619816566
Csub_21_171 sn_21 sn_171 1.458553102715673e-18
Rsub_21_177 sn_21 sn_177 41198532.68247873
Csub_21_177 sn_21 sn_177 2.557489992043103e-19
Rsub_21_181 sn_21 sn_181 9056926.465095112
Csub_21_181 sn_21 sn_181 1.163361935512783e-18
Rsub_21_140 sn_21 sn_140 14120495.62638226
Csub_21_140 sn_21 sn_140 7.461836879538415e-19
Rsub_21_213 sn_21 sn_213 3461767.435107773
Csub_21_213 sn_21 sn_213 3.043671679204521e-18
Rsub_21_169 sn_21 sn_169 12245684.94406044
Csub_21_169 sn_21 sn_169 8.604241861816427e-19
Rsub_21_165 sn_21 sn_165 39103978.40678874
Csub_21_165 sn_21 sn_165 2.694478651921716e-19
Rsub_21_53 sn_21 sn_53 25177550.64897507
Csub_21_53 sn_21 sn_53 4.184872328976497e-19
Rsub_21_132 sn_21 sn_132 19358974.3258418
Csub_21_132 sn_21 sn_132 5.442686851526591e-19
Rsub_21_54 sn_21 sn_54 39268699.49041863
Csub_21_54 sn_21 sn_54 2.68317607635589e-19
Rsub_21_221 sn_21 sn_221 1137701.413699179
Csub_21_221 sn_21 sn_221 9.261202786037819e-18
Rsub_21_142 sn_21 sn_142 77993.98000508558
Csub_21_142 sn_21 sn_142 1.350935482654299e-16
Rsub_21_158 sn_21 sn_158 8664881.868253075
Csub_21_158 sn_21 sn_158 1.215998517052404e-18
Rsub_21_60 sn_21 sn_60 37118811.54543898
Csub_21_60 sn_21 sn_60 2.838583204457332e-19
Rsub_21_227 sn_21 sn_227 6611460.761010421
Csub_21_227 sn_21 sn_227 1.59366952071568e-18
Rsub_21_138 sn_21 sn_138 5529336.301918758
Csub_21_138 sn_21 sn_138 1.90556025658517e-18
Rsub_21_50 sn_21 sn_50 20767510.50236023
Csub_21_50 sn_21 sn_50 5.073541915884683e-19
Rsub_21_217 sn_21 sn_217 114936433.068723
Csub_21_217 sn_21 sn_217 9.167226806081589e-20
Rsub_21_31 sn_21 sn_31 17008710.25222864
Csub_21_31 sn_21 sn_31 6.194757477774903e-19
Rsub_21_198 sn_21 sn_198 1066663.36078798
Csub_21_198 sn_21 sn_198 9.87798389779353e-18
Rsub_21_74 sn_21 sn_74 27987474.38436743
Csub_21_74 sn_21 sn_74 3.7647139422181e-19
Rsub_21_185 sn_21 sn_185 8839051.562071595
Csub_21_185 sn_21 sn_185 1.192037791412157e-18
Rsub_21_222 sn_21 sn_222 358094.4280073656
Csub_21_222 sn_21 sn_222 2.942375719404737e-17
Rsub_21_33 sn_21 sn_33 8304852.499616163
Csub_21_33 sn_21 sn_33 1.268714104521059e-18
Rsub_21_200 sn_21 sn_200 2450908.454136843
Csub_21_200 sn_21 sn_200 4.299011447957456e-18
Rsub_21_219 sn_21 sn_219 4392131.857653975
Csub_21_219 sn_21 sn_219 2.398945169159376e-18
Rsub_21_52 sn_21 sn_52 133893.1536417565
Csub_21_52 sn_21 sn_52 7.86932207932105e-17
Rsub_21_152 sn_21 sn_152 9149165.222875966
Csub_21_152 sn_21 sn_152 1.151633317964931e-18
Rsub_21_59 sn_21 sn_59 1249686.426494905
Csub_21_59 sn_21 sn_59 8.431301868087434e-18
Rsub_21_226 sn_21 sn_226 136486.4968876195
Csub_21_226 sn_21 sn_226 7.719799205415573e-17
Rsub_21_211 sn_21 sn_211 3045441.9489132
Csub_21_211 sn_21 sn_211 3.459755161640846e-18
Rsub_21_44 sn_21 sn_44 879181.4876043733
Csub_21_44 sn_21 sn_44 1.198442375184697e-17
Rsub_21_35 sn_21 sn_35 345519.4574368774
Csub_21_35 sn_21 sn_35 3.049461694687599e-17
Rsub_21_202 sn_21 sn_202 76895864.97062251
Csub_21_202 sn_21 sn_202 1.370227580671e-19
Rsub_21_229 sn_21 sn_229 453406481.7242634
Csub_21_229 sn_21 sn_229 2.323849333198925e-20
Rsub_21_34 sn_21 sn_34 9129846.845837254
Csub_21_34 sn_21 sn_34 1.154070126273159e-18
Rsub_21_190 sn_21 sn_190 18848478.47034065
Csub_21_190 sn_21 sn_190 5.59009764040629e-19
Rsub_21_23 sn_21 sn_23 12852133.64399138
Csub_21_23 sn_21 sn_23 8.198236801837186e-19
Rsub_21_57 sn_21 sn_57 32121296.16068333
Csub_21_57 sn_21 sn_57 3.280217413868474e-19
Rsub_21_224 sn_21 sn_224 756875.3639210331
Csub_21_224 sn_21 sn_224 1.392102848696936e-17
Rsub_21_66 sn_21 sn_66 18911156.37176641
Csub_21_66 sn_21 sn_66 5.571570185925037e-19
Rsub_21_166 sn_21 sn_166 134720.3743518458
Csub_21_166 sn_21 sn_166 7.821002244777122e-17
Rsub_21_144 sn_21 sn_144 10868147.48562111
Csub_21_144 sn_21 sn_144 9.694829331466184e-19
Rsub_21_56 sn_21 sn_56 4730504.072619046
Csub_21_56 sn_21 sn_56 2.22734899716437e-18
Rsub_21_223 sn_21 sn_223 26854483.35703375
Csub_21_223 sn_21 sn_223 3.923547275941273e-19
Rsub_21_218 sn_21 sn_218 50383.06015344781
Csub_21_218 sn_21 sn_218 2.091275017861131e-16
Rsub_21_215 sn_21 sn_215 5132027.702968957
Csub_21_215 sn_21 sn_215 2.053083909920144e-18
Rsub_21_48 sn_21 sn_48 5545100.522850185
Csub_21_48 sn_21 sn_48 1.900142920549661e-18
Rsub_21_160 sn_21 sn_160 60683.63388697342
Csub_21_160 sn_21 sn_160 1.736297388164785e-16
Rsub_21_49 sn_21 sn_49 154001480.1445508
Csub_21_49 sn_21 sn_49 6.841806645195952e-20
Rsub_21_216 sn_21 sn_216 4157031.791863167
Csub_21_216 sn_21 sn_216 2.534617012757458e-18
Rsub_21_137 sn_21 sn_137 9193229.36405508
Csub_21_137 sn_21 sn_137 1.146113415099481e-18
Rsub_21_230 sn_21 0 121949.8377025698
Csub_21_230 sn_21 0 8.640014370439765e-17
Rsub_21_151 sn_21 sn_151 37027899.51426958
Csub_21_151 sn_21 sn_151 2.845552580742399e-19
Rsub_21_192 sn_21 sn_192 610926.6428931279
Csub_21_192 sn_21 sn_192 1.724672450416145e-17
Rsub_21_25 sn_21 sn_25 159056.5627497409
Csub_21_25 sn_21 sn_25 6.624362629291866e-17
Rsub_21_208 sn_21 sn_208 3525430.171542399
Csub_21_208 sn_21 sn_208 2.988708608464714e-18
Rsub_21_41 sn_21 sn_41 6409439.838350754
Csub_21_41 sn_21 sn_41 1.643900835012939e-18
Rsub_21_172 sn_21 sn_172 76219220.02430654
Csub_21_172 sn_21 sn_172 1.382391934589449e-19
Rsub_21_93 sn_21 sn_93 1569537.941596064
Csub_21_93 sn_21 sn_93 6.713111689109885e-18
Rsub_21_141 sn_21 sn_141 2484109.699325236
Csub_21_141 sn_21 sn_141 4.241553223310567e-18
Rsub_21_22 sn_21 sn_22 18115420.92987946
Csub_21_22 sn_21 sn_22 5.81630619736315e-19
Rsub_21_101 sn_21 sn_101 6086874.129335833
Csub_21_101 sn_21 sn_101 1.731017149089575e-18
Rsub_21_186 sn_21 sn_186 8389820.472575473
Csub_21_186 sn_21 sn_186 1.255865192428314e-18
Rsub_21_30 sn_21 sn_30 4078009.063064395
Csub_21_30 sn_21 sn_30 2.583732242692081e-18
Rsub_21_197 sn_21 sn_197 5269775.404535154
Csub_21_197 sn_21 sn_197 1.99941794353557e-18
Rsub_21_228 sn_21 sn_228 14773599.18595392
Csub_21_228 sn_21 sn_228 7.131967890564962e-19
Rsub_21_207 sn_21 sn_207 1614636.661550946
Csub_21_207 sn_21 sn_207 6.525606505248766e-18
Rsub_21_128 sn_21 sn_128 141796461.9948409
Csub_21_128 sn_21 sn_128 7.430709732809382e-20
Rsub_21_45 sn_21 sn_45 405944.6373914503
Csub_21_45 sn_21 sn_45 2.595546912489381e-17
Rsub_21_212 sn_21 sn_212 848947.4896748873
Csub_21_212 sn_21 sn_212 1.241123111897657e-17
Rsub_21_155 sn_21 sn_155 759821.4698338005
Csub_21_155 sn_21 sn_155 1.386705156480337e-17
Rsub_21_170 sn_21 sn_170 16242067.89009421
Csub_21_170 sn_21 sn_170 6.487156422154868e-19
Rsub_21_125 sn_21 sn_125 12136192.26361288
Csub_21_125 sn_21 sn_125 8.681869299171227e-19
Rsub_21_195 sn_21 sn_195 2025234.051192831
Csub_21_195 sn_21 sn_195 5.202600408591874e-18
Rsub_21_203 sn_21 sn_203 1649781.970750834
Csub_21_203 sn_21 sn_203 6.386591494532294e-18
Rsub_21_36 sn_21 sn_36 22555360.62002984
Csub_21_36 sn_21 sn_36 4.671387737810445e-19
Rsub_21_196 sn_21 sn_196 1494908.884374223
Csub_21_196 sn_21 sn_196 7.048244620367366e-18
Rsub_21_43 sn_21 sn_43 4519433.386775796
Csub_21_43 sn_21 sn_43 2.331372674517241e-18
Rsub_21_122 sn_21 sn_122 69567109.23219582
Csub_21_122 sn_21 sn_122 1.514578314165984e-19
Rsub_21_159 sn_21 sn_159 10841122.28549708
Csub_21_159 sn_21 sn_159 9.718997004881484e-19
Rsub_21_214 sn_21 sn_214 5754580.645188328
Csub_21_214 sn_21 sn_214 1.830973297948313e-18
Rsub_21_47 sn_21 sn_47 24906241.13307281
Csub_21_47 sn_21 sn_47 4.23045912305036e-19
Rsub_21_84 sn_21 sn_84 11487340.25802225
Csub_21_84 sn_21 sn_84 9.172256819738396e-19
Rsub_160_163 sn_160 sn_163 3082190.072627132
Csub_160_163 sn_160 sn_163 3.418505430863689e-18
Rsub_160_217 sn_160 sn_217 7467260.293350052
Csub_160_217 sn_160 sn_217 1.411024001883695e-18
Rsub_160_202 sn_160 sn_202 4247608.881079562
Csub_160_202 sn_160 sn_202 2.480568196653754e-18
Rsub_160_191 sn_160 sn_191 116897.0504191853
Csub_160_191 sn_160 sn_191 9.013472508028945e-17
Rsub_160_168 sn_160 sn_168 3869394.32962399
Csub_160_168 sn_160 sn_168 2.723031721415141e-18
Rsub_160_204 sn_160 sn_204 9270831.365118437
Csub_160_204 sn_160 sn_204 1.136519810065102e-18
Rsub_160_180 sn_160 sn_180 1559001.199732445
Csub_160_180 sn_160 sn_180 6.758483254559562e-18
Rsub_160_201 sn_160 sn_201 10052221.02015609
Csub_160_201 sn_160 sn_201 1.048174675139245e-18
Rsub_160_190 sn_160 sn_190 2127499.158958998
Csub_160_190 sn_160 sn_190 4.952520642774584e-18
Rsub_160_169 sn_160 sn_169 1085872.872149703
Csub_160_169 sn_160 sn_169 9.703238539674466e-18
Rsub_160_214 sn_160 sn_214 581338.2677749057
Csub_160_214 sn_160 sn_214 1.812453107991461e-17
Rsub_160_206 sn_160 sn_206 1563261.60894188
Csub_160_206 sn_160 sn_206 6.740064133834772e-18
Rsub_160_183 sn_160 sn_183 1352676.862930318
Csub_160_183 sn_160 sn_183 7.789357377936301e-18
Rsub_160_229 sn_160 sn_229 39819954.01750362
Csub_160_229 sn_160 sn_229 2.646031057092253e-19
Rsub_160_200 sn_160 sn_200 1122288.325027906
Csub_160_200 sn_160 sn_200 9.388392685959743e-18
Rsub_160_165 sn_160 sn_165 50297619.06899941
Csub_160_165 sn_160 sn_165 2.094827488310294e-19
Rsub_160_216 sn_160 sn_216 513280.4210782117
Csub_160_216 sn_160 sn_216 2.052773312509516e-17
Rsub_160_199 sn_160 sn_199 21583727.9855653
Csub_160_199 sn_160 sn_199 4.881679156296149e-19
Rsub_160_162 sn_160 sn_162 524013.3938783465
Csub_160_162 sn_160 sn_162 2.010727898431566e-17
Rsub_160_213 sn_160 sn_213 291521.1665233187
Csub_160_213 sn_160 sn_213 3.614311656298614e-17
Rsub_160_218 sn_160 sn_218 22020.34948638312
Csub_160_218 sn_160 sn_218 4.784884776122885e-16
Rsub_160_181 sn_160 sn_181 955961.7590576658
Csub_160_181 sn_160 sn_181 1.10218671431128e-17
Rsub_160_207 sn_160 sn_207 165860.603272419
Csub_160_207 sn_160 sn_207 6.352613757785674e-17
Rsub_160_170 sn_160 sn_170 704379.8507374906
Csub_160_170 sn_160 sn_170 1.495852485160987e-17
Rsub_160_177 sn_160 sn_177 1740950.775840316
Csub_160_177 sn_160 sn_177 6.052143258986911e-18
Rsub_160_197 sn_160 sn_197 153607.2816573918
Csub_160_197 sn_160 sn_197 6.85936460078159e-17
Rsub_160_227 sn_160 sn_227 120338.0798425289
Csub_160_227 sn_160 sn_227 8.755735105643827e-17
Rsub_160_208 sn_160 sn_208 261565.6868303692
Csub_160_208 sn_160 sn_208 4.028236130629447e-17
Rsub_160_171 sn_160 sn_171 2030697.573477611
Csub_160_171 sn_160 sn_171 5.188602990343884e-18
Rsub_160_166 sn_160 sn_166 2889.319243486162
Csub_160_166 sn_160 sn_166 3.646701044193722e-15
Rsub_160_203 sn_160 sn_203 82355.66364600456
Csub_160_203 sn_160 sn_203 1.279387844838425e-16
Rsub_160_198 sn_160 sn_198 1559477.016941916
Csub_160_198 sn_160 sn_198 6.756421151298341e-18
Rsub_160_215 sn_160 sn_215 182432.5875475233
Csub_160_215 sn_160 sn_215 5.775549009019713e-17
Rsub_160_178 sn_160 sn_178 6510797.453780404
Csub_160_178 sn_160 sn_178 1.618309212815726e-18
Rsub_160_212 sn_160 sn_212 68801.8057570802
Csub_160_212 sn_160 sn_212 1.531425430813743e-16
Rsub_160_192 sn_160 sn_192 22101.01766957543
Csub_160_192 sn_160 sn_192 4.767420061717189e-16
Rsub_160_226 sn_160 sn_226 20147.37101545239
Csub_160_226 sn_160 sn_226 5.229706394024737e-16
Rsub_160_186 sn_160 sn_186 23281.49944203054
Csub_160_186 sn_160 sn_186 4.525689390610418e-16
Rsub_160_222 sn_160 sn_222 25147.41556560691
Csub_160_222 sn_160 sn_222 4.18988721713428e-16
Rsub_160_230 sn_160 0 21533.05830889019
Csub_160_230 sn_160 0 4.893166289286406e-16
Rsub_160_221 sn_160 sn_221 179986.6689932972
Csub_160_221 sn_160 sn_221 5.854035502275106e-17
Rsub_160_184 sn_160 sn_184 2787414.434804542
Csub_160_184 sn_160 sn_184 3.78002042705531e-18
Rsub_160_211 sn_160 sn_211 502841.3591619704
Csub_160_211 sn_160 sn_211 2.095389193878161e-17
Rsub_160_174 sn_160 sn_174 1364237.284121729
Csub_160_174 sn_160 sn_174 7.723351080390092e-18
Rsub_160_195 sn_160 sn_195 991823.6925091441
Csub_160_195 sn_160 sn_195 1.062334322300217e-17
Rsub_160_224 sn_160 sn_224 828850.5302257866
Csub_160_224 sn_160 sn_224 1.271216355421739e-17
Rsub_160_164 sn_160 sn_164 3223744.931148367
Csub_160_164 sn_160 sn_164 3.268398625593706e-18
Rsub_160_196 sn_160 sn_196 485337.7111190616
Csub_160_196 sn_160 sn_196 2.17095916118606e-17
Rsub_160_219 sn_160 sn_219 1502177.209423621
Csub_160_219 sn_160 sn_219 7.014141498174376e-18
Rsub_160_182 sn_160 sn_182 467880.5378401926
Csub_160_182 sn_160 sn_182 2.251960201394143e-17
Rsub_160_209 sn_160 sn_209 14624552.30353142
Csub_160_209 sn_160 sn_209 7.204653710791362e-19
Rsub_74_215 sn_74 sn_215 12302509.47414958
Csub_74_215 sn_74 sn_215 8.564499401012122e-19
Rsub_74_154 sn_74 sn_154 14482476.28795619
Csub_74_154 sn_74 sn_154 7.275332817905094e-19
Rsub_74_131 sn_74 sn_131 39220377.95229615
Csub_74_131 sn_74 sn_131 2.686481888329978e-19
Rsub_74_86 sn_74 sn_86 2477741.416641421
Csub_74_86 sn_74 sn_86 4.252454849187694e-18
Rsub_74_156 sn_74 sn_156 2184235.605082334
Csub_74_156 sn_74 sn_156 4.823876818834676e-18
Rsub_74_77 sn_74 sn_77 2792886.698947736
Csub_74_77 sn_74 sn_77 3.772614014811195e-18
Rsub_74_176 sn_74 sn_176 32112204.49007954
Csub_74_176 sn_74 sn_176 3.281146115485484e-19
Rsub_74_192 sn_74 sn_192 9003680.799472589
Csub_74_192 sn_74 sn_192 1.170241786320013e-18
Rsub_74_177 sn_74 sn_177 2312969.942761272
Csub_74_177 sn_74 sn_177 4.555391450375411e-18
Rsub_74_138 sn_74 sn_138 4425057.103360306
Csub_74_138 sn_74 sn_138 2.381095487836482e-18
Rsub_74_166 sn_74 sn_166 2746160.528393926
Csub_74_166 sn_74 sn_166 3.836805384568031e-18
Rsub_74_140 sn_74 sn_140 10578338.84941741
Csub_74_140 sn_74 sn_140 9.960432967989375e-19
Rsub_74_130 sn_74 sn_130 6856707.584995423
Csub_74_130 sn_74 sn_130 1.536668054109097e-18
Rsub_74_175 sn_74 sn_175 13939955.2706031
Csub_74_175 sn_74 sn_175 7.558477267462672e-19
Rsub_74_132 sn_74 sn_132 4382056.853536212
Csub_74_132 sn_74 sn_132 2.404460702906517e-18
Rsub_74_150 sn_74 sn_150 51908333.73881117
Csub_74_150 sn_74 sn_150 2.029825028722124e-19
Rsub_74_218 sn_74 sn_218 2610949.742716362
Csub_74_218 sn_74 sn_218 4.035498397325766e-18
Rsub_74_199 sn_74 sn_199 11675217.89434598
Csub_74_199 sn_74 sn_199 9.024656839451841e-19
Rsub_74_120 sn_74 sn_120 48531441.94804708
Csub_74_120 sn_74 sn_120 2.171063351777042e-19
Rsub_74_169 sn_74 sn_169 33730235.87259278
Csub_74_169 sn_74 sn_169 3.123750317676056e-19
Rsub_74_183 sn_74 sn_183 14712763.01338305
Csub_74_183 sn_74 sn_183 7.161458043363972e-19
Rsub_74_101 sn_74 sn_101 5797199.452023123
Csub_74_101 sn_74 sn_101 1.817512678221369e-18
Rsub_74_181 sn_74 sn_181 4163811.90726004
Csub_74_181 sn_74 sn_181 2.530489786020003e-18
Rsub_74_128 sn_74 sn_128 11603112.40862726
Csub_74_128 sn_74 sn_128 9.080738969998957e-19
Rsub_74_221 sn_74 sn_221 8810570.115305074
Csub_74_221 sn_74 sn_221 1.19589122659915e-18
Rsub_74_164 sn_74 sn_164 359564.6433194104
Csub_74_164 sn_74 sn_164 2.930344709357359e-17
Rsub_74_195 sn_74 sn_195 4649956.805512892
Csub_74_195 sn_74 sn_195 2.265931479135068e-18
Rsub_74_116 sn_74 sn_116 945426.3021375734
Csub_74_116 sn_74 sn_116 1.114469047286648e-17
Rsub_74_148 sn_74 sn_148 9743687.226950031
Csub_74_148 sn_74 sn_148 1.081365119468037e-18
Rsub_74_227 sn_74 sn_227 4020388.832077725
Csub_74_227 sn_74 sn_227 2.62076230491984e-18
Rsub_74_230 sn_74 0 163250.163301695
Csub_74_230 sn_74 0 6.454194770242293e-17
Rsub_74_159 sn_74 sn_159 32112204.49007954
Csub_74_159 sn_74 sn_159 3.281146115485484e-19
Rsub_74_80 sn_74 sn_80 8589426.205337711
Csub_74_80 sn_74 sn_80 1.226680717704092e-18
Rsub_74_202 sn_74 sn_202 17604140.78818703
Csub_74_202 sn_74 sn_202 5.985230196125412e-19
Rsub_74_123 sn_74 sn_123 60010.42830147147
Csub_74_123 sn_74 sn_123 1.755775421114874e-16
Rsub_74_160 sn_74 sn_160 828168.410428297
Csub_74_160 sn_74 sn_160 1.27226339106329e-17
Rsub_74_118 sn_74 sn_118 881383.5392907744
Csub_74_118 sn_74 sn_118 1.195448182604865e-17
Rsub_74_197 sn_74 sn_197 4580959.017575044
Csub_74_197 sn_74 sn_197 2.300060633986537e-18
Rsub_74_184 sn_74 sn_184 686333.434898946
Csub_74_184 sn_74 sn_184 1.535184353037e-17
Rsub_74_93 sn_74 sn_93 40932.1241114678
Csub_74_93 sn_74 sn_93 2.574135530698744e-16
Rsub_74_147 sn_74 sn_147 14444095.16705171
Csub_74_147 sn_74 sn_147 7.294664968882697e-19
Rsub_74_226 sn_74 sn_226 2531203.949507467
Csub_74_226 sn_74 sn_226 4.162637113568125e-18
Rsub_74_186 sn_74 sn_186 3754333.943592393
Csub_74_186 sn_74 sn_186 2.80648542738529e-18
Rsub_74_84 sn_74 sn_84 118762.4357044537
Csub_74_84 sn_74 sn_84 8.87189913185224e-17
Rsub_74_158 sn_74 sn_158 565315.039877288
Csub_74_158 sn_74 sn_158 1.863825081412505e-17
Rsub_74_153 sn_74 sn_153 4164385.948806192
Csub_74_153 sn_74 sn_153 2.530140969582923e-18
Rsub_74_222 sn_74 sn_222 508709.7113803718
Csub_74_222 sn_74 sn_222 2.07121729082771e-17
Rsub_74_171 sn_74 sn_171 39473.16843099485
Csub_74_171 sn_74 sn_171 2.669277365116861e-16
Rsub_74_208 sn_74 sn_208 293984.2195618069
Csub_74_208 sn_74 sn_208 3.584030298610917e-17
Rsub_74_155 sn_74 sn_155 543797.7615861912
Csub_74_155 sn_74 sn_155 1.937573900910584e-17
Rsub_74_76 sn_74 sn_76 13879506.82219326
Csub_74_76 sn_74 sn_76 7.591396176542972e-19
Rsub_74_224 sn_74 sn_224 605435.4530201112
Csub_74_224 sn_74 sn_224 1.740314917084977e-17
Rsub_74_146 sn_74 sn_146 93478.27716296531
Csub_74_146 sn_74 sn_146 1.127158503773152e-16
Rsub_74_135 sn_74 sn_135 6284668.338545315
Csub_74_135 sn_74 sn_135 1.676537716017141e-18
Rsub_74_212 sn_74 sn_212 1742925.864599047
Csub_74_212 sn_74 sn_212 6.045284952297084e-18
Rsub_74_216 sn_74 sn_216 214438.0614489212
Csub_74_216 sn_74 sn_216 4.913532341710602e-17
Rsub_74_137 sn_74 sn_137 7035662.02166974
Csub_74_137 sn_74 sn_137 1.49758238382938e-18
Rsub_74_141 sn_74 sn_141 2084504.067675423
Csub_74_141 sn_74 sn_141 5.054671595810304e-18
Rsub_74_162 sn_74 sn_162 626383.3606939862
Csub_74_162 sn_74 sn_162 1.68211420727338e-17
Rsub_74_125 sn_74 sn_125 10125943.36893943
Csub_74_125 sn_74 sn_125 1.040543396139255e-18
Rsub_74_206 sn_74 sn_206 156603159.9785417
Csub_74_206 sn_74 sn_206 6.728142333573437e-20
Rsub_74_144 sn_74 sn_144 64389211.04195596
Csub_74_144 sn_74 sn_144 1.636374065115417e-19
Rsub_74_198 sn_74 sn_198 14789525.25519201
Csub_74_198 sn_74 sn_198 7.124287845907064e-19
Rsub_93_99 sn_93 sn_99 10836055.03956373
Csub_93_99 sn_93 sn_99 9.723541882871617e-19
Rsub_93_177 sn_93 sn_177 719544.0946418555
Csub_93_177 sn_93 sn_177 1.464327701483591e-17
Rsub_93_127 sn_93 sn_127 766337.5799965946
Csub_93_127 sn_93 sn_127 1.374914107993611e-17
Rsub_93_200 sn_93 sn_200 3538303.686388157
Csub_93_200 sn_93 sn_200 2.977834701629433e-18
Rsub_93_189 sn_93 sn_189 1223128.47165135
Csub_93_189 sn_93 sn_189 8.614371872158822e-18
Rsub_93_196 sn_93 sn_196 4923872.064545992
Csub_93_196 sn_93 sn_196 2.139877593103452e-18
Rsub_93_110 sn_93 sn_110 34363896.91647555
Csub_93_110 sn_93 sn_110 3.066149199504306e-19
Rsub_93_218 sn_93 sn_218 217064.2164857899
Csub_93_218 sn_93 sn_218 4.854085888873245e-17
Rsub_93_139 sn_93 sn_139 1465721.730553234
Csub_93_139 sn_93 sn_139 7.188597455161578e-18
Rsub_93_207 sn_93 sn_207 121944.751414077
Csub_93_207 sn_93 sn_207 8.640374743519874e-17
Rsub_93_128 sn_93 sn_128 3123658.723139545
Csub_93_128 sn_93 sn_128 3.373122493881128e-18
Rsub_93_168 sn_93 sn_168 5407326.408621133
Csub_93_168 sn_93 sn_168 1.948556958838518e-18
Rsub_93_146 sn_93 sn_146 304786.795922292
Csub_93_146 sn_93 sn_146 3.457001301629998e-17
Rsub_93_141 sn_93 sn_141 575886.0629007856
Csub_93_141 sn_93 sn_141 1.829612519038378e-17
Rsub_93_214 sn_93 sn_214 909970.2447120495
Csub_93_214 sn_93 sn_214 1.157893190844296e-17
Rsub_93_135 sn_93 sn_135 633485.5101371085
Csub_93_135 sn_93 sn_135 1.663255644150335e-17
Rsub_93_158 sn_93 sn_158 214815.5732781118
Csub_93_158 sn_93 sn_158 4.904897415695698e-17
Rsub_93_198 sn_93 sn_198 9372525.981128352
Csub_93_198 sn_93 sn_198 1.124188241616538e-18
Rsub_93_212 sn_93 sn_212 1933766.768696376
Csub_93_212 sn_93 sn_212 5.448683715530512e-18
Rsub_93_133 sn_93 sn_133 65597507.03051435
Csub_93_133 sn_93 sn_133 1.606232306561389e-19
Rsub_93_138 sn_93 sn_138 5267376.332099331
Csub_93_138 sn_93 sn_138 2.000328595855358e-18
Rsub_93_186 sn_93 sn_186 77396.6267995994
Csub_93_186 sn_93 sn_186 1.361362108133185e-16
Rsub_93_107 sn_93 sn_107 9477558.474698236
Csub_93_107 sn_93 sn_107 1.1117297276887e-18
Rsub_93_142 sn_93 sn_142 973576.4941959829
Csub_93_142 sn_93 sn_142 1.082245058815993e-17
Rsub_93_221 sn_93 sn_221 1123451.980673086
Csub_93_221 sn_93 sn_221 9.378668321824805e-18
Rsub_93_216 sn_93 sn_216 114123.396198016
Csub_93_216 sn_93 sn_216 9.232535880677874e-17
Rsub_93_164 sn_93 sn_164 203936.7077376456
Csub_93_164 sn_93 sn_164 5.166545846069391e-17
Rsub_93_156 sn_93 sn_156 1477557.236365692
Csub_93_156 sn_93 sn_156 7.131015464515141e-18
Rsub_93_230 sn_93 0 30370.31109153938
Csub_93_230 sn_93 0 3.469336705334334e-16
Rsub_93_151 sn_93 sn_151 3372445.701088713
Csub_93_151 sn_93 sn_151 3.124285588594815e-18
Rsub_93_184 sn_93 sn_184 517246.1780875407
Csub_93_184 sn_93 sn_184 2.037034578232643e-17
Rsub_93_224 sn_93 sn_224 87497.96242415369
Csub_93_224 sn_93 sn_224 1.204197584756719e-16
Rsub_93_116 sn_93 sn_116 455035.6479476591
Csub_93_116 sn_93 sn_116 2.315529244742155e-17
Rsub_93_190 sn_93 sn_190 104690.9668753174
Csub_93_190 sn_93 sn_190 1.006436736302046e-16
Rsub_93_120 sn_93 sn_120 207801.6908620957
Csub_93_120 sn_93 sn_120 5.070451283874475e-17
Rsub_93_199 sn_93 sn_199 28478109.87497229
Csub_93_199 sn_93 sn_199 3.699853518540529e-19
Rsub_93_97 sn_93 sn_97 3954838.87697724
Csub_93_97 sn_93 sn_97 2.664200446588924e-18
Rsub_93_208 sn_93 sn_208 43030.45909868088
Csub_93_208 sn_93 sn_208 2.448610524481483e-16
Rsub_93_129 sn_93 sn_129 11510095.6498988
Csub_93_129 sn_93 sn_129 9.154123321575211e-19
Rsub_93_171 sn_93 sn_171 56160.67990926447
Csub_93_171 sn_93 sn_171 1.87613175610644e-16
Rsub_93_222 sn_93 sn_222 129061.3227256583
Csub_93_222 sn_93 sn_222 8.163935778519082e-17
Rsub_93_162 sn_93 sn_162 399857.1829760091
Csub_93_162 sn_93 sn_162 2.635061704734256e-17
Rsub_93_160 sn_93 sn_160 41373.38790211401
Csub_93_160 sn_93 sn_160 2.546681341919217e-16
Rsub_93_123 sn_93 sn_123 151759.5765268134
Csub_93_123 sn_93 sn_123 6.942878824103981e-17
Rsub_93_202 sn_93 sn_202 19018382.31433635
Csub_93_202 sn_93 sn_202 5.540157584426851e-19
Rsub_93_197 sn_93 sn_197 308164.175660767
Csub_93_197 sn_93 sn_197 3.419113684982243e-17
Rsub_93_118 sn_93 sn_118 1612651.511567781
Csub_93_118 sn_93 sn_118 6.533639429628961e-18
Rsub_93_166 sn_93 sn_166 97067.77118178819
Csub_93_166 sn_93 sn_166 1.085477020225107e-16
Rsub_93_155 sn_93 sn_155 209531.1863752441
Csub_93_155 sn_93 sn_155 5.028599171562212e-17
Rsub_93_226 sn_93 sn_226 122735.6046618502
Csub_93_226 sn_93 sn_226 8.584700039779937e-17
Rsub_93_140 sn_93 sn_140 2393390.24168812
Csub_93_140 sn_93 sn_140 4.402325754783034e-18
Rsub_93_132 sn_93 sn_132 235364.0306481828
Csub_93_132 sn_93 sn_132 4.476675332765572e-17
Rsub_93_211 sn_93 sn_211 7126619.301893612
Csub_93_211 sn_93 sn_211 1.478468689835917e-18
Rsub_93_192 sn_93 sn_192 592535.7917040406
Csub_93_192 sn_93 sn_192 1.778202034332596e-17
Rsub_93_124 sn_93 sn_124 3349868.280057973
Csub_93_124 sn_93 sn_124 3.14534262882947e-18
Rsub_93_203 sn_93 sn_203 1183315.428476386
Csub_93_203 sn_93 sn_203 8.904205293593247e-18
Rsub_93_131 sn_93 sn_131 642737.8822980509
Csub_93_131 sn_93 sn_131 1.639312664216673e-17
Rsub_93_210 sn_93 sn_210 1899334.15133588
Csub_93_210 sn_93 sn_210 5.547461722214207e-18
Rsub_93_170 sn_93 sn_170 452282.5569100039
Csub_93_170 sn_93 sn_170 2.329624112460869e-17
Rsub_93_181 sn_93 sn_181 2030349.969672139
Csub_93_181 sn_93 sn_181 5.189491299340593e-18
Rsub_93_102 sn_93 sn_102 19230888.03642106
Csub_93_102 sn_93 sn_102 5.478937572864617e-19
Rsub_93_227 sn_93 sn_227 391078.343206457
Csub_93_227 sn_93 sn_227 2.694212984498508e-17
Rsub_93_148 sn_93 sn_148 1122077.344956686
Csub_93_148 sn_93 sn_148 9.390157950864544e-18
Rsub_93_130 sn_93 sn_130 2874871.745190378
Csub_93_130 sn_93 sn_130 3.665027325082379e-18
Rsub_93_213 sn_93 sn_213 2547377.449059364
Csub_93_213 sn_93 sn_213 4.136208203507756e-18
Rsub_93_134 sn_93 sn_134 1740068.755613073
Csub_93_134 sn_93 sn_134 6.055211018669039e-18
Rsub_93_174 sn_93 sn_174 13844471.95782061
Csub_93_174 sn_93 sn_174 7.610606987634544e-19
Rsub_93_95 sn_93 sn_95 3691558.681597794
Csub_93_95 sn_93 sn_95 2.854209945179461e-18
Rsub_93_215 sn_93 sn_215 582862.3010779636
Csub_93_215 sn_93 sn_215 1.807714014569737e-17
Rsub_93_182 sn_93 sn_182 645021.2755865601
Csub_93_182 sn_93 sn_182 1.633509451707385e-17
Rsub_93_144 sn_93 sn_144 13484531.42282143
Csub_93_144 sn_93 sn_144 7.81375575601974e-19
Rsub_93_150 sn_93 sn_150 4740884.860165197
Csub_93_150 sn_93 sn_150 2.222471925180409e-18
Rsub_93_204 sn_93 sn_204 12927723.31703841
Csub_93_204 sn_93 sn_204 8.150300902822686e-19
Rsub_93_179 sn_93 sn_179 5528599.509981496
Csub_93_179 sn_93 sn_179 1.905814209042837e-18
Rsub_93_188 sn_93 sn_188 15588319.95713221
Csub_93_188 sn_93 sn_188 6.759216856726878e-19
Rsub_93_169 sn_93 sn_169 947626.9906854931
Csub_93_169 sn_93 sn_169 1.111880898897586e-17
Rsub_93_101 sn_93 sn_101 9184193.177918496
Csub_93_101 sn_93 sn_101 1.147241058426646e-18
Rsub_97_104 sn_97 sn_104 30746086.21918683
Csub_97_104 sn_97 sn_104 3.426934871357642e-19
Rsub_97_154 sn_97 sn_154 27865635.81030256
Csub_97_154 sn_97 sn_154 3.781174624529623e-19
Rsub_97_194 sn_97 sn_194 15100734.77753943
Csub_97_194 sn_97 sn_194 6.977464115124905e-19
Rsub_97_122 sn_97 sn_122 11865074.6466004
Csub_97_122 sn_97 sn_122 8.880250496568882e-19
Rsub_97_197 sn_97 sn_197 33320637.72224274
Csub_97_197 sn_97 sn_197 3.162149413243827e-19
Rsub_97_120 sn_97 sn_120 16660318.86112137
Csub_97_120 sn_97 sn_120 6.324298826487654e-19
Rsub_97_145 sn_97 sn_145 9258953.337452427
Csub_97_145 sn_97 sn_145 1.137977816521655e-18
Rsub_97_126 sn_97 sn_126 5052577.390933216
Csub_97_126 sn_97 sn_126 2.08536805811972e-18
Rsub_97_140 sn_97 sn_140 2853780.161082827
Csub_97_140 sn_97 sn_140 3.692114636550027e-18
Rsub_97_192 sn_97 sn_192 21672319.17498024
Csub_97_192 sn_97 sn_192 4.861724034774237e-19
Rsub_97_190 sn_97 sn_190 7980575.916555036
Csub_97_190 sn_97 sn_190 1.320266057537646e-18
Rsub_97_214 sn_97 sn_214 10980936.0824858
Csub_97_214 sn_97 sn_214 9.595250735531846e-19
Rsub_97_176 sn_97 sn_176 9954565.369403096
Csub_97_176 sn_97 sn_176 1.058457412376388e-18
Rsub_97_174 sn_97 sn_174 67320945.55689636
Csub_97_174 sn_97 sn_174 1.565112226970294e-19
Rsub_97_144 sn_97 sn_144 62430967.67195217
Csub_97_144 sn_97 sn_144 1.687701455725415e-19
Rsub_97_135 sn_97 sn_135 5993375.225514678
Csub_97_135 sn_97 sn_135 1.758021666551869e-18
Rsub_97_162 sn_97 sn_162 165771575.5899452
Csub_97_162 sn_97 sn_162 6.356025431219394e-20
Rsub_97_225 sn_97 sn_225 4834573.415293857
Csub_97_225 sn_97 sn_225 2.179402937371584e-18
Rsub_97_160 sn_97 sn_160 7333777.806715609
Csub_97_160 sn_97 sn_160 1.436706126081656e-18
Rsub_97_149 sn_97 sn_149 10087482.9490215
Csub_97_149 sn_97 sn_149 1.044510662915376e-18
Rsub_97_159 sn_97 sn_159 1946191.953417156
Csub_97_159 sn_97 sn_159 5.413897372111661e-18
Rsub_97_213 sn_97 sn_213 3816424.866047241
Csub_97_213 sn_97 sn_213 2.760825608272194e-18
Rsub_97_191 sn_97 sn_191 8496817.297007143
Csub_97_191 sn_97 sn_191 1.240050613532822e-18
Rsub_97_196 sn_97 sn_196 18701369.9110888
Csub_97_196 sn_97 sn_196 5.63407041961268e-19
Rsub_97_137 sn_97 sn_137 28337631.08372322
Csub_97_137 sn_97 sn_137 3.718194887603722e-19
Rsub_97_125 sn_97 sn_125 3023199.115542043
Csub_97_125 sn_97 sn_125 3.485209904985324e-18
Rsub_97_219 sn_97 sn_219 179072.5648832372
Csub_97_219 sn_97 sn_219 5.88391834846406e-17
Rsub_97_227 sn_97 sn_227 1086616.402473082
Csub_97_227 sn_97 sn_227 9.696598982170263e-18
Rsub_97_222 sn_97 sn_222 357069.517197038
Csub_97_222 sn_97 sn_222 2.950821337239986e-17
Rsub_97_152 sn_97 sn_152 3666609.929153518
Csub_97_152 sn_97 sn_152 2.87363087588171e-18
Rsub_97_211 sn_97 sn_211 2759958.519927051
Csub_97_211 sn_97 sn_211 3.817623861429806e-18
Rsub_97_127 sn_97 sn_127 204327.7927109259
Csub_97_127 sn_97 sn_127 5.156657037418576e-17
Rsub_97_206 sn_97 sn_206 670333.0874776964
Csub_97_206 sn_97 sn_206 1.571828050719721e-17
Rsub_97_164 sn_97 sn_164 38597405.99621014
Csub_97_164 sn_97 sn_164 2.729842389735874e-19
Rsub_97_165 sn_97 sn_165 2247210.246444307
Csub_97_165 sn_97 sn_165 4.688695024820914e-18
Rsub_97_230 sn_97 0 31980.55507442616
Csub_97_230 sn_97 0 3.294653103333936e-16
Rsub_97_151 sn_97 sn_151 3352636.432651198
Csub_97_151 sn_97 sn_151 3.142745631353162e-18
Rsub_97_228 sn_97 sn_228 10251250.4573201
Csub_97_228 sn_97 sn_228 1.027824219698605e-18
Rsub_97_157 sn_97 sn_157 1256102.730805261
Csub_97_157 sn_97 sn_157 8.388233895069462e-18
Rsub_97_184 sn_97 sn_184 11243274.66677113
Csub_97_184 sn_97 sn_184 9.371365384650782e-19
Rsub_97_105 sn_97 sn_105 127564.4380630893
Csub_97_105 sn_97 sn_105 8.259734187845517e-17
Rsub_97_110 sn_97 sn_110 122541.5859211521
Csub_97_110 sn_97 sn_110 8.598292100617642e-17
Rsub_97_195 sn_97 sn_195 21769.2721296518
Csub_97_195 sn_97 sn_195 4.840071564854168e-16
Rsub_97_129 sn_97 sn_129 548947.4227070621
Csub_97_129 sn_97 sn_129 1.919397571860474e-17
Rsub_97_166 sn_97 sn_166 3753380.076381079
Csub_97_166 sn_97 sn_166 2.807198655029104e-18
Rsub_97_99 sn_97 sn_99 524601.513388139
Csub_97_99 sn_97 sn_99 2.008473714492381e-17
Rsub_97_178 sn_97 sn_178 3184829.829481166
Csub_97_178 sn_97 sn_178 3.308334845616062e-18
Rsub_97_216 sn_97 sn_216 1662302.530027707
Csub_97_216 sn_97 sn_216 6.338487316177266e-18
Rsub_97_168 sn_97 sn_168 3480884.029512007
Csub_97_168 sn_97 sn_168 3.026956202188423e-18
Rsub_97_131 sn_97 sn_131 195676.0411590707
Csub_97_131 sn_97 sn_131 5.384656925711506e-17
Rsub_97_210 sn_97 sn_210 2609934.671259806
Csub_97_210 sn_97 sn_210 4.03706790758256e-18
Rsub_97_153 sn_97 sn_153 41324.32271379041
Csub_97_153 sn_97 sn_153 2.549705067208241e-16
Rsub_97_167 sn_97 sn_167 5396546.809629887
Csub_97_167 sn_97 sn_167 1.952449200186337e-18
Rsub_97_204 sn_97 sn_204 161407.2628168791
Csub_97_204 sn_97 sn_204 6.527886861066424e-17
Rsub_97_101 sn_97 sn_101 311460.7631318773
Csub_97_101 sn_97 sn_101 3.382924833382203e-17
Rsub_97_180 sn_97 sn_180 3088052.768333786
Csub_97_180 sn_97 sn_180 3.412015367831667e-18
Rsub_97_141 sn_97 sn_141 1337018.807908528
Csub_97_141 sn_97 sn_141 7.880579869113445e-18
Rsub_97_220 sn_97 sn_220 4375771.505680272
Csub_97_220 sn_97 sn_220 2.40791446458125e-18
Rsub_97_215 sn_97 sn_215 539229.7916207672
Csub_97_215 sn_97 sn_215 1.95398764422129e-17
Rsub_97_136 sn_97 sn_136 6209806.749215563
Csub_97_136 sn_97 sn_136 1.696749017763072e-18
Rsub_97_181 sn_97 sn_181 1358857.577280807
Csub_97_181 sn_97 sn_181 7.75392776873234e-18
Rsub_97_177 sn_97 sn_177 559474.2366097342
Csub_97_177 sn_97 sn_177 1.883283056263377e-17
Rsub_97_98 sn_97 sn_98 4775459.663594269
Csub_97_98 sn_97 sn_98 2.206381007163544e-18
Rsub_97_188 sn_97 sn_188 2607120.978590454
Csub_97_188 sn_97 sn_188 4.041424847084225e-18
Rsub_97_107 sn_97 sn_107 15659497.32902684
Csub_97_107 sn_97 sn_107 6.728494076690005e-19
Rsub_97_186 sn_97 sn_186 35147609.23335749
Csub_97_186 sn_97 sn_186 2.997780996219269e-19
Rsub_97_212 sn_97 sn_212 2093027.251327663
Csub_97_212 sn_97 sn_212 5.034088063376351e-18
Rsub_97_115 sn_97 sn_115 16783912.52316547
Csub_97_115 sn_97 sn_115 6.277727846643237e-19
Rsub_97_150 sn_97 sn_150 595914.5253702534
Csub_97_150 sn_97 sn_150 1.768119932247578e-17
Rsub_97_229 sn_97 sn_229 2521040.533979456
Csub_97_229 sn_97 sn_229 4.179418521922054e-18
Rsub_97_117 sn_97 sn_117 2339340.778034649
Csub_97_117 sn_97 sn_117 4.504039600028696e-18
Rsub_97_199 sn_97 sn_199 3014550.223072485
Csub_97_199 sn_97 sn_199 3.495209143170627e-18
Rsub_97_138 sn_97 sn_138 703148.4043646596
Csub_97_138 sn_97 sn_138 1.498472219637674e-17
Rsub_97_217 sn_97 sn_217 206318.8367226447
Csub_97_217 sn_97 sn_217 5.106893616502036e-17
Rsub_97_114 sn_97 sn_114 1292786.273157691
Csub_97_114 sn_97 sn_114 8.150213009683452e-18
Rsub_97_130 sn_97 sn_130 1365272.421063512
Csub_97_130 sn_97 sn_130 7.717495306923692e-18
Rsub_97_205 sn_97 sn_205 3822386.090024299
Csub_97_205 sn_97 sn_205 2.756519946985005e-18
Rsub_97_139 sn_97 sn_139 3659960.412267823
Csub_97_139 sn_97 sn_139 2.87885176760731e-18
Rsub_97_112 sn_97 sn_112 1410519.240725343
Csub_97_112 sn_97 sn_112 7.46993248869951e-18
Rsub_97_172 sn_97 sn_172 2824072.417498755
Csub_97_172 sn_97 sn_172 3.73095372375827e-18
Rsub_97_179 sn_97 sn_179 4329161.65104541
Csub_97_179 sn_97 sn_179 2.43383923991049e-18
Rsub_97_185 sn_97 sn_185 3935310.244995501
Csub_97_185 sn_97 sn_185 2.677421307666696e-18
Rsub_97_158 sn_97 sn_158 3599666.630699466
Csub_97_158 sn_97 sn_158 2.92707202727343e-18
Rsub_97_155 sn_97 sn_155 1064908.852286514
Csub_97_155 sn_97 sn_155 9.894258536405853e-18
Rsub_97_202 sn_97 sn_202 1660503.513087553
Csub_97_202 sn_97 sn_202 6.345354538057185e-18
Rsub_97_103 sn_97 sn_103 41530924.86455211
Csub_97_103 sn_97 sn_103 2.537021156305432e-19
Rsub_97_182 sn_97 sn_182 4438350.482691933
Csub_97_182 sn_97 sn_182 2.37396382807503e-18
Rsub_97_170 sn_97 sn_170 924687.7312197718
Csub_97_170 sn_97 sn_170 1.139463966752445e-17
Rsub_97_201 sn_97 sn_201 1757063.878852345
Csub_97_201 sn_97 sn_201 5.996642255893439e-18
Rsub_97_111 sn_97 sn_111 5587545.295581173
Csub_97_111 sn_97 sn_111 1.885708830058635e-18
Rsub_97_183 sn_97 sn_183 6083124.341961144
Csub_97_183 sn_97 sn_183 1.732084190610698e-18
Rsub_97_128 sn_97 sn_128 4415220.916249542
Csub_97_128 sn_97 sn_128 2.386400069688946e-18
Rsub_97_146 sn_97 sn_146 7878479.416591408
Csub_97_146 sn_97 sn_146 1.33737526559263e-18
Rsub_7_152 sn_7 sn_152 301256346.583188
Csub_7_152 sn_7 sn_152 3.497514200691036e-20
Rsub_7_79 sn_7 sn_79 115356587.5239828
Csub_7_79 sn_7 sn_79 9.133837718664705e-20
Rsub_7_136 sn_7 sn_136 136654894.6326634
Csub_7_136 sn_7 sn_136 7.710286214447501e-20
Rsub_7_134 sn_7 sn_134 149308940.9045915
Csub_7_134 sn_7 sn_134 7.056833595091146e-20
Rsub_7_77 sn_7 sn_77 52617546.72295
Csub_7_77 sn_7 sn_77 2.002465747350083e-19
Rsub_7_169 sn_7 sn_169 156030522.8501751
Csub_7_169 sn_7 sn_169 6.752834836263048e-20
Rsub_7_93 sn_7 sn_93 145780692.303895
Csub_7_93 sn_7 sn_93 7.227626193642714e-20
Rsub_7_38 sn_7 sn_38 96515649.13143392
Csub_7_38 sn_7 sn_38 1.091686539649289e-19
Rsub_7_20 sn_7 sn_20 189321225.1902729
Csub_7_20 sn_7 sn_20 5.565400018746208e-20
Rsub_7_87 sn_7 sn_87 395577864.5885946
Csub_7_87 sn_7 sn_87 2.663567516142002e-20
Rsub_7_115 sn_7 sn_115 97614501.12367709
Csub_7_115 sn_7 sn_115 1.079397362168591e-19
Rsub_7_190 sn_7 sn_190 75448832.1819859
Csub_7_190 sn_7 sn_190 1.396507168834044e-19
Rsub_7_88 sn_7 sn_88 298256211.6619894
Csub_7_88 sn_7 sn_88 3.532695410941143e-20
Rsub_7_180 sn_7 sn_180 171350499.3252769
Csub_7_180 sn_7 sn_180 6.149082461807397e-20
Rsub_7_118 sn_7 sn_118 395381540.5108696
Csub_7_118 sn_7 sn_118 2.664890092900111e-20
Rsub_7_85 sn_7 sn_85 130859539.3652881
Csub_7_85 sn_7 sn_85 8.051750413714901e-20
Rsub_7_158 sn_7 sn_158 53620055.11906006
Csub_7_158 sn_7 sn_158 1.965026607830668e-19
Rsub_7_17 sn_7 sn_17 109345038.3570182
Csub_7_17 sn_7 sn_17 9.635995981662874e-20
Rsub_7_22 sn_7 sn_22 310843696.637771
Csub_7_22 sn_7 sn_22 3.389640393611796e-20
Rsub_7_189 sn_7 sn_189 809654010.048943
Csub_7_189 sn_7 sn_189 1.301356304230875e-20
Rsub_7_147 sn_7 sn_147 404827005.0244715
Csub_7_147 sn_7 sn_147 2.60271260846175e-20
Rsub_7_194 sn_7 sn_194 225253559.9497622
Csub_7_194 sn_7 sn_194 4.677610202733281e-20
Rsub_7_27 sn_7 sn_27 342597831.9688372
Csub_7_27 sn_7 sn_27 3.075467069268671e-20
Rsub_7_54 sn_7 sn_54 404827005.0244715
Csub_7_54 sn_7 sn_54 2.60271260846175e-20
Rsub_7_103 sn_7 sn_103 366682552.6096577
Csub_7_103 sn_7 sn_103 2.87346191610222e-20
Rsub_7_106 sn_7 sn_106 198600495.9341589
Csub_7_106 sn_7 sn_106 5.305366158664133e-20
Rsub_7_157 sn_7 sn_157 47657790.4681754
Csub_7_157 sn_7 sn_157 2.210862777884339e-19
Rsub_7_112 sn_7 sn_112 297876277.6554986
Csub_7_112 sn_7 sn_112 3.537201278718713e-20
Rsub_7_75 sn_7 sn_75 75976207.64621989
Csub_7_75 sn_7 sn_75 1.386813560278332e-19
Rsub_7_120 sn_7 sn_120 130944794.0607101
Csub_7_120 sn_7 sn_120 8.046508131774187e-20
Rsub_7_68 sn_7 sn_68 121904205.8684304
Csub_7_68 sn_7 sn_68 8.64324854681543e-20
Rsub_7_124 sn_7 sn_124 404827005.0244715
Csub_7_124 sn_7 sn_124 2.60271260846175e-20
Rsub_7_135 sn_7 sn_135 128963720.5879299
Csub_7_135 sn_7 sn_135 8.170114396665553e-20
Rsub_7_230 sn_7 0 1502909.632218736
Csub_7_230 sn_7 0 7.010723250655504e-18
Rsub_7_126 sn_7 sn_126 320407568.0484961
Csub_7_126 sn_7 sn_126 3.288462743375408e-20
Rsub_7_172 sn_7 sn_172 217579067.1824478
Csub_7_172 sn_7 sn_172 4.842599813793109e-20
Rsub_7_148 sn_7 sn_148 134164609.7713929
Csub_7_148 sn_7 sn_148 7.853400028653932e-20
Rsub_7_80 sn_7 sn_80 399364179.3341631
Csub_7_80 sn_7 sn_80 2.638314612942221e-20
Rsub_7_125 sn_7 sn_125 91997485.92720282
Csub_7_125 sn_7 sn_125 1.145301243402181e-19
Rsub_7_18 sn_7 sn_18 29262623.74629647
Csub_7_18 sn_7 sn_18 3.600662604139698e-19
Rsub_7_122 sn_7 sn_122 290348642.0887286
Csub_7_122 sn_7 sn_122 3.628907449482791e-20
Rsub_7_84 sn_7 sn_84 182397797.7507239
Csub_7_84 sn_7 sn_84 5.776650613199732e-20
Rsub_7_151 sn_7 sn_151 418616521.6371003
Csub_7_151 sn_7 sn_151 2.516977462099335e-20
Rsub_7_200 sn_7 sn_200 126710233.80376
Csub_7_200 sn_7 sn_200 8.315416352674538e-20
Rsub_7_154 sn_7 sn_154 161406038.0839175
Csub_7_154 sn_7 sn_154 6.527936394022584e-20
Rsub_7_12 sn_7 sn_12 16908285.67478124
Csub_7_12 sn_7 sn_12 6.231550439170306e-19
Rsub_7_166 sn_7 sn_166 404827005.0244715
Csub_7_166 sn_7 sn_166 2.60271260846175e-20
Rsub_7_25 sn_7 sn_25 125497789.1191088
Csub_7_25 sn_7 sn_25 8.395752288695638e-20
Rsub_7_35 sn_7 sn_35 41256943.94596103
Csub_7_35 sn_7 sn_35 2.553869117409871e-19
Rsub_7_202 sn_7 sn_202 52340269.01252487
Csub_7_202 sn_7 sn_202 2.013074006117289e-19
Rsub_7_155 sn_7 sn_155 35134537.12007125
Csub_7_155 sn_7 sn_155 2.998896346982422e-19
Rsub_7_62 sn_7 sn_62 404827005.0244715
Csub_7_62 sn_7 sn_62 2.60271260846175e-20
Rsub_7_229 sn_7 sn_229 98120928.33259995
Csub_7_229 sn_7 sn_229 1.073826316289481e-19
Rsub_7_131 sn_7 sn_131 6779525.854323482
Csub_7_131 sn_7 sn_131 1.554162301115882e-18
Rsub_7_130 sn_7 sn_130 53888715.08707141
Csub_7_130 sn_7 sn_130 1.955230048667061e-19
Rsub_7_209 sn_7 sn_209 76066882.05158211
Csub_7_209 sn_7 sn_209 1.385160429618379e-19
Rsub_7_218 sn_7 sn_218 404827005.0244715
Csub_7_218 sn_7 sn_218 2.60271260846175e-20
Rsub_7_51 sn_7 sn_51 22034900.27850429
Csub_7_51 sn_7 sn_51 4.781725067532373e-19
Rsub_7_127 sn_7 sn_127 72516449.19421458
Csub_7_127 sn_7 sn_127 1.45297840963104e-19
Rsub_7_139 sn_7 sn_139 52493742.5672181
Csub_7_139 sn_7 sn_139 2.007188473700092e-19
Rsub_7_177 sn_7 sn_177 14790166.83323729
Csub_7_177 sn_7 sn_177 7.123978803641232e-19
Rsub_7_153 sn_7 sn_153 15179649.72520227
Csub_7_153 sn_7 sn_153 6.941190141388196e-19
Rsub_7_133 sn_7 sn_133 16621541.65231272
Csub_7_133 sn_7 sn_133 6.339053093046851e-19
Rsub_7_45 sn_7 sn_45 79039705.93057197
Csub_7_45 sn_7 sn_45 1.333062082934011e-19
Rsub_7_212 sn_7 sn_212 49867067.64745815
Csub_7_212 sn_7 sn_212 2.112914193535315e-19
Rsub_7_101 sn_7 sn_101 2063248.65619847
Csub_7_101 sn_7 sn_101 5.106744390975852e-18
Rsub_7_141 sn_7 sn_141 31789438.18539788
Csub_7_141 sn_7 sn_141 3.314460432040544e-19
Rsub_7_67 sn_7 sn_67 1109143.370860144
Csub_7_67 sn_7 sn_67 9.499658726769407e-18
Rsub_7_208 sn_7 sn_208 407001935.2090585
Csub_7_208 sn_7 sn_208 2.588804276033205e-20
Rsub_7_41 sn_7 sn_41 434885.8117437515
Csub_7_41 sn_7 sn_41 2.42281610889583e-17
Rsub_7_83 sn_7 sn_83 148051942.1257023
Csub_7_83 sn_7 sn_83 7.116747913569474e-20
Rsub_7_213 sn_7 sn_213 407001935.2090585
Csub_7_213 sn_7 sn_213 2.588804276033205e-20
Rsub_7_46 sn_7 sn_46 655764.5863027493
Csub_7_46 sn_7 sn_46 1.606747866888558e-17
Rsub_7_204 sn_7 sn_204 2957062.394442215
Csub_7_204 sn_7 sn_204 3.563159006057253e-18
Rsub_7_145 sn_7 sn_145 146747471.3743016
Csub_7_145 sn_7 sn_145 7.180010260861742e-20
Rsub_7_15 sn_7 sn_15 271162385.4575747
Csub_7_15 sn_7 sn_15 3.8856729647256e-20
Rsub_7_182 sn_7 sn_182 12327977.30911146
Csub_7_182 sn_7 sn_182 8.546806372236437e-19
Rsub_7_110 sn_7 sn_110 3718487.880224308
Csub_7_110 sn_7 sn_110 2.833539826300151e-18
Rsub_7_99 sn_7 sn_99 229155.9076414026
Csub_7_99 sn_7 sn_99 4.597954122447563e-17
Rsub_7_160 sn_7 sn_160 71137038.51084554
Csub_7_160 sn_7 sn_160 1.481152958120911e-19
Rsub_7_128 sn_7 sn_128 40687407.80296285
Csub_7_128 sn_7 sn_128 2.589617788691551e-19
Rsub_7_210 sn_7 sn_210 120536361.109658
Csub_7_210 sn_7 sn_210 8.741331997441361e-20
Rsub_7_43 sn_7 sn_43 5297336.055639783
Csub_7_43 sn_7 sn_43 1.989015496008109e-18
Rsub_7_34 sn_7 sn_34 11940157.73472949
Csub_7_34 sn_7 sn_34 8.824408970396833e-19
Rsub_7_201 sn_7 sn_201 62907687.1609176
Csub_7_201 sn_7 sn_201 1.674911918996119e-19
Rsub_7_78 sn_7 sn_78 841640.1297431915
Csub_7_78 sn_7 sn_78 1.251898897150375e-17
Rsub_7_61 sn_7 sn_61 2442576.122240362
Csub_7_61 sn_7 sn_61 4.313676616377385e-18
Rsub_7_140 sn_7 sn_140 404827005.0244715
Csub_7_140 sn_7 sn_140 2.60271260846175e-20
Rsub_7_52 sn_7 sn_52 662744.0867909628
Csub_7_52 sn_7 sn_52 1.589826859602495e-17
Rsub_7_219 sn_7 sn_219 9011689.816009041
Csub_7_219 sn_7 sn_219 1.169201749877387e-18
Rsub_7_188 sn_7 sn_188 39824881.4381744
Csub_7_188 sn_7 sn_188 2.645703671105016e-19
Rsub_7_159 sn_7 sn_159 818120061.4410805
Csub_7_159 sn_7 sn_159 1.287889638553842e-20
Rsub_7_178 sn_7 sn_178 27337683.7848149
Csub_7_178 sn_7 sn_178 3.854197592292964e-19
Rsub_7_11 sn_7 sn_11 3950844.597239013
Csub_7_11 sn_7 sn_11 2.66689393695547e-18
Rsub_7_76 sn_7 sn_76 82246.72650895755
Csub_7_76 sn_7 sn_76 1.281082415004379e-16
Rsub_7_206 sn_7 sn_206 17317376.46707981
Csub_7_206 sn_7 sn_206 6.084341656635905e-19
Rsub_7_39 sn_7 sn_39 118326931.6061736
Csub_7_39 sn_7 sn_39 8.904552293554339e-20
Rsub_7_72 sn_7 sn_72 9285514.194056218
Csub_7_72 sn_7 sn_72 1.134722674698462e-18
Rsub_7_129 sn_7 sn_129 905878.1684512646
Csub_7_129 sn_7 sn_129 1.163123681437616e-17
Rsub_7_50 sn_7 sn_50 4757251.529464263
Csub_7_50 sn_7 sn_50 2.214825816329406e-18
Rsub_7_117 sn_7 sn_117 781822.234007234
Csub_7_117 sn_7 sn_117 1.347682765201649e-17
Rsub_7_196 sn_7 sn_196 380449376.0722967
Csub_7_196 sn_7 sn_196 2.769483711869133e-20
Rsub_7_28 sn_7 sn_28 25430941.3283147
Csub_7_28 sn_7 sn_28 4.143174790977448e-19
Rsub_7_195 sn_7 sn_195 8056609.575694954
Csub_7_195 sn_7 sn_195 1.307806143916455e-18
Rsub_7_170 sn_7 sn_170 152209992.0001502
Csub_7_170 sn_7 sn_170 6.922333654823137e-20
Rsub_7_49 sn_7 sn_49 13949399.44666304
Csub_7_49 sn_7 sn_49 7.553359943929722e-19
Rsub_7_216 sn_7 sn_216 90089447.12635824
Csub_7_216 sn_7 sn_216 1.16955801576312e-19
Rsub_7_137 sn_7 sn_137 126000802.3122992
Csub_7_137 sn_7 sn_137 8.362235246815976e-20
Rsub_7_31 sn_7 sn_31 407001935.2090585
Csub_7_31 sn_7 sn_31 2.588804276033205e-20
Rsub_7_198 sn_7 sn_198 37911337.69968874
Csub_7_198 sn_7 sn_198 2.779243398292566e-19
Rsub_7_55 sn_7 sn_55 227014379.4890094
Csub_7_55 sn_7 sn_55 4.641328679683972e-20
Rsub_7_222 sn_7 sn_222 2353923.996757573
Csub_7_222 sn_7 sn_222 4.476135812687047e-18
Rsub_7_220 sn_7 sn_220 239708860.9702716
Csub_7_220 sn_7 sn_220 4.395533590031419e-20
Rsub_7_53 sn_7 sn_53 23929558.95764537
Csub_7_53 sn_7 sn_53 4.403124821848691e-19
Rsub_7_44 sn_7 sn_44 42516450.35473752
Csub_7_44 sn_7 sn_44 2.478213353729786e-19
Rsub_7_211 sn_7 sn_211 134942335.0081572
Csub_7_211 sn_7 sn_211 7.808137825385251e-20
Rsub_7_97 sn_7 sn_97 2037696.813400769
Csub_7_97 sn_7 sn_97 5.170780772162748e-18
Rsub_7_60 sn_7 sn_60 89519337.07011147
Csub_7_60 sn_7 sn_60 1.177006426441455e-19
Rsub_7_227 sn_7 sn_227 47398424.18078229
Csub_7_227 sn_7 sn_227 2.222960717437104e-19
Rsub_7_65 sn_7 sn_65 116708031.6176056
Csub_7_65 sn_7 sn_65 9.028070610215446e-20
Rsub_7_163 sn_7 sn_163 71068450.14258353
Csub_7_163 sn_7 sn_163 1.482582423155538e-19
Rsub_7_48 sn_7 sn_48 817401.2523070833
Csub_7_48 sn_7 sn_48 1.28902218738853e-17
Rsub_7_215 sn_7 sn_215 2052128.495850794
Csub_7_215 sn_7 sn_215 5.1344170326243e-18
Rsub_7_59 sn_7 sn_59 304159085.0849537
Csub_7_59 sn_7 sn_59 3.464135716770417e-20
Rsub_7_226 sn_7 sn_226 53963497.79971604
Csub_7_226 sn_7 sn_226 1.952520487336802e-19
Rsub_7_14 sn_7 sn_14 43461550.10244292
Csub_7_14 sn_7 sn_14 2.424322988341311e-19
Rsub_7_181 sn_7 sn_181 13576862.82278886
Csub_7_181 sn_7 sn_181 7.760617190993811e-19
Rsub_7_86 sn_7 sn_86 341253155.207563
Csub_7_86 sn_7 sn_86 3.087585665199583e-20
Rsub_7_175 sn_7 sn_175 84541950.26591869
Csub_7_175 sn_7 sn_175 1.246302394147342e-19
Rsub_7_105 sn_7 sn_105 6218626.250868613
Csub_7_105 sn_7 sn_105 1.69434262121128e-18
Rsub_7_150 sn_7 sn_150 694920461.6944071
Csub_7_150 sn_7 sn_150 1.516214312719927e-20
Rsub_7_214 sn_7 sn_214 197076897.0181901
Csub_7_214 sn_7 sn_214 5.346381875120293e-20
Rsub_7_47 sn_7 sn_47 18225647.22626278
Csub_7_47 sn_7 sn_47 5.781129949145041e-19
Rsub_7_191 sn_7 sn_191 108858145.7588957
Csub_7_191 sn_7 sn_191 9.679095146050639e-20
Rsub_7_203 sn_7 sn_203 203500967.6045293
Csub_7_203 sn_7 sn_203 5.17760855206641e-20
Rsub_126_193 sn_126 sn_193 15306844.43860572
Csub_126_193 sn_126 sn_193 6.883511192976986e-19
Rsub_126_216 sn_126 sn_216 341681.1620060073
Csub_126_216 sn_126 sn_216 3.083718002002333e-17
Rsub_126_137 sn_126 sn_137 10201044.79470319
Csub_126_137 sn_126 sn_137 1.032882779585576e-18
Rsub_126_127 sn_126 sn_127 2141267.855467776
Csub_126_127 sn_126 sn_127 4.920675138948569e-18
Rsub_126_206 sn_126 sn_206 3377441.194091239
Csub_126_206 sn_126 sn_206 3.119664532031929e-18
Rsub_126_208 sn_126 sn_208 4652923.753728666
Csub_126_208 sn_126 sn_208 2.264486602383391e-18
Rsub_126_129 sn_126 sn_129 4028284.166554804
Csub_126_129 sn_126 sn_129 2.615625677480778e-18
Rsub_126_130 sn_126 sn_130 1297506.126317646
Csub_126_130 sn_126 sn_130 8.120565512960464e-18
Rsub_126_209 sn_126 sn_209 20373572.21985415
Csub_126_209 sn_126 sn_209 5.17164264986488e-19
Rsub_126_202 sn_126 sn_202 2838172.953020489
Csub_126_202 sn_126 sn_202 3.712417698511532e-18
Rsub_126_128 sn_126 sn_128 1675642.266724826
Csub_126_128 sn_126 sn_128 6.288026813040698e-18
Rsub_126_133 sn_126 sn_133 93669295.82367648
Csub_126_133 sn_126 sn_133 1.124859903085417e-19
Rsub_126_212 sn_126 sn_212 2582941.271138945
Csub_126_212 sn_126 sn_212 4.079257867750107e-18
Rsub_126_180 sn_126 sn_180 492951.4320267519
Csub_126_180 sn_126 sn_180 2.137428318021033e-17
Rsub_126_217 sn_126 sn_217 10211815.06842812
Csub_126_217 sn_126 sn_217 1.031793411026964e-18
Rsub_126_138 sn_126 sn_138 3248948.275090935
Csub_126_138 sn_126 sn_138 3.243044397785955e-18
Rsub_126_229 sn_126 sn_229 2963602.777744772
Csub_126_229 sn_126 sn_229 3.555295460428743e-18
Rsub_126_150 sn_126 sn_150 57414.76156037885
Csub_126_150 sn_126 sn_150 1.835152357316604e-16
Rsub_126_198 sn_126 sn_198 1428763.025780911
Csub_126_198 sn_126 sn_198 7.374549391401793e-18
Rsub_126_139 sn_126 sn_139 1375912.190533672
Csub_126_139 sn_126 sn_139 7.657816810346912e-18
Rsub_126_176 sn_126 sn_176 177244.8031843065
Csub_126_176 sn_126 sn_176 5.944593755605757e-17
Rsub_126_230 sn_126 0 54536.16625306632
Csub_126_230 sn_126 0 1.932017636395111e-16
Rsub_126_151 sn_126 sn_151 4443265.503437228
Csub_126_151 sn_126 sn_151 2.371337813164479e-18
Rsub_126_156 sn_126 sn_156 13343941.79792422
Csub_126_156 sn_126 sn_156 7.896080230107908e-19
Rsub_126_132 sn_126 sn_132 542606.8631176348
Csub_126_132 sn_126 sn_132 1.941826434278945e-17
Rsub_126_211 sn_126 sn_211 24340182.37922355
Csub_126_211 sn_126 sn_211 4.32884328394507e-19
Rsub_126_188 sn_126 sn_188 7433915.198411499
Csub_126_188 sn_126 sn_188 1.41735320097295e-18
Rsub_126_135 sn_126 sn_135 289949.5236537869
Csub_126_135 sn_126 sn_135 3.633902677078045e-17
Rsub_126_214 sn_126 sn_214 1947614.547673506
Csub_126_214 sn_126 sn_214 5.409942904162531e-18
Rsub_126_140 sn_126 sn_140 413032.5399763622
Csub_126_140 sn_126 sn_140 2.551005667212807e-17
Rsub_126_219 sn_126 sn_219 73075.09820855928
Csub_126_219 sn_126 sn_219 1.441870590739194e-16
Rsub_126_177 sn_126 sn_177 169887.4058520737
Csub_126_177 sn_126 sn_177 6.202039197304859e-17
Rsub_126_228 sn_126 sn_228 24920.71857461636
Csub_126_228 sn_126 sn_228 4.228001480247125e-16
Rsub_126_195 sn_126 sn_195 64131.13369339598
Csub_126_195 sn_126 sn_195 1.642959183070705e-16
Rsub_126_162 sn_126 sn_162 2897530.433121467
Csub_126_162 sn_126 sn_162 3.636366811470967e-18
Rsub_126_153 sn_126 sn_153 26865.54802932882
Csub_126_153 sn_126 sn_153 3.921931348925932e-16
Rsub_126_190 sn_126 sn_190 1165104.623063682
Csub_126_190 sn_126 sn_190 9.043379704840552e-18
Rsub_126_141 sn_126 sn_141 472902.4895953398
Csub_126_141 sn_126 sn_141 2.228045682577399e-17
Rsub_126_220 sn_126 sn_220 2336912.65004261
Csub_126_220 sn_126 sn_220 4.508719443166985e-18
Rsub_126_222 sn_126 sn_222 90015.25812905945
Csub_126_222 sn_126 sn_222 1.170521944971075e-16
Rsub_126_227 sn_126 sn_227 1699619.97154013
Csub_126_227 sn_126 sn_227 6.199317305434016e-18
Rsub_126_131 sn_126 sn_131 76376.91415104024
Csub_126_131 sn_126 sn_131 1.379537733272836e-16
Rsub_126_210 sn_126 sn_210 27674.63105665541
Csub_126_210 sn_126 sn_210 3.807271533506535e-16
Rsub_126_168 sn_126 sn_168 160222.1743429001
Csub_126_168 sn_126 sn_168 6.576170586525874e-17
Rsub_126_152 sn_126 sn_152 3196488.332433168
Csub_126_152 sn_126 sn_152 3.29626840658906e-18
Rsub_126_215 sn_126 sn_215 1205856.317660025
Csub_126_215 sn_126 sn_215 8.737760335058941e-18
Rsub_126_157 sn_126 sn_157 2042422.406385437
Csub_126_157 sn_126 sn_157 5.158817034756718e-18
Rsub_126_169 sn_126 sn_169 799166.9950724753
Csub_126_169 sn_126 sn_169 1.318433264536214e-17
Rsub_126_179 sn_126 sn_179 1409188.101691298
Csub_126_179 sn_126 sn_179 7.476988692697719e-18
Rsub_126_182 sn_126 sn_182 6214989.361732809
Csub_126_182 sn_126 sn_182 1.695334117079214e-18
Rsub_126_191 sn_126 sn_191 6573932.569561322
Csub_126_191 sn_126 sn_191 1.602767200718808e-18
Rsub_126_189 sn_126 sn_189 3526759.883785079
Csub_126_189 sn_126 sn_189 2.987581760434954e-18
Rsub_126_199 sn_126 sn_199 3650786.518681985
Csub_126_199 sn_126 sn_199 2.88608590184942e-18
Rsub_126_165 sn_126 sn_165 1910691.395165934
Csub_126_165 sn_126 sn_165 5.514487336305277e-18
Rsub_126_155 sn_126 sn_155 553911.1443071351
Csub_126_155 sn_126 sn_155 1.90219742110617e-17
Rsub_126_145 sn_126 sn_145 46974704.95770542
Csub_126_145 sn_126 sn_145 2.243012172554725e-19
Rsub_126_158 sn_126 sn_158 2516885.363353762
Csub_126_158 sn_126 sn_158 4.186318397986186e-18
Rsub_126_185 sn_126 sn_185 6857608.25330054
Csub_126_185 sn_126 sn_185 1.536466230359373e-18
Rsub_126_221 sn_126 sn_221 2491692.166594567
Csub_126_221 sn_126 sn_221 4.228645754676178e-18
Rsub_126_200 sn_126 sn_200 13268981.95947632
Csub_126_200 sn_126 sn_200 7.940687186408564e-19
Rsub_126_144 sn_126 sn_144 10186786.10992707
Csub_126_144 sn_126 sn_144 1.034328529972976e-18
Rsub_126_226 sn_126 sn_226 2576062.01790685
Csub_126_226 sn_126 sn_226 4.090151335250579e-18
Rsub_126_197 sn_126 sn_197 4274482.399907283
Csub_126_197 sn_126 sn_197 2.464972952621947e-18
Rsub_126_166 sn_126 sn_166 47823794.75741958
Csub_126_166 sn_126 sn_166 2.203188508079512e-19
Rsub_126_159 sn_126 sn_159 1848190.035318809
Csub_126_159 sn_126 sn_159 5.7009740886372e-18
Rsub_126_183 sn_126 sn_183 9310772.562390348
Csub_126_183 sn_126 sn_183 1.131644386287638e-18
Rsub_126_164 sn_126 sn_164 30231529.56576014
Csub_126_164 sn_126 sn_164 3.485263118861009e-19
Rsub_126_184 sn_126 sn_184 24674646.53859004
Csub_126_184 sn_126 sn_184 4.270165931557079e-19
Rsub_126_225 sn_126 sn_225 11187944.44996905
Csub_126_225 sn_126 sn_225 9.417711671118596e-19
Rsub_126_160 sn_126 sn_160 5845002.468754135
Csub_126_160 sn_126 sn_160 1.802648255249729e-18

.DC V7 0 0.7 0.1
.PLOT V(n1_145)
