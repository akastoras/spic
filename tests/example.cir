* Given example

* Voltage Sources
V1 5 0 2
V_source2 3 2 0.2
Vsource_1 7 6 2

* Current Sources
I1 4 8 1e-3
I2 0 6 1e-3

* Resistors
R1 1 5 1.5
R2 1 2 1
R3 5 2 50
R4 5 6 0.1
R5 2 6 1.5
R6 3 4 0.1
R7 8 0 1e3
R8 4 0 10
