R2 1 2 4
R1 2 0 2
I1 0 2 2
V1 1 0 3
