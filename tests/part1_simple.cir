* SPICE netlist of Part1-Parser.pdf

V1 5 0 2
V2 3 2 0.2
V3 7 6 2
I1 4 8 1e-3
I2 0 6 1e-3
R1 1 5 1.5 -> 0.66667
R2 1 2 1 -> 1
R3 5 2 50 -> 0.02
R4 5 6 0.1 -> 10
R5 2 6 1.5 -> 0.66667
R6 3 4 0.1 -> 10
R7 8 0 1e3 -> 0.001
R8 4 0 10 -> 0.1

L1 1 2 0.2
C1 4 8 1e-6
